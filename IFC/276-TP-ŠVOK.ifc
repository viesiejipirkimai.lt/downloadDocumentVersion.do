Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcFlowFitting: M_Tee - Generic:Standard (58)
Name (M_Tee - Generic:Standard:...) | In | Group
1211389 | Level 1 | Hydronic Return 1
1211393 | Level 1 | Hydronic Return 1
1212605 | 3A vėdinimas | Hydronic Return 1
1212636 | 3A vėdinimas | Hydronic Return 1
1212690 | 3A vėdinimas | Hydronic Return 1
1217105 | Level 1 | Hydronic Return 1
1229239 | Level 1 | Hydronic Supply 1
1229493 | Level 1 | Hydronic Return 2
1243358 | Level 1 | Baseino term. 2
1243919 | Level 1 | Baseino term. 2
1244144 | Level 1 | Baseino term. 2
1244327 | Level 1 | Baseino term. 2
1244411 | Level 1 | Baseino term. 2
1244493 | Level 1 | Baseino term. 2
1244561 | Level 1 | Baseino term. 2
1258994 | Level 1 | AHU 2
1259654 | Level 1 | AHU 2
1260182 | Level 1 | AHU 2
1260222 | Level 1 | AHU 2
1269821 | Level 1 | Baseino term. 2
1269865 | Level 1 | Baseino term. 2
1271820 | Level 1 | Baseino term. 2
1271833 | Level 1 | Baseino term. 2
1272575 | Level 1 | Baseino term. 2
1272594 | Level 1 | Baseino term. 2
1272613 | Level 1 | Baseino term. 2
1272902 | Level 1 | Baseino term. 2
1272919 | Level 1 | Baseino term. 2
1272936 | Level 1 | Baseino term. 2
1273001 | Level 1 | Baseino term. 2
1273162 | Level 1 | Baseino term. 2
1282686 | Level 1 | Baseino term. 2
1286576 | Level 1 | Hydronic Supply 1
1286851 | Level 1 | Hydronic Return 2

# IfcFlowFitting: M_Transition - Generic:Standard (81)
Type - Material: <Unnamed>
Name (M_Transition - Generic:Standard:...) | In | Group
1096204 | Level 1 | Hydronic Return 1
1096264 | Level 1 | Hydronic Return 1
1097086 | 3A vėdinimas | Hydronic Return 1
1097111 | Level 1 | Hydronic Return 1
1098322 | Level 1 | Hydronic Return 1
1145489 | Level 1 | Hydronic Return 1
1179624 | 3A vėdinimas | Hydronic Return 4
1179686 | 3A vėdinimas | VRF 2
1203222 | Level 1 | Hydronic Return 1
1207831 | Level 1 | Hydronic Return 1
1209853 | Level 1 | Hydronic Return 1
1210298 | Level 1 | Hydronic Return 1
1210300 | 3A vėdinimas | Hydronic Return 1
1211064 | Level 1 | Hydronic Return 1
1212603 | Level 1 | Hydronic Return 1
1212634 | Level 1 | Hydronic Return 1
1227535 | 3A vėdinimas | Hydronic Supply 1
1227538 | 3A vėdinimas | Hydronic Return 2
1227742 | Level 1 | Hydronic Supply 1
1227745 | Level 1 | Hydronic Return 2
1227752 | Level 1 | Hydronic Supply 1
1227755 | Level 1 | Hydronic Return 2
1227788 | Level 1 | Hydronic Supply 1
1227791 | Level 1 | Hydronic Return 2
1227834 | Level 2 | Hydronic Supply 2
1227837 | Level 2 | Hydronic Return 3
1227874 | Level 2 | Hydronic Supply 2
1227877 | Level 2 | Hydronic Return 3
1227886 | Level 2 | Hydronic Supply 2
1227889 | Level 2 | Hydronic Supply 2
1227892 | Level 2 | Hydronic Return 3
1227895 | Level 2 | Hydronic Return 3
1227912 | Level 1 | Hydronic Supply 2
1227915 | Level 1 | Hydronic Supply 2
1227918 | Level 1 | Hydronic Return 3
1227921 | Level 1 | Hydronic Return 3
1227967 | Level 1 | Hydronic Return 3
1227997 | Level 1 | Hydronic Supply 2
1228336 | Level 2 | Hydronic Return 2
1228360 | Level 2 | Hydronic Supply 1
1228460 | Level 2 | Hydronic Return 2
1228626 | Level 2 | Hydronic Supply 1
1229393 | Level 2 | Hydronic Return 2
1229419 | Level 2 | Hydronic Supply 1
1260190 | Level 1 | AHU 2
1260230 | Level 1 | AHU 2
1260610 | 3A vėdinimas | Hydronic Return 1
1271964 | Level 1 | Baseino term. 2
1271977 | Level 1 | Baseino term. 2
1271980 | Level 1 | Baseino term. 2
1271983 | Level 1 | Baseino term. 2
1271986 | Level 1 | Baseino term. 2
1271989 | Level 1 | Baseino term. 2
1271995 | Level 1 | Baseino term. 2
1272001 | Level 1 | Baseino term. 2
1272004 | Level 1 | Baseino term. 2
1273010 | Level 1 | Baseino term. 2
1273171 | Level 1 | Baseino term. 2
1282692 | Level 1 | Baseino term. 2
1282742 | Level 1 | Baseino term. 2
1282770 | Level 1 | Baseino term. 2
1282940 | Level 1 | Baseino term. 2
1282944 | Level 1 | Baseino term. 2
1286234 | Level 1 | Baseino term. 2
1286237 | Level 1 | Baseino term. 2
1286240 | Level 1 | Baseino term. 2
1286243 | Level 1 | Baseino term. 2
1287020 | Level 1 | Hydronic Supply 1
1287023 | Level 1 | Hydronic Return 2
1287026 | Level 1 | Hydronic Supply 1
1287029 | Level 1 | Hydronic Supply 1
1287032 | Level 1 | Hydronic Return 2
1287035 | Level 1 | Hydronic Return 2
1287106 | Level 1 | Hydronic Supply 1
1287109 | Level 1 | Hydronic Supply 1
1287112 | Level 1 | Hydronic Return 2
1287115 | Level 1 | Hydronic Return 2
1287124 | Level 1 | Hydronic Supply 1
1287127 | Level 1 | Hydronic Supply 1
1287130 | Level 1 | Hydronic Return 2
1287133 | Level 1 | Hydronic Return 2

# IfcFlowSegment: Pipe Types:Standard (358)
Name (Pipe Types:Standard:...) | In | Group
1096093 | Level 1 | Hydronic Return 1
1096254 | Level 1 | Hydronic Return 1
1096348 | Level 1 | Hydronic Return 1
1096354 | Level 1 | Hydronic Return 1
1096422 | Level 2 | Hydronic Return 1
1096562 | Level 1 | Hydronic Return 1
1097074 | 3A vėdinimas | Hydronic Return 1
1097161 | 3A vėdinimas | Hydronic Return 1
1097165 | 3A vėdinimas | Hydronic Return 1
1097169 | 3A vėdinimas | Hydronic Return 1
1097238 | 3A vėdinimas | Hydronic Return 1
1097429 | Level 2 | Hydronic Return 1
1097556 | Level 2 | Hydronic Return 1
1097981 | 3A vėdinimas | Hydronic Return 1
1098009 | 3A vėdinimas | Hydronic Return 1
1098162 | 3A vėdinimas | Hydronic Return 1
1098232 | 3A vėdinimas | Hydronic Return 1
1098339 | 3A vėdinimas | Hydronic Return 1
1098348 | 3A vėdinimas | Hydronic Return 1
1104555 | Level 1 | Hydronic Supply 1
1104569 | Level 1 | Hydronic Supply 1
1104579 | Level 1 | Hydronic Supply 1
1104626 | Level 1 | Hydronic Return 2
1104634 | Level 1 | Hydronic Return 2
1104644 | Level 1 | Hydronic Return 2
1108212 | Level 1 | Hydronic Supply 1
1108220 | Level 1 | Hydronic Supply 1
1108232 | Level 1 | Hydronic Supply 1
1108301 | Level 1 | Hydronic Return 2
1108311 | Level 1 | Hydronic Return 2
1108477 | Level 1 | Hydronic Supply 1
1108487 | Level 1 | Hydronic Supply 1
1108497 | Level 1 | Hydronic Supply 1
1108561 | Level 1 | Hydronic Return 2
1108571 | Level 1 | Hydronic Return 2
1113039 | Level 2 | Hydronic Supply 1
1113130 | Level 2 | Hydronic Return 2
1115015 | Level 2 | Hydronic Supply 1
1115053 | Level 1 | Hydronic Supply 1
1115115 | Level 1 | Hydronic Supply 1
1116019 | Level 2 | Hydronic Supply 2
1116029 | Level 2 | Hydronic Supply 2
1116086 | Level 2 | Hydronic Return 3
1116094 | Level 2 | Hydronic Return 3
1116182 | Level 1 | Hydronic Supply 2
1116192 | Level 1 | Hydronic Supply 2
1116249 | Level 1 | Hydronic Return 3
1116259 | Level 1 | Hydronic Return 3
1116269 | Level 2 | Hydronic Return 3
1116330 | Level 2 | Hydronic Supply 2
1116478 | Level 2 | Hydronic Supply 2
1116500 | Level 2 | Hydronic Supply 2
1116510 | Level 2 | Hydronic Supply 2
1117075 | Level 2 | Hydronic Return 3
1117422 | Level 2 | Hydronic Return 3
1117511 | Level 1 | Hydronic Return 3
1117617 | Level 1 | Hydronic Return 2
1118096 | Level 1 | Hydronic Supply 1
1118167 | Level 1 | Hydronic Supply 1
1118252 | Level 2 | Hydronic Return 2
1118254 | Level 1 | Hydronic Return 2
1118258 | Level 1 | Hydronic Return 2
1118302 | Level 1 | Hydronic Return 2
1118312 | Level 1 | Hydronic Return 2
1118339 | Level 1 | Hydronic Return 2
1118563 | Level 1 | Hydronic Supply 1
1118829 | Level 2 | Hydronic Return 2
1119909 | Level 2 | Hydronic Return 3
1119934 | Level 2 | Hydronic Supply 2
1120063 | Level 2 | Hydronic Supply 2
1120066 | Level 1 | Hydronic Supply 2
1120108 | Level 2 | Hydronic Return 3
1120118 | Level 2 | Hydronic Return 3
1120129 | Level 1 | Hydronic Return 3
1120157 | Level 1 | Hydronic Supply 1
1120187 | Level 1 | Hydronic Return 3
1120196 | Level 1 | Hydronic Return 3; Hydronic Return 2
1120224 | Level 2 | Hydronic Supply 2
1120271 | Level 1 | Hydronic Supply 2
1120336 | Level 1 | Hydronic Supply 2; Hydronic Supply 1
1120348 | Level 1 | Hydronic Supply 2
1120370 | Level 1 | Hydronic Return 3
1140125 | Level 1 | VRF 2
1140194 | Level 1 | VRF 2
1140204 | Level 1 | VRF 2
1140227 | Level 1 | VRF 2
1140237 | Level 1 | VRF 2
1140289 | Level 1 | VRF 2
1140312 | Level 1 | VRF 2
1140322 | Level 1 | VRF 2
1140332 | Level 1 | VRF 2
1140409 | Level 2 | VRF 2
1145461 | Level 1 | Hydronic Return 1
1145492 | Level 1 | Hydronic Return 1
1145502 | Level 1 | Hydronic Return 1
1145512 | Level 1 | Hydronic Return 1
1145822 | Level 1 | Hydronic Supply 1
1145830 | Level 1 | Hydronic Supply 1
1145894 | Level 1 | Hydronic Return 2
1145934 | Level 1 | Hydronic Supply 1
1145950 | Level 1 | Hydronic Supply 1
1145982 | Level 1 | Hydronic Supply 1
1146022 | Level 1 | Hydronic Return 2
1146032 | Level 1 | Hydronic Return 2
1146096 | Level 1 | Hydronic Return 2
1146108 | Level 1 | Hydronic Return 2
1176421 | 3A vėdinimas | VRF 2
1176431 | 3A vėdinimas | VRF 2
1179617 | 3A vėdinimas | Hydronic Return 4
1179682 | 3A vėdinimas | VRF 2
1202855 | Level 2 | Hydronic Return 3
1203316 | Level 2 | Hydronic Return 1
1203327 | Level 2 | Hydronic Return 1
1203360 | Level 2 | Hydronic Supply 2
1203367 | Level 2 | Hydronic Supply 2
1203372 | Level 2 | Hydronic Supply 2
1203423 | Level 2 | Hydronic Return 3
1203429 | Level 2 | Hydronic Return 3
1203520 | Level 2 | Hydronic Return 3
1203523 | Level 2 | Hydronic Return 3
1204403 | 3A vėdinimas | Hydronic Return 1
1204411 | 3A vėdinimas | Hydronic Return 1
1207528 | Level 1 | Hydronic Return 2
1207538 | Level 1 | Hydronic Return 2
1207678 | Level 1 | Hydronic Return 2
1207688 | Level 1 | Hydronic Return 2
1207747 | Level 1 | Hydronic Return 2
1207757 | Level 1 | Hydronic Return 2
1207849 | 3A vėdinimas | Hydronic Return 1
1207858 | 3A vėdinimas | Hydronic Return 1
1209530 | 3A vėdinimas | Hydronic Return 1
1209569 | 3A vėdinimas | Hydronic Return 1
1209584 | 3A vėdinimas | Hydronic Return 1
1209603 | 3A vėdinimas | Hydronic Return 1
1209631 | 3A vėdinimas | Hydronic Return 1
1209818 | 3A vėdinimas | Hydronic Return 1
1209827 | 3A vėdinimas | Hydronic Return 1
1209830 | 3A vėdinimas | Hydronic Return 1
1209851 | Level 1 | Hydronic Return 1
1209998 | 3A vėdinimas | Hydronic Return 1
1210006 | 3A vėdinimas | Hydronic Return 1
1210057 | 3A vėdinimas | Hydronic Return 1
1210066 | 3A vėdinimas | Hydronic Return 1
1210069 | 3A vėdinimas | Hydronic Return 1
1210186 | 3A vėdinimas | Hydronic Return 1
1210238 | 3A vėdinimas | Hydronic Return 1
1210247 | 3A vėdinimas | Hydronic Return 1
1210250 | 3A vėdinimas | Hydronic Return 1
1210318 | 3A vėdinimas | Hydronic Return 1
1210326 | 3A vėdinimas | Hydronic Return 1
1210338 | 3A vėdinimas | Hydronic Return 1
1210347 | 3A vėdinimas | Hydronic Return 1
1210436 | 3A vėdinimas | Hydronic Return 1
1210932 | 3A vėdinimas | Hydronic Return 1
1210957 | 3A vėdinimas | Hydronic Return 1
1210965 | 3A vėdinimas | Hydronic Return 1
1211015 | 3A vėdinimas | Hydronic Return 1
1211024 | 3A vėdinimas | Hydronic Return 1
1211059 | Level 2 | Hydronic Return 1
1211067 | Level 2 | Hydronic Return 1
1211235 | Level 2 | Hydronic Return 1
1211386 | Level 1 | Hydronic Return 1
1211390 | Level 2 | Hydronic Return 1
1211620 | 3A vėdinimas | Hydronic Return 1
1211629 | 3A vėdinimas | Hydronic Return 1
1211891 | 3A vėdinimas | Hydronic Return 1
1212606 | 3A vėdinimas | Hydronic Return 1
1212637 | 3A vėdinimas | Hydronic Return 1
1212685 | 3A vėdinimas | Hydronic Return 1
1212691 | 3A vėdinimas | Hydronic Return 1
1213510 | Level 2 | Hydronic Supply 1
1213512 | Level 2 | Hydronic Supply 1
1213516 | Level 2 | Hydronic Return 2
1213518 | Level 2 | Hydronic Return 2
1213533 | Level 2 | Hydronic Supply 1
1216972 | Level 1 | Hydronic Return 1
1217018 | Level 1 | Hydronic Return 1
1217038 | Level 1 | Hydronic Return 1
1217066 | Level 1 | Hydronic Return 1
1217106 | Level 1 | Hydronic Return 1
1217760 | 3A vėdinimas | Hydronic Supply 1
1217762 | 3A vėdinimas | Hydronic Supply 1
1217766 | 3A vėdinimas | Hydronic Return 2
1217768 | 3A vėdinimas | Hydronic Return 2
1217901 | Level 2 | Hydronic Supply 1
1223062 | Level 2 | Hydronic Supply 1
1223064 | Level 2 | Hydronic Supply 1
1223066 | Level 2 | Hydronic Return 2
1223068 | Level 2 | Hydronic Return 2
1223109 | Level 1 | Hydronic Return 2
1223375 | Level 2 | Hydronic Supply 2
1223377 | Level 2 | Hydronic Return 3
1223379 | Level 2 | Hydronic Supply 2
1223383 | Level 2 | Hydronic Return 3
1223499 | Level 2 | Hydronic Supply 1
1223501 | Level 2 | Hydronic Supply 1
1223503 | Level 2 | Hydronic Return 2
1223505 | Level 2 | Hydronic Return 2
1227628 | Level 2 | Hydronic Return 2
1229229 | Level 1 | Hydronic Supply 1
1229240 | Level 1 | Hydronic Supply 1
1229245 | Level 1 | Hydronic Supply 1
1229253 | Level 1 | Hydronic Supply 1
1229293 | Level 1 | Hydronic Return 2
1229303 | Level 1 | Hydronic Return 2
1229311 | Level 1 | Hydronic Return 2
1229478 | Level 1 | Hydronic Return 2
1229494 | Level 1 | Hydronic Return 2
1243338 | Level 1 | Baseino term. 2
1243369 | Level 1 | Baseino term. 2
1243641 | Level 1 | Baseino term. 2
1243677 | Level 1 | Baseino term. 2
1243698 | Level 1 | Baseino term. 2
1243700 | Level 1 | Baseino term. 2
1243705 | Level 1 | Baseino term. 2
1243707 | Level 1 | Baseino term. 2
1243755 | Level 1 | Baseino term. 2
1244087 | Level 1 | Baseino term. 2
1244089 | Level 1 | Baseino term. 2
1244328 | Level 1 | Baseino term. 2
1244375 | Level 1 | Baseino term. 2
1244377 | Level 1 | Baseino term. 2
1244412 | Level 1 | Baseino term. 2
1244449 | Level 1 | Baseino term. 2
1244451 | Level 1 | Baseino term. 2
1244494 | Level 1 | Baseino term. 2
1244525 | Level 1 | Baseino term. 2
1244527 | Level 1 | Baseino term. 2
1244548 | Level 1 | Baseino term. 2
1244562 | Level 1 | Baseino term. 2
1244593 | Level 1 | Baseino term. 2
1244751 | Level 1 | Baseino term. 2
1244964 | Level 1 | Baseino term. 2
1244974 | Level 1 | Baseino term. 2
1244985 | Level 1 | Baseino term. 2
1245075 | Level 1 | Baseino term. 2
1245088 | Level 1 | Baseino term. 2
1245145 | Level 1 | Baseino term. 2
1245152 | Level 1 | Baseino term. 2
1245162 | Level 1 | Baseino term. 2
1245234 | Level 1 | Baseino term. 2
1245242 | Level 1 | Baseino term. 2
1252913 | Level 1 | Baseino term. 2
1252952 | Level 1 | Baseino term. 2
1254586 | Level 1 | Baseino term. 2
1254623 | Level 1 | Baseino term. 2
1254678 | Level 1 | Baseino term. 2
1254898 | Level 1 | Baseino term. 2
1254906 | Level 1 | Baseino term. 2
1254967 | Level 1 | Baseino term. 2
1255006 | Level 1 | Baseino term. 2
1258323 | Level 1 | AHU 2
1258345 | Level 1 | AHU 2
1258356 | Level 1 | AHU 2
1258360 | Level 1 | AHU 2
1258366 | Level 1 | AHU 2
1258391 | Level 1 | AHU 2
1258415 | Level 1 | AHU 2
1258491 | Level 1 | AHU 2
1258525 | Level 1 | AHU 2
1258612 | Level 1 | AHU 2
1258921 | Level 1 | AHU 2
1258951 | Level 1 | AHU 2
1258995 | Level 1 | AHU 2
1259201 | Level 1 | AHU 2
1259277 | Level 1 | AHU 2
1259286 | Level 1 | AHU 2
1259294 | Level 1 | AHU 2
1259319 | Level 1 | AHU 2
1259328 | Level 1 | AHU 2
1259336 | Level 1 | AHU 2
1259625 | Level 1 | AHU 2
1259627 | Level 1 | AHU 2
1259629 | Level 1 | AHU 2
1259631 | Level 1 | AHU 2
1259633 | Level 1 | AHU 2
1259649 | Level 1 | AHU 2
1259652 | Level 1 | AHU 2
1259655 | Level 1 | AHU 2
1259843 | Level 1 | AHU 2
1259855 | Level 1 | AHU 2
1259885 | Level 1 | AHU 2
1259894 | Level 1 | AHU 2
1259922 | Level 1 | AHU 2
1259932 | Level 1 | AHU 2
1259978 | Level 1 | AHU 2
1259988 | Level 1 | AHU 2
1260055 | Level 1 | AHU 2
1260105 | Level 1 | AHU 2
1260170 | Level 1 | AHU 2
1260183 | Level 1 | AHU 2
1260212 | Level 1 | AHU 2
1260223 | Level 1 | AHU 2
1260247 | Level 1 | AHU 2
1260542 | 3A vėdinimas | Hydronic Return 1
1260606 | 3A vėdinimas | Hydronic Return 1
1269554 | Level 1 | Baseino term. 2
1269556 | Level 1 | Baseino term. 2
1269569 | Level 1 | Baseino term. 2
1269571 | Level 1 | Baseino term. 2
1269822 | Level 1 | Baseino term. 2
1269866 | Level 1 | Baseino term. 2
1271800 | Level 1 | Baseino term. 2
1271834 | Level 1 | Baseino term. 2
1272223 | Level 1 | Baseino term. 2
1272251 | Level 1 | Baseino term. 2
1272362 | Level 1 | Baseino term. 2
1272410 | Level 1 | Baseino term. 2
1272440 | Level 1 | Baseino term. 2
1272450 | Level 1 | Baseino term. 2
1272460 | Level 1 | Baseino term. 2
1272491 | Level 1 | Baseino term. 2
1272533 | Level 1 | Baseino term. 2
1272543 | Level 1 | Baseino term. 2
1272557 | Level 1 | Baseino term. 2
1272576 | Level 1 | Baseino term. 2
1272595 | Level 1 | Baseino term. 2
1272614 | Level 1 | Baseino term. 2
1272659 | Level 1 | Baseino term. 2
1272669 | Level 1 | Baseino term. 2
1272725 | Level 1 | Baseino term. 2
1272735 | Level 1 | Baseino term. 2
1272761 | Level 1 | Baseino term. 2
1272771 | Level 1 | Baseino term. 2
1272813 | Level 1 | Baseino term. 2
1272858 | Level 1 | Baseino term. 2
1272868 | Level 1 | Baseino term. 2
1272878 | Level 1 | Baseino term. 2
1272903 | Level 1 | Baseino term. 2
1272920 | Level 1 | Baseino term. 2
1272937 | Level 1 | Baseino term. 2
1272981 | Level 1 | Baseino term. 2
1273002 | Level 1 | Baseino term. 2
1273107 | Level 1 | Baseino term. 2
1273154 | Level 1 | Baseino term. 2
1273163 | Level 1 | Baseino term. 2
1273211 | Level 1 | Baseino term. 2
1282687 | Level 1 | Baseino term. 2
1282816 | Level 1 | Baseino term. 2
1282852 | Level 1 | Baseino term. 2
1286118 | Level 1 | Baseino term. 2
1286388 | Level 1 | Hydronic Supply 1
1286403 | Level 1 | Hydronic Supply 1
1286411 | Level 1 | Hydronic Supply 1
1286563 | Level 1 | Hydronic Supply 1
1286577 | Level 1 | Hydronic Supply 1
1286591 | Level 1 | Hydronic Supply 1
1286603 | Level 1 | Hydronic Supply 1
1286613 | Level 1 | Hydronic Supply 1
1286645 | Level 1 | Hydronic Supply 1
1286742 | Level 1 | Hydronic Return 2
1286751 | Level 1 | Hydronic Return 2
1286759 | Level 1 | Hydronic Return 2
1286852 | Level 1 | Hydronic Return 2
1286891 | Level 1 | Hydronic Return 2
1286901 | Level 1 | Hydronic Return 2
1286916 | Level 1 | Hydronic Return 2
1286948 | Level 1 | Hydronic Return 2

# IfcFlowSegment: Rectangular Duct:Radius Elbows / Taps (106)
Name (Rectangular Duct:Radius Elbows / Taps:...) | In | Group
955891 | Level 1 | Mechanical Return Air 2
955952 | Level 1 | Mechanical Return Air 2
956174 | Level 1 | Mechanical Supply Air 2
956181 | Level 1 | Mechanical Supply Air 2
956294 | Level 1 | Mechanical Supply Air 8
956295 | Level 1 | Mechanical Exhaust Air 2
956296 | Level 1 | Mechanical Outside Air 3
956297 | Level 1 | Mechanical Return Air 12
956303 | Level 1 | Mechanical Supply Air 4
956304 | Level 1 | Mechanical Outside Air 4
956448 | Level 1 | Mechanical Return Air 1
958495 | Level 1 | Mechanical Return Air 2
958591 | Level 1 | Mechanical Return Air 6
958618 | Level 1 | Mechanical Supply Air 2
959139 | Level 1 | Mechanical Supply Air 3
961935 | Level 1 | Mechanical Return Air 1
962666 | Level 1 | Mechanical Return Air 1
963143 | Level 1 | Mechanical Exhaust Air 4
963487 | Level 1 | Mechanical Outside Air 1
964432 | Level 1 | Mechanical Return Air 1
964648 | Level 1 | Mechanical Return Air 1
964655 | Level 1 | Mechanical Return Air 1
964676 | Level 1 | Mechanical Return Air 1
964702 | Level 1 | Mechanical Return Air 1
965602 | Level 1 | Mechanical Supply Air 8
966139 | Level 1 | Mechanical Outside Air 7
966409 | Level 1 | Mechanical Outside Air 8
967067 | Level 1 | Mechanical Exhaust Air 2
967315 | Level 2 | Mechanical Return Air 1
967358 | Level 2 | Mechanical Supply Air 4
967369 | Level 2 | Mechanical Supply Air 4
967728 | Level 2 | Mechanical Supply Air 2
987060 | Level 1 | Mechanical Supply Air 4
987079 | Level 1 | Mechanical Return Air 1
995234 | Level 1 | Mechanical Exhaust Air 2
1000671 | Level 2 | Mechanical Return Air 1
1002636 | Level 2 | Mechanical Return Air 3
1002727 | Level 2 | Mechanical Return Air 3
1002758 | Level 2 | Mechanical Return Air 3
1004648 | Level 2 | Mechanical Return Air 3
1022567 | Level 1 | Mechanical Outside Air 2
1022676 | Level 1 | Mechanical Exhaust Air 2
1022701 | Level 1 | Mechanical Exhaust Air 2
1022890 | Level 1 | Mechanical Exhaust Air 2
1024939 | 3A vėdinimas | Mechanical Return Air 2
1026178 | Level 2 | Mechanical Supply Air 2
1026233 | Level 2 | Mechanical Supply Air 2
1026496 | Level 2 | Mechanical Return Air 2
1026993 | Level 1 | Mechanical Return Air 2
1027224 | Level 1 | Mechanical Return Air 2
1027240 | Level 1 | Mechanical Return Air 2
1027460 | Level 1 | Mechanical Supply Air 2
1027522 | Level 1 | Mechanical Supply Air 2
1027535 | Level 1 | Mechanical Supply Air 2
1027557 | Level 1 | Mechanical Supply Air 2
1031619 | Level 1 | Mechanical Exhaust Air 3
1031645 | Level 1 | Mechanical Exhaust Air 3
1031738 | Level 1 | Mechanical Exhaust Air 3
1031887 | 3A vėdinimas | Mechanical Exhaust Air 3
1051973 | Level 1 | Mechanical Return Air 2
1077354 | Level 1 | Mechanical Return Air 2
1077361 | Level 1 | Mechanical Return Air 2
1077414 | Level 1 | Mechanical Supply Air 2
1077421 | Level 1 | Mechanical Supply Air 2
1078217 | Level 1 | Mechanical Return Air 2
1078231 | Level 1 | Mechanical Return Air 2
1095709 | 3A vėdinimas | Mechanical Return Air 2
1095716 | 3A vėdinimas | Mechanical Return Air 2
1095800 | Level 2 | Mechanical Supply Air 2
1123085 | Level 1 | Mechanical Supply Air 2
1123118 | Level 1 | Mechanical Supply Air 2
1145554 | Level 2 | Mechanical Supply Air 2
1146448 | Level 1 | Mechanical Return Air 2
1146537 | Level 1 | Mechanical Return Air 2
1147127 | Level 1 | Mechanical Exhaust Air 3
1147251 | Level 2 | Mechanical Return Air 7
1147260 | Level 2 | Mechanical Return Air 7
1147679 | Level 2 | Mechanical Return Air 7
1170928 | Level 1 | Mechanical Return Air 1
1171647 | Level 1 | Mechanical Supply Air 4
1171770 | Level 1 | Mechanical Supply Air 4
1172947 | Level 1 | Mechanical Outside Air 9
1173913 | Level 1 | Mechanical Supply Air 2
1173938 | Level 1 | Mechanical Return Air 2
1174661 | Level 2 | Mechanical Supply Air 1
1175064 | Level 2 | Mechanical Supply Air 1
1180039 | Level 2 | Mechanical Supply Air 2
1186378 | Level 2 | Mechanical Supply Air 2
1186400 | Level 2 | Mechanical Return Air 2
1186684 | Level 1 | Mechanical Supply Air 2
1186691 | Level 1 | Mechanical Supply Air 2
1188573 | Level 2 | Mechanical Supply Air 2
1190603 | 3A vėdinimas | Mechanical Exhaust Air 3
1215168 | Level 1 | Mechanical Return Air 1
1215177 | Level 1 | Mechanical Return Air 1
1215478 | Level 2 | Mechanical Supply Air 2
1265372 | Level 1 | Mechanical Supply Air 2
1265387 | Level 1 | Mechanical Return Air 2
1268412 | Level 2 | Mechanical Supply Air 2
1268441 | 3A vėdinimas | Mechanical Return Air 2
1268562 | Level 2 | Mechanical Supply Air 2
1268606 | 3A vėdinimas | Mechanical Return Air 2
1268897 | Level 2 | Mechanical Return Air 3
1268968 | Level 2 | Mechanical Return Air 3
1270046 | Level 2 | Mechanical Supply Air 4
1271306 | Level 2 | Mechanical Return Air 1

# IfcFlowSegment: Rectangular Duct:Radius Elbows / Tees (2)
In: Level 1
Group: Mechanical Supply Air 2
Name (Rectangular Duct:Radius Elbows / Tees:...)
999655
1265506

# IfcFlowSegment: Round Duct:FabricAir Round Duct (9)
In: 3A vėdinimas
Group: Mechanical Supply Air 4
Name (Round Duct:FabricAir Round Duct:...)
1148446
1148471
1148528
1148655
1167312
1168471
1168678
1168856
1168905

# IfcFlowSegment: Round Duct:Taps (317)
Name (Round Duct:Taps:...) | In | Group
927171 | Level 1 | Mechanical Return Air 2
927447 | Level 1 | Mechanical Supply Air 2
929316 | Level 2 | Mechanical Supply Air 2
929345 | Level 2 | Mechanical Supply Air 2
929793 | Level 2 | Mechanical Return Air 2
929809 | Level 2 | Mechanical Return Air 2
930041 | Level 2 | Mechanical Return Air 2
930128 | Level 2 | Mechanical Return Air 2
930182 | Level 2 | Mechanical Return Air 2
930295 | Level 2 | Mechanical Return Air 2
930573 | Level 2 | Mechanical Return Air 2
930668 | Level 2 | Mechanical Return Air 2
931381 | Level 1 | Mechanical Supply Air 2
931404 | Level 1 | Mechanical Supply Air 2
931419 | Level 1 | Mechanical Supply Air 2
931474 | Level 1 | Mechanical Return Air 2
931553 | Level 1 | Mechanical Return Air 2
931567 | Level 1 | Mechanical Return Air 2
931591 | Level 1 | Mechanical Return Air 2
931682 | Level 1 | Mechanical Return Air 2
931986 | Level 1 | Mechanical Supply Air 2
932135 | Level 1 | Mechanical Return Air 2
932163 | Level 1 | Mechanical Supply Air 2
932193 | Level 1 | Mechanical Supply Air 2
932257 | Level 1 | Mechanical Supply Air 2
932307 | Level 1 | Mechanical Supply Air 2
932322 | Level 1 | Mechanical Supply Air 2
932386 | Level 1 | Mechanical Supply Air 2
932402 | Level 1 | Mechanical Supply Air 2
932413 | Level 1 | Mechanical Supply Air 2
932426 | Level 1 | Mechanical Supply Air 2
932542 | Level 1 | Mechanical Supply Air 2
932568 | Level 1 | Mechanical Return Air 2
934410 | Level 1 | Mechanical Return Air 2
934421 | Level 1 | Mechanical Return Air 2
951806 | Level 1 | Mechanical Return Air 2
951836 | Level 1 | Mechanical Supply Air 2
952450 | Level 2 | Mechanical Supply Air 2
952535 | Level 2 | Mechanical Supply Air 2
952572 | Level 2 | Mechanical Supply Air 2
953960 | Level 1 | Mechanical Return Air 2
953979 | Level 1 | Mechanical Return Air 2
953997 | Level 1 | Mechanical Return Air 2
954007 | Level 1 | Mechanical Return Air 2
954033 | Level 1 | Mechanical Return Air 2
957035 | Level 1 | Mechanical Return Air 2
957133 | Level 1 | Mechanical Return Air 2
957188 | Level 1 | Mechanical Supply Air 2
957300 | Level 1 | Mechanical Supply Air 2
957308 | Level 1 | Mechanical Supply Air 2
959319 | Level 1 | Mechanical Supply Air 2
959710 | Level 1 | Mechanical Return Air 2
966178 | Level 1 | Mechanical Outside Air 8
966197 | Level 1 | Mechanical Outside Air 8
967750 | Level 2 | Mechanical Supply Air 2
968197 | Level 1 | Mechanical Return Air 2
968625 | Level 1 | Mechanical Return Air 2
968701 | Level 1 | Mechanical Return Air 2
968972 | Level 1 | Mechanical Supply Air 2
969084 | Level 1 | Mechanical Supply Air 2
969121 | Level 1 | Mechanical Supply Air 2
969222 | Level 1 | Mechanical Supply Air 2
969240 | Level 1 | Mechanical Supply Air 2
969432 | Level 1 | Mechanical Return Air 2
969465 | Level 1 | Mechanical Supply Air 2
969481 | Level 1 | Mechanical Supply Air 2
969513 | Level 1 | Mechanical Supply Air 2
969542 | Level 2 | Mechanical Return Air 2
969558 | Level 2 | Mechanical Return Air 2
969598 | Level 2 | Mechanical Return Air 2
970207 | Level 2 | Mechanical Supply Air 2
970224 | Level 2 | Mechanical Supply Air 2
970251 | Level 2 | Mechanical Supply Air 2
970269 | Level 2 | Mechanical Supply Air 2
970288 | Level 2 | Mechanical Supply Air 2
970405 | Level 2 | Mechanical Supply Air 2
970633 | Level 2 | Mechanical Supply Air 2
973455 | Level 1 | Mechanical Return Air 2
973482 | Level 1 | Mechanical Return Air 2
973531 | Level 1 | Mechanical Return Air 2
973546 | Level 1 | Mechanical Return Air 2
974663 | Level 1 | Mechanical Supply Air 2
974686 | Level 1 | Mechanical Supply Air 2
974712 | Level 1 | Mechanical Return Air 2
974738 | Level 1 | Mechanical Supply Air 2
974772 | Level 1 | Mechanical Return Air 2
974799 | Level 1 | Mechanical Return Air 2
974894 | Level 1 | Mechanical Return Air 2
974942 | Level 1 | Mechanical Supply Air 2
975040 | Level 1 | Mechanical Supply Air 2
981190 | Level 1 | Mechanical Return Air 2
983903 | Level 1 | Mechanical Return Air 2
983922 | Level 1 | Mechanical Supply Air 2
987448 | Level 1 | Mechanical Supply Air 2
987495 | Level 1 | Mechanical Return Air 2
987512 | Level 1 | Mechanical Supply Air 2
987658 | Level 2 | Mechanical Supply Air 2
987715 | Level 2 | Mechanical Supply Air 2
987780 | Level 1 | Mechanical Return Air 2
987800 | Level 1 | Mechanical Supply Air 2
989042 | Level 1 | Mechanical Supply Air 2
991048 | Level 2 | Mechanical Return Air 2
1000161 | Level 1 | Mechanical Supply Air 2
1001746 | Level 1 | Mechanical Supply Air 2
1002237 | Level 1 | Mechanical Return Air 2
1015780 | Level 2 | Mechanical Return Air 2
1017214 | Level 1 | Mechanical Return Air 2
1017218 | Level 1 | Mechanical Return Air 2
1017220 | Level 1 | Mechanical Return Air 2
1017246 | Level 1 | Mechanical Return Air 2
1017875 | Level 2 | Mechanical Supply Air 2
1018893 | Level 2 | Mechanical Supply Air 2
1019698 | Level 2 | Mechanical Return Air 2
1020126 | Level 2 | Mechanical Supply Air 2
1020130 | Level 2 | Mechanical Supply Air 2
1020135 | Level 2 | Mechanical Supply Air 2
1020140 | Level 2 | Mechanical Supply Air 2
1020275 | Level 2 | Mechanical Supply Air 2
1020300 | Level 2 | Mechanical Return Air 2
1020302 | Level 2 | Mechanical Return Air 2
1020307 | Level 2 | Mechanical Return Air 2
1020312 | Level 2 | Mechanical Return Air 2
1020546 | 3A vėdinimas | Mechanical Return Air 2
1020594 | 3A vėdinimas | Mechanical Return Air 2
1021641 | Level 1 | Mechanical Supply Air 2
1023628 | Level 1 | Mechanical Return Air 2
1023890 | Level 2 | Mechanical Return Air 2
1023898 | Level 2 | Mechanical Return Air 2
1023946 | Level 1 | Mechanical Supply Air 2
1023953 | Level 1 | Mechanical Supply Air 2
1024212 | Level 1 | Mechanical Supply Air 2
1024416 | Level 1 | Mechanical Supply Air 2
1024473 | 3A vėdinimas | Mechanical Return Air 2
1024484 | 3A vėdinimas | Mechanical Return Air 2
1024887 | 3A vėdinimas | Mechanical Return Air 2
1025567 | Level 2 | Mechanical Return Air 2
1025917 | Level 2 | Mechanical Return Air 2
1026458 | Level 1 | Mechanical Return Air 2
1026466 | Level 1 | Mechanical Return Air 2
1027855 | Level 2 | Mechanical Return Air 2
1027863 | Level 2 | Mechanical Return Air 2
1027898 | Level 2 | Mechanical Return Air 2
1029029 | 3A vėdinimas | Mechanical Return Air 2
1029491 | Level 2 | Mechanical Return Air 2
1029494 | Level 2 | Mechanical Return Air 2
1029510 | Level 2 | Mechanical Return Air 2
1029518 | Level 2 | Mechanical Return Air 2
1029632 | Level 2 | Mechanical Return Air 2
1029653 | Level 2 | Mechanical Return Air 2
1029656 | Level 2 | Mechanical Return Air 2
1029658 | Level 2 | Mechanical Return Air 2
1029661 | Level 2 | Mechanical Return Air 2
1029718 | Level 2 | Mechanical Return Air 2
1029729 | Level 2 | Mechanical Return Air 2
1029757 | Level 2 | Mechanical Return Air 2
1029765 | Level 2 | Mechanical Return Air 2
1029792 | Level 2 | Mechanical Return Air 2
1030078 | Level 1 | Mechanical Return Air 2
1030086 | Level 1 | Mechanical Return Air 2
1030170 | 3A vėdinimas | Mechanical Return Air 2
1030194 | 3A vėdinimas | Mechanical Return Air 2
1030236 | Level 1 | Mechanical Return Air 2
1031024 | Level 1 | Mechanical Return Air 2
1031049 | Level 1 | Mechanical Supply Air 2
1032763 | Level 1 | Mechanical Supply Air 2
1032905 | Level 2 | Mechanical Supply Air 7
1032914 | Level 2 | Mechanical Supply Air 7
1033081 | Level 1 | Mechanical Return Air 2
1033090 | Level 1 | Mechanical Return Air 2
1033101 | Level 1 | Mechanical Return Air 2
1033317 | Level 1 | Mechanical Supply Air 2
1052137 | Level 1 | Mechanical Return Air 2
1052546 | Level 2 | Mechanical Supply Air 7
1086669 | Level 1 | Mechanical Supply Air 2
1093754 | Level 1 | Mechanical Return Air 2
1093764 | Level 1 | Mechanical Return Air 2
1099692 | Level 1 | Mechanical Supply Air 2
1099716 | Level 1 | Mechanical Supply Air 2
1104028 | Level 2 | Mechanical Return Air 2
1104125 | Level 2 | Mechanical Return Air 2
1120527 | Level 1 | Mechanical Return Air 2
1120542 | Level 1 | Mechanical Return Air 2
1121682 | Level 1 | Mechanical Return Air 2
1144919 | Level 1 | Mechanical Supply Air 2
1144935 | Level 1 | Mechanical Supply Air 2
1144952 | Level 1 | Mechanical Supply Air 2
1144973 | Level 1 | Mechanical Supply Air 2
1146501 | Level 1 | Mechanical Return Air 2
1147868 | Level 2 | Mechanical Supply Air 4
1148024 | Level 2 | Mechanical Supply Air 4
1174532 | Level 2 | Mechanical Supply Air 7
1174545 | Level 2 | Mechanical Supply Air 7
1174731 | Level 2 | Mechanical Supply Air 7
1175111 | Level 2 | Mechanical Supply Air 7
1175319 | Level 2 | Mechanical Supply Air 7
1175544 | Level 2 | Mechanical Supply Air 2
1175584 | Level 2 | Mechanical Return Air 2
1175598 | Level 2 | Mechanical Return Air 2
1175815 | Level 2 | Mechanical Supply Air 4
1176181 | Level 2 | Mechanical Supply Air 4
1176216 | Level 2 | Mechanical Supply Air 4
1179966 | Level 2 | Mechanical Return Air 2
1180006 | Level 2 | Mechanical Return Air 2
1180274 | Level 2 | Mechanical Return Air 2
1180550 | Level 2 | Mechanical Supply Air 2
1180799 | Level 1 | Mechanical Supply Air 2
1181013 | Level 2 | Mechanical Supply Air 2
1186424 | Level 2 | Mechanical Supply Air 2
1194363 | Level 1 | Mechanical Supply Air 7
1195596 | Level 1 | Mechanical Return Air 2
1195616 | Level 1 | Mechanical Return Air 2
1195715 | Level 1 | Mechanical Return Air 2
1195825 | Level 1 | Mechanical Return Air 2
1195855 | Level 1 | Mechanical Return Air 2
1196076 | Level 1 | Mechanical Return Air 2
1196148 | Level 1 | Mechanical Supply Air 2
1196323 | Level 1 | Mechanical Supply Air 9
1200582 | Level 1 | Mechanical Supply Air 9
1202177 | Level 1 | Mechanical Return Air 8
1202227 | Level 1 | Mechanical Return Air 8
1204025 | Level 1 | Mechanical Return Air 2
1204051 | Level 1 | Mechanical Return Air 2
1204089 | Level 1 | Mechanical Return Air 2
1208354 | Level 1 | Mechanical Return Air 8
1210640 | Level 1 | Mechanical Return Air 2
1211432 | Level 1 | Mechanical Supply Air 2
1211471 | Level 1 | Mechanical Supply Air 2
1215848 | Level 2 | Mechanical Supply Air 2
1215923 | Level 2 | Mechanical Supply Air 2
1215953 | Level 2 | Mechanical Supply Air 2
1215957 | Level 2 | Mechanical Supply Air 2
1215959 | Level 2 | Mechanical Supply Air 2
1215976 | Level 2 | Mechanical Supply Air 2
1215980 | Level 2 | Mechanical Supply Air 2
1215982 | Level 2 | Mechanical Supply Air 2
1216178 | Level 2 | Mechanical Return Air 2
1216182 | Level 2 | Mechanical Return Air 2
1216184 | Level 2 | Mechanical Return Air 2
1216279 | Level 2 | Mechanical Return Air 2
1216283 | Level 2 | Mechanical Return Air 2
1216285 | Level 2 | Mechanical Return Air 2
1216300 | Level 2 | Mechanical Return Air 2
1216304 | Level 2 | Mechanical Return Air 2
1216306 | Level 2 | Mechanical Return Air 2
1219026 | Level 1 | Mechanical Exhaust Air 1
1219033 | Level 1 | Mechanical Exhaust Air 1
1219192 | Level 1 | Mechanical Exhaust Air 1
1219200 | Level 1 | Mechanical Exhaust Air 1
1219209 | Level 1 | Mechanical Exhaust Air 1
1219429 | Level 1 | Mechanical Exhaust Air 1
1219700 | Level 1 | Mechanical Exhaust Air 1
1261047 | Level 1 | Mechanical Return Air 2
1261072 | Level 1 | Mechanical Supply Air 2
1261589 | Level 1 | Mechanical Return Air 2
1261608 | Level 1 | Mechanical Supply Air 2
1261847 | Level 1 | Mechanical Supply Air 7
1261916 | Level 1 | Mechanical Return Air 2
1261971 | Level 1 | Mechanical Return Air 2
1262061 | Level 1 | Mechanical Supply Air 2
1262069 | Level 1 | Mechanical Supply Air 2
1262158 | Level 1 | Mechanical Supply Air 2
1262177 | Level 1 | Mechanical Supply Air 2
1265286 | Level 1 | Mechanical Return Air 2
1265307 | Level 1 | Mechanical Supply Air 2
1265489 | Level 1 | Mechanical Supply Air 2
1265579 | Level 1 | Mechanical Return Air 2
1265628 | Level 1 | Mechanical Supply Air 2
1266847 | Level 1 | Mechanical Outside Air 11
1266905 | Level 1 | Mechanical Outside Air 11
1266931 | Level 1 | Mechanical Outside Air 12
1266935 | Level 1 | Mechanical Outside Air 12
1267020 | Level 1 | Mechanical Outside Air 5
1267024 | Level 1 | Mechanical Outside Air 5
1267184 | Level 1 | Mechanical Outside Air 14
1267188 | Level 1 | Mechanical Outside Air 14
1267208 | Level 1 | Mechanical Outside Air 15
1267212 | Level 1 | Mechanical Outside Air 15
1267215 | Level 1 | Mechanical Outside Air 17
1267219 | Level 1 | Mechanical Outside Air 17
1267247 | Level 1 | Mechanical Outside Air 16
1267251 | Level 1 | Mechanical Outside Air 16
1267254 | Level 1 | Mechanical Outside Air 19
1267258 | Level 1 | Mechanical Outside Air 19
1267482 | Level 2 | Mechanical Return Air 2
1267519 | Level 2 | Mechanical Supply Air 2
1267662 | Level 1 | Mechanical Outside Air 10
1267666 | Level 1 | Mechanical Outside Air 10
1267712 | Level 1 | Mechanical Outside Air 13
1267716 | Level 1 | Mechanical Outside Air 13
1267741 | Level 1 | Mechanical Outside Air 18
1267745 | Level 1 | Mechanical Outside Air 18
1267901 | Level 2 | Mechanical Supply Air 2
1267944 | Level 2 | Mechanical Supply Air 2
1267959 | Level 2 | Mechanical Supply Air 2
1268035 | Level 2 | Mechanical Outside Air 21
1268039 | Level 2 | Mechanical Outside Air 21
1268061 | Level 2 | Mechanical Outside Air 22
1268065 | Level 2 | Mechanical Outside Air 22
1268198 | Level 2 | Mechanical Return Air 2
1268220 | Level 2 | Mechanical Return Air 2
1268334 | Level 2 | Mechanical Outside Air 20
1287332 | Level 1 | Mechanical Return Air 2
1287350 | Level 1 | Mechanical Return Air 2
1287416 | Level 1 | Mechanical Return Air 2
1287437 | Level 1 | Mechanical Return Air 2
1287452 | Level 1 | Mechanical Return Air 2
1287481 | Level 1 | Mechanical Return Air 2
1287503 | Level 1 | Mechanical Return Air 2
1287541 | Level 1 | Mechanical Return Air 2
1287645 | Level 2 | Mechanical Outside Air 24
1287649 | Level 2 | Mechanical Outside Air 24
1287776 | Level 1 | Mechanical Supply Air 2
1287831 | Level 1 | Mechanical Supply Air 2
1287890 | Level 1 | Mechanical Supply Air 2
1287928 | Level 1 | Mechanical Outside Air 6
1287932 | Level 1 | Mechanical Outside Air 6
1288012 | Level 2 | Mechanical Outside Air 20

# IfcFlowSegment: Round Duct:Taps / Short Radius (2)
In: Level 2
Group: Mechanical Supply Air 4
Name (Round Duct:Taps / Short Radius:...)
1175943
1176052

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro išmetimo grotelės (plastikinės) d200, su apsauga nuo kritulių, Airvent_E5O_RFA_2022_LevelBased (3):Oro išmetimo grotelės (plastikinės) d200, su apsauga nuo kritulių:1219578
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 1

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro išmetimo grotelės d125, Airvent_E5O_RFA_2022_LevelBased (3):Oro išmetimo grotelės d125:1208651
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Return Air 8

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo grotelės (plastikinės) d200, Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo grotelės (plastikinės) d200:1219500
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 1

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo grotelės d160, Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo grotelės d160:977085
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Return Air 2

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo grotelės d315, Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo grotelės d315:1140488
In: 3A vėdinimas
Type - Material: <Unnamed>
Group: Mechanical Return Air 2

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo tinklelis d125 (6)
In: Level 1
Type - Material: <Unnamed>
Name (Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo tinklelis d125:...) | Group
974602 | Mechanical Return Air 2
974615 | Mechanical Return Air 2
974628 | Mechanical Return Air 2
974647 | Mechanical Return Air 2
1195654 | Mechanical Return Air 2
1208392 | Mechanical Return Air 8

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo tinklelis d160, Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo tinklelis d160:987240
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Return Air 2

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo tinklelis d200, Airvent_E5O_RFA_2022_LevelBased (3):Oro ištraukimo tinklelis d200:1204138
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Return Air 2

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Oro pritekėjimo grotelės d125, Airvent_E5O_RFA_2022_LevelBased (3):Oro pritekėjimo grotelės d125:1208659
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Supply Air 9

# IfcFlowTerminal: Airvent_E5O_RFA_2022_LevelBased (3):Tinklelis d125, Airvent_E5O_RFA_2022_LevelBased (3):Tinklelis d125:1208403
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Supply Air 9

# IfcFlowTerminal: Airvent_ÖLR_RFA_2022_LevelBased (2):Ã–LR-100 (16)
Type - Material: <Unnamed>
Name (Airvent_ÖLR_RFA_2022_LevelBased (2):Ã–LR-100:...) | In | Group
1266930 | Level 1 | Mechanical Outside Air 12
1266933 | Level 1 | Mechanical Outside Air 12
1267019 | Level 1 | Mechanical Outside Air 5
1267022 | Level 1 | Mechanical Outside Air 5
1267661 | Level 1 | Mechanical Outside Air 10
1267664 | Level 1 | Mechanical Outside Air 10
1267711 | Level 1 | Mechanical Outside Air 13
1267714 | Level 1 | Mechanical Outside Air 13
1267740 | Level 1 | Mechanical Outside Air 18
1267743 | Level 1 | Mechanical Outside Air 18
1268034 | Level 2 | Mechanical Outside Air 21
1268037 | Level 2 | Mechanical Outside Air 21
1268333 | Level 2 | Mechanical Outside Air 20
1268336 | Level 2 | Mechanical Outside Air 20
1287644 | Level 2 | Mechanical Outside Air 24
1287647 | Level 2 | Mechanical Outside Air 24

# IfcFlowTerminal: Airvent_ÖLR_RFA_2022_LevelBased (2):Ã–LR-125 (10)
In: Level 1
Type - Material: <Unnamed>
Name (Airvent_ÖLR_RFA_2022_LevelBased (2):Ã–LR-125:...) | Group
1266825 | Mechanical Outside Air 11
1266885 | Mechanical Outside Air 11
1267183 | Mechanical Outside Air 14
1267186 | Mechanical Outside Air 14
1267207 | Mechanical Outside Air 15
1267210 | Mechanical Outside Air 15
1267214 | Mechanical Outside Air 17
1267217 | Mechanical Outside Air 17
1287927 | Mechanical Outside Air 6
1287930 | Mechanical Outside Air 6

# IfcFlowTerminal: Airvent_ÖLR_RFA_2022_LevelBased (2):Ã–LR-160 (6)
Type - Material: <Unnamed>
Name (Airvent_ÖLR_RFA_2022_LevelBased (2):Ã–LR-160:...) | In | Group
1267246 | Level 1 | Mechanical Outside Air 16
1267249 | Level 1 | Mechanical Outside Air 16
1267253 | Level 1 | Mechanical Outside Air 19
1267256 | Level 1 | Mechanical Outside Air 19
1268060 | Level 2 | Mechanical Outside Air 22
1268063 | Level 2 | Mechanical Outside Air 22

# IfcFlowTerminal: ETS_NORD_RVLU_RFA_2022_LevelBased:Lauko oro paėmimo grotelės 1650x1400, ETS_NORD_RVLU_RFA_2022_LevelBased:Lauko oro paėmimo grotelės 1650x1400:1207116
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Outside Air 1

# IfcFlowTerminal: Lindab_AT-V_RFA_2022_LevelBased:Oro tiekimo grotelės 400x300, Lindab_AT-V_RFA_2022_LevelBased:Oro tiekimo grotelės 400x300:1141671
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Supply Air 2

# IfcFlowTerminal: Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 125-20mm-4V (12)
Type - Material: <Unnamed>
Name (Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 125-20mm-4V:...) | In | Group
968621 | Level 1 | Mechanical Return Air 2
968699 | Level 1 | Mechanical Return Air 2
968970 | Level 1 | Mechanical Supply Air 2
969430 | Level 1 | Mechanical Return Air 2
969463 | Level 1 | Mechanical Supply Air 2
969479 | Level 1 | Mechanical Supply Air 2
969511 | Level 1 | Mechanical Supply Air 2
969556 | Level 2 | Mechanical Return Air 2
969596 | Level 2 | Mechanical Return Air 2
1019697 | Level 2 | Mechanical Return Air 2
1020306 | Level 2 | Mechanical Return Air 2
1287501 | Level 1 | Mechanical Return Air 2

# IfcFlowTerminal: Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 160-30mm-4V (10)
Type - Material: <Unnamed>
Name (Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 160-30mm-4V:...) | In | Group
969540 | Level 2 | Mechanical Return Air 2
970403 | Level 2 | Mechanical Supply Air 2
991046 | Level 2 | Mechanical Return Air 2
1028938 | Level 2 | Mechanical Return Air 2
1029493 | Level 2 | Mechanical Return Air 2
1029655 | Level 2 | Mechanical Return Air 2
1029660 | Level 2 | Mechanical Return Air 2
1104102 | Level 1 | Mechanical Return Air 2
1287414 | Level 1 | Mechanical Return Air 2
1287886 | Level 1 | Mechanical Supply Air 2

# IfcFlowTerminal: Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 200-30mm-4V (15)
Type - Material: <Unnamed>
Name (Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 200-30mm-4V:...) | In | Group
969220 | Level 1 | Mechanical Supply Air 2
969238 | Level 1 | Mechanical Supply Air 2
969304 | Level 1 | Mechanical Supply Air 2
970249 | Level 2 | Mechanical Supply Air 2
970267 | Level 2 | Mechanical Supply Air 2
970286 | Level 2 | Mechanical Supply Air 2
970364 | Level 2 | Mechanical Supply Air 2
1017216 | Level 1 | Mechanical Return Air 2
1020134 | Level 2 | Mechanical Supply Air 2
1020139 | Level 2 | Mechanical Supply Air 2
1215955 | Level 2 | Mechanical Supply Air 2
1215978 | Level 2 | Mechanical Supply Air 2
1216180 | Level 2 | Mechanical Return Air 2
1216281 | Level 2 | Mechanical Return Air 2
1216302 | Level 2 | Mechanical Return Air 2

# IfcFlowTerminal: Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 315-30mm-4V (2)
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Supply Air 4
Name (Swegon_AB_CDRb-_4V_RFA_2019_LevelBased:CDRb 315-30mm-4V:...)
1175941
1176051

# IfcFlowTerminal: Systemair_NOVA-CC-2-_-H-ZN_RFA_2022_LevelBased (1):NOVA-CC-2-325x75-H-ZN, Systemair_NOVA-CC-2-_-H-ZN_RFA_2022_LevelBased (1):NOVA-CC-2-325x75-H-ZN:990952
In: Level 1
Type - Material: <Unnamed>

# IfcFlowTerminal: Systemair_NOVA-CC-2-_-H-ZN_RFA_2022_LevelBased (1):NOVA-CC-2-525x125-H-ZN, Systemair_NOVA-CC-2-_-H-ZN_RFA_2022_LevelBased (1):NOVA-CC-2-525x125-H-ZN:990783
In: Level 1
Type - Material: <Unnamed>

# IfcFlowTerminal: TROX_RIA-2_RFA_2022_LevelBased (1):Lauko oro pėmimo grotelės 1200x600, TROX_RIA-2_RFA_2022_LevelBased (1):Lauko oro pėmimo grotelės 1200x600:1218336
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Outside Air 7

# IfcFlowTerminal: TROX_RIA-2_RFA_2022_LevelBased (1):Lauko oro pėmimo grotelės 2000x700, TROX_RIA-2_RFA_2022_LevelBased (1):Lauko oro pėmimo grotelės 2000x700:1204800
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Outside Air 4

# IfcFlowTerminal: TROX_RIA-2_RFA_2022_LevelBased (1):Oro išmetimo grotelės 1400x1700, TROX_RIA-2_RFA_2022_LevelBased (1):Oro išmetimo grotelės 1400x1700:1103792
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 2

# IfcFlowTerminal: TROX_WAP-0-AG_RFA_2022_LevelBased:Oro ištraukimo grotelės 600X250, TROX_WAP-0-AG_RFA_2022_LevelBased:Oro ištraukimo grotelės 600X250:1147695
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Supply Air 5

# IfcFlowTerminal: TROX_WAP-0-AG_RFA_2022_LevelBased:Oro ištraukimo grotelės 800X450, TROX_WAP-0-AG_RFA_2022_LevelBased:Oro ištraukimo grotelės 800X450:1143092
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Return Air 3

# IfcFlowTerminal: TROX_WAP-0-AG_RFA_2022_LevelBased:Oro tiekimo grotelės 200X100, TROX_WAP-0-AG_RFA_2022_LevelBased:Oro tiekimo grotelės 200X100:1174921
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Supply Air 6
