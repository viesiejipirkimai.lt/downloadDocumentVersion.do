Properties of the parts of a building model (IFC2X3), part 4 of 5

# IfcDistributionPort (3760)
Name | FlowDirection | Group
Port_1259654_2 | SOURCEANDSINK | AHU 2
Port_1259655_1 | SOURCEANDSINK | AHU 2
Port_1259843_0 | SOURCEANDSINK | AHU 2
Port_1259853_2 | SOURCEANDSINK | AHU 2
Port_1259843_1 | SOURCEANDSINK | AHU 2
Port_1259861_1 | SOURCEANDSINK | AHU 2
Port_1259855_0 | SOURCEANDSINK | AHU 2
Port_1259861_2 | SOURCEANDSINK | AHU 2
Port_1259855_1 | SOURCEANDSINK | AHU 2
Port_1259885_1 | SOURCEANDSINK | AHU 2
Port_1259902_1 | SOURCEANDSINK | AHU 2
Port_1259894_0 | SOURCEANDSINK | AHU 2
Port_1259902_2 | SOURCEANDSINK | AHU 2
Port_1259894_1 | SOURCEANDSINK | AHU 2
Port_1259922_0 | SOURCEANDSINK | AHU 2
Port_1259930_2 | SOURCEANDSINK | AHU 2
Port_1259922_1 | SOURCEANDSINK | AHU 2
Port_1259941_1 | SOURCEANDSINK | AHU 2
Port_1259932_0 | SOURCEANDSINK | AHU 2
Port_1259941_2 | SOURCEANDSINK | AHU 2
Port_1259932_1 | SOURCEANDSINK | AHU 2
Port_1260063_1 | SOURCEANDSINK | AHU 2
Port_1259978_0 | SOURCEANDSINK | AHU 2
Port_1259986_2 | SOURCEANDSINK | AHU 2
Port_1259978_1 | SOURCEANDSINK | AHU 2
Port_1260255_1 | SOURCEANDSINK | AHU 2
Port_1259988_0 | SOURCEANDSINK | AHU 2
Port_1260255_2 | SOURCEANDSINK | AHU 2
Port_1259988_1 | SOURCEANDSINK | AHU 2
Port_1260259_2 | SOURCEANDSINK | AHU 2
Port_1260055_0 | SOURCEANDSINK | AHU 2
Port_1260063_2 | SOURCEANDSINK | AHU 2
Port_1260055_1 | SOURCEANDSINK | AHU 2
Port_1260232_1 | SOURCEANDSINK | AHU 2
Port_1260105_0 | SOURCEANDSINK | AHU 2
Port_1260249_1 | SOURCEANDSINK | AHU 2
Port_1260105_1 | SOURCEANDSINK | AHU 2
Port_1260192_1 | SOURCEANDSINK | AHU 2
Port_1260170_0 | SOURCEANDSINK | AHU 2
Port_1260190_2 | SOURCEANDSINK | AHU 2
Port_1260170_1 | SOURCEANDSINK | AHU 2
Port_1260192_2 | SOURCEANDSINK | AHU 2
Port_1260182_2 | SOURCEANDSINK | AHU 2
Port_1260183_1 | SOURCEANDSINK | AHU 2
Port_1260182_3 | SOURCEANDSINK | AHU 2
Port_1260190_1 | SOURCEANDSINK | AHU 2
Port_1260212_0 | SOURCEANDSINK | AHU 2
Port_1260230_2 | SOURCEANDSINK | AHU 2
Port_1260212_1 | SOURCEANDSINK | AHU 2
Port_1260232_2 | SOURCEANDSINK | AHU 2
Port_1260222_2 | SOURCEANDSINK | AHU 2
Port_1260223_1 | SOURCEANDSINK | AHU 2
Port_1260222_3 | SOURCEANDSINK | AHU 2
Port_1260230_1 | SOURCEANDSINK | AHU 2
Port_1260247_0 | SOURCEANDSINK | AHU 2
Port_1260249_2 | SOURCEANDSINK | AHU 2
Port_1260247_1 | SOURCEANDSINK | AHU 2
Port_1260259_1 | SOURCEANDSINK | AHU 2
Port_1260542_0 | SOURCEANDSINK | Hydronic Return 1
Port_1260552_1 | SOURCEANDSINK | Hydronic Return 1
Port_1260542_1 | SOURCEANDSINK | Hydronic Return 1
Port_1260608_1 | SOURCEANDSINK | Hydronic Return 1
Port_1260606_0 | SOURCEANDSINK | Hydronic Return 1
Port_1260610_2 | SOURCEANDSINK | Hydronic Return 1
Port_1260606_1 | SOURCEANDSINK | Hydronic Return 1
Port_1260619_1 | SOURCEANDSINK | Hydronic Return 1
Port_1260608_2 | SOURCEANDSINK | Hydronic Return 1
Port_1260610_1 | SOURCEANDSINK | Hydronic Return 1
InPort_1260644_1 | SINK
OutPort_1260644_2 | SOURCE
Port_1260644_3 | SOURCEANDSINK
OutPort_1260644_4 | SOURCE | Other 1
Port_1260644_5 | SOURCEANDSINK
InPort_1261047_1 | SINK | Mechanical Return Air 2
OutPort_1261045_1 | SOURCE | Mechanical Return Air 2
InPort_1261072_1 | SINK | Mechanical Supply Air 2
OutPort_1261070_1 | SOURCE | Mechanical Supply Air 2
InPort_1261070_2 | SINK | Mechanical Supply Air 2
OutPort_1261608_0 | SOURCE | Mechanical Supply Air 2
InPort_1261589_1 | SINK | Mechanical Return Air 2
OutPort_1261587_2 | SOURCE | Mechanical Return Air 2
InPort_1261608_1 | SINK | Mechanical Supply Air 2
OutPort_1261606_1 | SOURCE | Mechanical Supply Air 2
InPort_1261847_1 | SINK | Mechanical Supply Air 7
OutPort_1261845_2 | SOURCE | Mechanical Supply Air 7
InPort_1261914_1 | SINK | Mechanical Return Air 2
OutPort_1261916_1 | SOURCE | Mechanical Return Air 2
InPort_1261969_2 | SINK | Mechanical Return Air 2
OutPort_1261971_1 | SOURCE | Mechanical Return Air 2
InPort_1262049_2 | SINK | Mechanical Supply Air 2
OutPort_1262061_0 | SOURCE | Mechanical Supply Air 2
InPort_1262061_1 | SINK | Mechanical Supply Air 2
OutPort_1262084_2 | SOURCE | Mechanical Supply Air 2
InPort_1262069_0 | SINK | Mechanical Supply Air 2
OutPort_1262082_2 | SOURCE | Mechanical Supply Air 2
InPort_1262084_1 | SINK | Mechanical Supply Air 2
OutPort_1262069_1 | SOURCE | Mechanical Supply Air 2
InPort_1262158_1 | SINK | Mechanical Supply Air 2
OutPort_1262156_2 | SOURCE | Mechanical Supply Air 2
InPort_1262175_2 | SINK | Mechanical Supply Air 2
OutPort_1262158_0 | SOURCE | Mechanical Supply Air 2
InPort_1262177_1 | SINK | Mechanical Supply Air 2
OutPort_1262175_1 | SOURCE | Mechanical Supply Air 2
InPort_1265286_1 | SINK | Mechanical Return Air 2
OutPort_1265284_2 | SOURCE | Mechanical Return Air 2
Port_1265284_3 | SOURCEANDSINK
Port_1265284_4 | SOURCEANDSINK
InPort_1265305_2 | SINK | Mechanical Supply Air 2
OutPort_1265307_1 | SOURCE | Mechanical Supply Air 2
Port_1265305_3 | SOURCEANDSINK
Port_1265305_4 | SOURCEANDSINK
InPort_1265372_1 | SINK | Mechanical Supply Air 2
OutPort_1265370_1 | SOURCE | Mechanical Supply Air 2
InPort_1265387_1 | SINK | Mechanical Return Air 2
OutPort_1265385_1 | SOURCE | Mechanical Return Air 2
InPort_1265487_2 | SINK | Mechanical Supply Air 2
OutPort_1265489_1 | SOURCE | Mechanical Supply Air 2
InPort_1265504_1 | SINK | Mechanical Supply Air 2
OutPort_1265506_1 | SOURCE | Mechanical Supply Air 2
InPort_1265577_1 | SINK | Mechanical Return Air 2
OutPort_1265579_1 | SOURCE | Mechanical Return Air 2
Port_1265577_3 | SOURCEANDSINK
Port_1265577_4 | SOURCEANDSINK
InPort_1265628_1 | SINK | Mechanical Supply Air 2
OutPort_1265626_2 | SOURCE | Mechanical Supply Air 2
InPort_1266825_1 | SINK | Mechanical Outside Air 11
OutPort_1266905_0 | SOURCE | Mechanical Outside Air 11
InPort_1266903_1 | SINK | Mechanical Outside Air 11
OutPort_1266847_0 | SOURCE | Mechanical Outside Air 11
InPort_1266847_1 | SINK | Mechanical Outside Air 11
OutPort_1266885_1 | SOURCE | Mechanical Outside Air 11
InPort_1266885_1 | SINK | Mechanical Outside Air 11
OutPort_1266847_1 | SOURCE | Mechanical Outside Air 11
InPort_1266905_1 | SINK | Mechanical Outside Air 11
OutPort_1266903_2 | SOURCE | Mechanical Outside Air 11
InPort_1266930_1 | SINK | Mechanical Outside Air 12
OutPort_1266935_0 | SOURCE | Mechanical Outside Air 12
InPort_1266934_1 | SINK | Mechanical Outside Air 12
OutPort_1266931_0 | SOURCE | Mechanical Outside Air 12
InPort_1266931_1 | SINK | Mechanical Outside Air 12
OutPort_1266933_1 | SOURCE | Mechanical Outside Air 12
InPort_1266933_1 | SINK | Mechanical Outside Air 12
OutPort_1266931_1 | SOURCE | Mechanical Outside Air 12
InPort_1266935_1 | SINK | Mechanical Outside Air 12
OutPort_1266934_2 | SOURCE | Mechanical Outside Air 12
InPort_1267019_1 | SINK | Mechanical Outside Air 5
OutPort_1267024_0 | SOURCE | Mechanical Outside Air 5
InPort_1267023_1 | SINK | Mechanical Outside Air 5
OutPort_1267020_0 | SOURCE | Mechanical Outside Air 5
InPort_1267020_1 | SINK | Mechanical Outside Air 5
OutPort_1267022_1 | SOURCE | Mechanical Outside Air 5
InPort_1267022_1 | SINK | Mechanical Outside Air 5
OutPort_1267020_1 | SOURCE | Mechanical Outside Air 5
InPort_1267024_1 | SINK | Mechanical Outside Air 5
OutPort_1267023_2 | SOURCE | Mechanical Outside Air 5
InPort_1267183_1 | SINK | Mechanical Outside Air 14
OutPort_1267188_0 | SOURCE | Mechanical Outside Air 14
InPort_1267187_1 | SINK | Mechanical Outside Air 14
OutPort_1267184_0 | SOURCE | Mechanical Outside Air 14
InPort_1267184_1 | SINK | Mechanical Outside Air 14
OutPort_1267186_1 | SOURCE | Mechanical Outside Air 14
InPort_1267186_1 | SINK | Mechanical Outside Air 14
OutPort_1267184_1 | SOURCE | Mechanical Outside Air 14
InPort_1267188_1 | SINK | Mechanical Outside Air 14
OutPort_1267187_2 | SOURCE | Mechanical Outside Air 14
InPort_1267207_1 | SINK | Mechanical Outside Air 15
OutPort_1267212_0 | SOURCE | Mechanical Outside Air 15
InPort_1267211_1 | SINK | Mechanical Outside Air 15
OutPort_1267208_0 | SOURCE | Mechanical Outside Air 15
InPort_1267208_1 | SINK | Mechanical Outside Air 15
OutPort_1267210_1 | SOURCE | Mechanical Outside Air 15
InPort_1267210_1 | SINK | Mechanical Outside Air 15
OutPort_1267208_1 | SOURCE | Mechanical Outside Air 15
InPort_1267212_1 | SINK | Mechanical Outside Air 15
OutPort_1267211_2 | SOURCE | Mechanical Outside Air 15
InPort_1267214_1 | SINK | Mechanical Outside Air 17
OutPort_1267219_0 | SOURCE | Mechanical Outside Air 17
InPort_1267218_1 | SINK | Mechanical Outside Air 17
OutPort_1267215_0 | SOURCE | Mechanical Outside Air 17
InPort_1267215_1 | SINK | Mechanical Outside Air 17
OutPort_1267217_1 | SOURCE | Mechanical Outside Air 17
InPort_1267217_1 | SINK | Mechanical Outside Air 17
OutPort_1267215_1 | SOURCE | Mechanical Outside Air 17
InPort_1267219_1 | SINK | Mechanical Outside Air 17
OutPort_1267218_2 | SOURCE | Mechanical Outside Air 17
InPort_1267246_1 | SINK | Mechanical Outside Air 16
OutPort_1267251_0 | SOURCE | Mechanical Outside Air 16
InPort_1267250_1 | SINK | Mechanical Outside Air 16
OutPort_1267247_0 | SOURCE | Mechanical Outside Air 16
InPort_1267247_1 | SINK | Mechanical Outside Air 16
OutPort_1267249_1 | SOURCE | Mechanical Outside Air 16
InPort_1267249_1 | SINK | Mechanical Outside Air 16
OutPort_1267247_1 | SOURCE | Mechanical Outside Air 16
InPort_1267251_1 | SINK | Mechanical Outside Air 16
OutPort_1267250_2 | SOURCE | Mechanical Outside Air 16
InPort_1267253_1 | SINK | Mechanical Outside Air 19
OutPort_1267258_0 | SOURCE | Mechanical Outside Air 19
InPort_1267257_1 | SINK | Mechanical Outside Air 19
OutPort_1267254_0 | SOURCE | Mechanical Outside Air 19
InPort_1267254_1 | SINK | Mechanical Outside Air 19
OutPort_1267256_1 | SOURCE | Mechanical Outside Air 19
InPort_1267256_1 | SINK | Mechanical Outside Air 19
OutPort_1267254_1 | SOURCE | Mechanical Outside Air 19
InPort_1267258_1 | SINK | Mechanical Outside Air 19
OutPort_1267257_2 | SOURCE | Mechanical Outside Air 19
InPort_1267480_2 | SINK | Mechanical Return Air 2
OutPort_1267482_1 | SOURCE | Mechanical Return Air 2
InPort_1267519_1 | SINK | Mechanical Supply Air 2
OutPort_1267517_2 | SOURCE | Mechanical Supply Air 2
InPort_1267661_1 | SINK | Mechanical Outside Air 10
OutPort_1267666_0 | SOURCE | Mechanical Outside Air 10
InPort_1267665_1 | SINK | Mechanical Outside Air 10
OutPort_1267662_0 | SOURCE | Mechanical Outside Air 10
InPort_1267662_1 | SINK | Mechanical Outside Air 10
OutPort_1267664_1 | SOURCE | Mechanical Outside Air 10
InPort_1267664_1 | SINK | Mechanical Outside Air 10
OutPort_1267662_1 | SOURCE | Mechanical Outside Air 10
InPort_1267666_1 | SINK | Mechanical Outside Air 10
OutPort_1267665_2 | SOURCE | Mechanical Outside Air 10
InPort_1267711_1 | SINK | Mechanical Outside Air 13
OutPort_1267716_0 | SOURCE | Mechanical Outside Air 13
InPort_1267715_1 | SINK | Mechanical Outside Air 13
OutPort_1267712_0 | SOURCE | Mechanical Outside Air 13
InPort_1267712_1 | SINK | Mechanical Outside Air 13
OutPort_1267714_1 | SOURCE | Mechanical Outside Air 13
InPort_1267714_1 | SINK | Mechanical Outside Air 13
OutPort_1267712_1 | SOURCE | Mechanical Outside Air 13
InPort_1267716_1 | SINK | Mechanical Outside Air 13
OutPort_1267715_2 | SOURCE | Mechanical Outside Air 13
InPort_1267740_1 | SINK | Mechanical Outside Air 18
OutPort_1267745_0 | SOURCE | Mechanical Outside Air 18
InPort_1267744_1 | SINK | Mechanical Outside Air 18
OutPort_1267741_0 | SOURCE | Mechanical Outside Air 18
InPort_1267741_1 | SINK | Mechanical Outside Air 18
OutPort_1267743_1 | SOURCE | Mechanical Outside Air 18
InPort_1267743_1 | SINK | Mechanical Outside Air 18
OutPort_1267741_1 | SOURCE | Mechanical Outside Air 18
InPort_1267745_1 | SINK | Mechanical Outside Air 18
OutPort_1267744_2 | SOURCE | Mechanical Outside Air 18
InPort_1267899_2 | SINK | Mechanical Supply Air 2
OutPort_1267901_1 | SOURCE | Mechanical Supply Air 2
InPort_1267944_1 | SINK | Mechanical Supply Air 2
OutPort_1267942_2 | SOURCE | Mechanical Supply Air 2
InPort_1267957_1 | SINK | Mechanical Supply Air 2
OutPort_1267944_0 | SOURCE | Mechanical Supply Air 2
InPort_1267959_1 | SINK | Mechanical Supply Air 2
OutPort_1267957_2 | SOURCE | Mechanical Supply Air 2
InPort_1268034_1 | SINK | Mechanical Outside Air 21
OutPort_1268039_0 | SOURCE | Mechanical Outside Air 21
InPort_1268038_1 | SINK | Mechanical Outside Air 21
OutPort_1268035_0 | SOURCE | Mechanical Outside Air 21
InPort_1268035_1 | SINK | Mechanical Outside Air 21
OutPort_1268037_1 | SOURCE | Mechanical Outside Air 21
InPort_1268037_1 | SINK | Mechanical Outside Air 21
OutPort_1268035_1 | SOURCE | Mechanical Outside Air 21
InPort_1268039_1 | SINK | Mechanical Outside Air 21
OutPort_1268038_2 | SOURCE | Mechanical Outside Air 21
InPort_1268060_1 | SINK | Mechanical Outside Air 22
OutPort_1268065_0 | SOURCE | Mechanical Outside Air 22
InPort_1268064_1 | SINK | Mechanical Outside Air 22
OutPort_1268061_0 | SOURCE | Mechanical Outside Air 22
InPort_1268061_1 | SINK | Mechanical Outside Air 22
OutPort_1268063_1 | SOURCE | Mechanical Outside Air 22
InPort_1268063_1 | SINK | Mechanical Outside Air 22
OutPort_1268061_1 | SOURCE | Mechanical Outside Air 22
InPort_1268065_1 | SINK | Mechanical Outside Air 22
OutPort_1268064_2 | SOURCE | Mechanical Outside Air 22
InPort_1268198_1 | SINK | Mechanical Return Air 2
OutPort_1268196_2 | SOURCE | Mechanical Return Air 2
InPort_1268220_1 | SINK | Mechanical Return Air 2
OutPort_1268218_2 | SOURCE | Mechanical Return Air 2
InPort_1268333_1 | SINK | Mechanical Outside Air 20
OutPort_1268334_1 | SOURCE | Mechanical Outside Air 20
InPort_1288010_1 | SINK | Mechanical Outside Air 20
OutPort_1268334_0 | SOURCE | Mechanical Outside Air 20
InPort_1268334_1 | SINK | Mechanical Outside Air 20
OutPort_1268333_1 | SOURCE | Mechanical Outside Air 20
InPort_1268336_1 | SINK | Mechanical Outside Air 20
OutPort_1288012_0 | SOURCE | Mechanical Outside Air 20
InPort_1268412_1 | SINK | Mechanical Supply Air 2
OutPort_1268410_1 | SOURCE | Mechanical Supply Air 2
InPort_1268560_1 | SINK | Mechanical Supply Air 2
OutPort_1268412_0 | SOURCE | Mechanical Supply Air 2
InPort_1268441_1 | SINK | Mechanical Return Air 2
OutPort_1268437_1 | SOURCE | Mechanical Return Air 2
InPort_1268591_1 | SINK | Mechanical Return Air 2
OutPort_1268441_0 | SOURCE | Mechanical Return Air 2
InPort_1268562_1 | SINK | Mechanical Supply Air 2
OutPort_1268560_2 | SOURCE | Mechanical Supply Air 2
InPort_1268606_1 | SINK | Mechanical Return Air 2
OutPort_1268591_2 | SOURCE | Mechanical Return Air 2
InPort_1268968_1 | SINK | Mechanical Return Air 3
OutPort_1268950_2 | SOURCE | Mechanical Return Air 3
Port_1269554_0 | SOURCEANDSINK | Baseino term. 2
Port_1269817_2 | SOURCEANDSINK | Baseino term. 2
Port_1269554_1 | SOURCEANDSINK | Baseino term. 2
Port_1272001_2 | SOURCEANDSINK | Baseino term. 2
Port_1269556_0 | SOURCEANDSINK | Baseino term. 2
Port_1269817_1 | SOURCEANDSINK | Baseino term. 2
Port_1269556_1 | SOURCEANDSINK | Baseino term. 2
Port_1269560_1 | SOURCEANDSINK | Baseino term. 2
InPort_1269560_1 | SINK | Baseino term. 2
OutPort_1269556_1 | SOURCE | Baseino term. 2
Port_1269569_0 | SOURCEANDSINK | Baseino term. 2
Port_1269861_2 | SOURCEANDSINK | Baseino term. 2
Port_1269569_1 | SOURCEANDSINK | Baseino term. 2
Port_1272004_2 | SOURCEANDSINK | Baseino term. 2
Port_1269571_0 | SOURCEANDSINK | Baseino term. 2
Port_1269861_1 | SOURCEANDSINK | Baseino term. 2
Port_1269571_1 | SOURCEANDSINK | Baseino term. 2
Port_1269575_1 | SOURCEANDSINK | Baseino term. 2
InPort_1269575_1 | SINK | Baseino term. 2
OutPort_1269571_1 | SOURCE | Baseino term. 2
Port_1269821_1 | SOURCEANDSINK | Baseino term. 2
Port_1272440_0 | SOURCEANDSINK | Baseino term. 2
Port_1269821_2 | SOURCEANDSINK | Baseino term. 2
Port_1269822_1 | SOURCEANDSINK | Baseino term. 2
Port_1269821_3 | SOURCEANDSINK | Baseino term. 2
Port_1272001_1 | SOURCEANDSINK | Baseino term. 2
Port_1269865_1 | SOURCEANDSINK | Baseino term. 2
Port_1272410_0 | SOURCEANDSINK | Baseino term. 2
Port_1269865_2 | SOURCEANDSINK | Baseino term. 2
Port_1269866_1 | SOURCEANDSINK | Baseino term. 2
Port_1269865_3 | SOURCEANDSINK | Baseino term. 2
Port_1272004_1 | SOURCEANDSINK | Baseino term. 2
Port_1270044_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1270046_1 | SOURCEANDSINK | Mechanical Supply Air 4
InPort_1271304_2 | SINK | Mechanical Return Air 1
OutPort_1271306_1 | SOURCE | Mechanical Return Air 1
Port_1271800_0 | SOURCEANDSINK | Baseino term. 2
Port_1271833_1 | SOURCEANDSINK | Baseino term. 2
Port_1271820_3 | SOURCEANDSINK | Baseino term. 2
Port_1286118_0 | SOURCEANDSINK | Baseino term. 2
Port_1271833_2 | SOURCEANDSINK | Baseino term. 2
Port_1271834_0 | SOURCEANDSINK | Baseino term. 2
Port_1271834_1 | SOURCEANDSINK | Baseino term. 2
Port_1282742_1 | SOURCEANDSINK | Baseino term. 2
Port_1271916_2 | SOURCEANDSINK | Baseino term. 2
Port_1273002_0 | SOURCEANDSINK | Baseino term. 2
Port_1272221_2 | SOURCEANDSINK | Baseino term. 2
Port_1272223_1 | SOURCEANDSINK | Baseino term. 2
Port_1272223_0 | SOURCEANDSINK | Baseino term. 2
Port_1273001_2 | SOURCEANDSINK | Baseino term. 2
Port_1272249_1 | SOURCEANDSINK | Baseino term. 2
Port_1272251_1 | SOURCEANDSINK | Baseino term. 2
Port_1272249_2 | SOURCEANDSINK | Baseino term. 2
Port_1273163_0 | SOURCEANDSINK | Baseino term. 2
Port_1272360_2 | SOURCEANDSINK | Baseino term. 2
Port_1272362_1 | SOURCEANDSINK | Baseino term. 2
Port_1272362_0 | SOURCEANDSINK | Baseino term. 2
Port_1286116_1 | SOURCEANDSINK | Baseino term. 2
Port_1272410_1 | SOURCEANDSINK | Baseino term. 2
Port_1272667_2 | SOURCEANDSINK | Baseino term. 2
Port_1272440_1 | SOURCEANDSINK | Baseino term. 2
Port_1272458_2 | SOURCEANDSINK | Baseino term. 2
Port_1272450_0 | SOURCEANDSINK | Baseino term. 2
Port_1272458_1 | SOURCEANDSINK | Baseino term. 2
Port_1272450_1 | SOURCEANDSINK | Baseino term. 2
Port_1272466_1 | SOURCEANDSINK | Baseino term. 2
Port_1272460_0 | SOURCEANDSINK | Baseino term. 2
Port_1286237_2 | SOURCEANDSINK | Baseino term. 2
Port_1272460_1 | SOURCEANDSINK | Baseino term. 2
Port_1272499_1 | SOURCEANDSINK | Baseino term. 2
Port_1272466_2 | SOURCEANDSINK | Baseino term. 2
Port_1272576_0 | SOURCEANDSINK | Baseino term. 2
Port_1272491_0 | SOURCEANDSINK | Baseino term. 2
Port_1272499_2 | SOURCEANDSINK | Baseino term. 2
Port_1272491_1 | SOURCEANDSINK | Baseino term. 2
Port_1272533_0 | SOURCEANDSINK | Baseino term. 2
Port_1272613_3 | SOURCEANDSINK | Baseino term. 2
Port_1272533_1 | SOURCEANDSINK | Baseino term. 2
Port_1272543_0 | SOURCEANDSINK | Baseino term. 2
Port_1272594_3 | SOURCEANDSINK | Baseino term. 2
Port_1272543_1 | SOURCEANDSINK | Baseino term. 2
Port_1272557_0 | SOURCEANDSINK | Baseino term. 2
Port_1272575_3 | SOURCEANDSINK | Baseino term. 2
Port_1272557_1 | SOURCEANDSINK | Baseino term. 2
Port_1272575_1 | SOURCEANDSINK | Baseino term. 2
Port_1272595_0 | SOURCEANDSINK | Baseino term. 2
Port_1272575_2 | SOURCEANDSINK | Baseino term. 2
Port_1272576_1 | SOURCEANDSINK | Baseino term. 2
Port_1272594_1 | SOURCEANDSINK | Baseino term. 2
Port_1286234_1 | SOURCEANDSINK | Baseino term. 2
Port_1272594_2 | SOURCEANDSINK | Baseino term. 2
Port_1272595_1 | SOURCEANDSINK | Baseino term. 2
Port_1272613_1 | SOURCEANDSINK | Baseino term. 2
Port_1286237_1 | SOURCEANDSINK | Baseino term. 2
Port_1272613_2 | SOURCEANDSINK | Baseino term. 2
Port_1272614_1 | SOURCEANDSINK | Baseino term. 2
Port_1272614_0 | SOURCEANDSINK | Baseino term. 2
Port_1286234_2 | SOURCEANDSINK | Baseino term. 2
Port_1272659_0 | SOURCEANDSINK | Baseino term. 2
Port_1272667_1 | SOURCEANDSINK | Baseino term. 2
Port_1272659_1 | SOURCEANDSINK | Baseino term. 2
Port_1272675_1 | SOURCEANDSINK | Baseino term. 2
Port_1272669_0 | SOURCEANDSINK | Baseino term. 2
Port_1272675_2 | SOURCEANDSINK | Baseino term. 2
Port_1272669_1 | SOURCEANDSINK | Baseino term. 2
Port_1272733_1 | SOURCEANDSINK | Baseino term. 2
Port_1272725_0 | SOURCEANDSINK | Baseino term. 2
Port_1272733_2 | SOURCEANDSINK | Baseino term. 2
Port_1272725_1 | SOURCEANDSINK | Baseino term. 2
Port_1272744_1 | SOURCEANDSINK | Baseino term. 2
Port_1272735_0 | SOURCEANDSINK | Baseino term. 2
Port_1272744_2 | SOURCEANDSINK | Baseino term. 2
Port_1272735_1 | SOURCEANDSINK | Baseino term. 2
Port_1272769_2 | SOURCEANDSINK | Baseino term. 2
Port_1272761_0 | SOURCEANDSINK | Baseino term. 2
Port_1272769_1 | SOURCEANDSINK | Baseino term. 2
Port_1272761_1 | SOURCEANDSINK | Baseino term. 2
Port_1272777_2 | SOURCEANDSINK | Baseino term. 2
Port_1272771_0 | SOURCEANDSINK | Baseino term. 2
Port_1286240_2 | SOURCEANDSINK | Baseino term. 2
Port_1272771_1 | SOURCEANDSINK | Baseino term. 2
Port_1272821_1 | SOURCEANDSINK | Baseino term. 2
Port_1272777_1 | SOURCEANDSINK | Baseino term. 2
Port_1272937_0 | SOURCEANDSINK | Baseino term. 2
Port_1272813_0 | SOURCEANDSINK | Baseino term. 2
Port_1272821_2 | SOURCEANDSINK | Baseino term. 2
Port_1272813_1 | SOURCEANDSINK | Baseino term. 2
Port_1272858_0 | SOURCEANDSINK | Baseino term. 2
Port_1272902_3 | SOURCEANDSINK | Baseino term. 2
Port_1272858_1 | SOURCEANDSINK | Baseino term. 2
Port_1272868_0 | SOURCEANDSINK | Baseino term. 2
Port_1272919_3 | SOURCEANDSINK | Baseino term. 2
Port_1272868_1 | SOURCEANDSINK | Baseino term. 2
Port_1272878_0 | SOURCEANDSINK | Baseino term. 2
Port_1272936_3 | SOURCEANDSINK | Baseino term. 2
Port_1272878_1 | SOURCEANDSINK | Baseino term. 2
Port_1272902_1 | SOURCEANDSINK | Baseino term. 2
Port_1286240_1 | SOURCEANDSINK | Baseino term. 2
Port_1272902_2 | SOURCEANDSINK | Baseino term. 2
Port_1272903_1 | SOURCEANDSINK | Baseino term. 2
Port_1272903_0 | SOURCEANDSINK | Baseino term. 2
Port_1286243_2 | SOURCEANDSINK | Baseino term. 2
Port_1272919_1 | SOURCEANDSINK | Baseino term. 2
Port_1286243_1 | SOURCEANDSINK | Baseino term. 2
Port_1272919_2 | SOURCEANDSINK | Baseino term. 2
Port_1272920_1 | SOURCEANDSINK | Baseino term. 2
Port_1272920_0 | SOURCEANDSINK | Baseino term. 2
Port_1272936_1 | SOURCEANDSINK | Baseino term. 2
Port_1272936_2 | SOURCEANDSINK | Baseino term. 2
Port_1272937_1 | SOURCEANDSINK | Baseino term. 2
Port_1272981_0 | SOURCEANDSINK | Baseino term. 2
Port_1273010_2 | SOURCEANDSINK | Baseino term. 2
Port_1272981_1 | SOURCEANDSINK | Baseino term. 2
Port_1273025_1 | SOURCEANDSINK | Baseino term. 2
Port_1273001_1 | SOURCEANDSINK | Baseino term. 2
Port_1273002_1 | SOURCEANDSINK | Baseino term. 2
Port_1273001_3 | SOURCEANDSINK | Baseino term. 2
Port_1273010_1 | SOURCEANDSINK | Baseino term. 2
Port_1273025_2 | SOURCEANDSINK | Baseino term. 2
Port_1273107_0 | SOURCEANDSINK | Baseino term. 2
Port_1273105_1 | SOURCEANDSINK | Baseino term. 2
Port_1273107_1 | SOURCEANDSINK | Baseino term. 2
OutPort_1273105_2 | SOURCE | Baseino term. 2
Port_1273154_0 | SOURCEANDSINK | Baseino term. 2
Port_1273171_2 | SOURCEANDSINK | Baseino term. 2
Port_1273154_1 | SOURCEANDSINK | Baseino term. 2
Port_1273182_1 | SOURCEANDSINK | Baseino term. 2
Port_1273162_2 | SOURCEANDSINK | Baseino term. 2
Port_1273163_1 | SOURCEANDSINK | Baseino term. 2
Port_1273162_3 | SOURCEANDSINK | Baseino term. 2
Port_1273171_1 | SOURCEANDSINK | Baseino term. 2
Port_1273182_2 | SOURCEANDSINK | Baseino term. 2
Port_1273211_0 | SOURCEANDSINK | Baseino term. 2
Port_1273209_1 | SOURCEANDSINK | Baseino term. 2
Port_1273211_1 | SOURCEANDSINK | Baseino term. 2
OutPort_1273209_2 | SOURCE | Baseino term. 2
Port_1282686_2 | SOURCEANDSINK | Baseino term. 2
Port_1282687_1 | SOURCEANDSINK | Baseino term. 2
Port_1282814_2 | SOURCEANDSINK | Baseino term. 2
Port_1282816_1 | SOURCEANDSINK | Baseino term. 2
Port_1282850_2 | SOURCEANDSINK | Baseino term. 2
Port_1282852_1 | SOURCEANDSINK | Baseino term. 2
Port_1286116_2 | SOURCEANDSINK | Baseino term. 2
Port_1286118_1 | SOURCEANDSINK | Baseino term. 2
Port_1286388_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286401_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286388_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286409_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286403_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286409_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286403_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286653_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286411_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286653_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286411_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286655_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286563_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1287026_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286563_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286601_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286576_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1287026_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286576_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286577_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286576_3 | SOURCEANDSINK | Hydronic Supply 1
Port_1287029_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286577_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1287020_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286591_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286601_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286591_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286611_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286603_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286611_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286603_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286619_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286613_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286619_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286613_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286647_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286645_0 | SOURCEANDSINK | Hydronic Supply 1
Port_1286647_2 | SOURCEANDSINK | Hydronic Supply 1
Port_1286645_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286655_1 | SOURCEANDSINK | Hydronic Supply 1
Port_1286717_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286742_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286742_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286757_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286751_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286757_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286751_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286956_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286759_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286956_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286759_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286958_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286851_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286852_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286851_2 | SOURCEANDSINK | Hydronic Return 2
Port_1287032_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286851_3 | SOURCEANDSINK | Hydronic Return 2
Port_1287035_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286852_0 | SOURCEANDSINK | Hydronic Return 2
Port_1287023_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286891_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286899_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286891_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286914_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286901_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286914_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286901_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286922_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286916_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286922_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286916_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286950_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286948_0 | SOURCEANDSINK | Hydronic Return 2
Port_1286950_2 | SOURCEANDSINK | Hydronic Return 2
Port_1286948_1 | SOURCEANDSINK | Hydronic Return 2
Port_1286958_1 | SOURCEANDSINK | Hydronic Return 2
InPort_1287332_0 | SINK | Mechanical Return Air 2
OutPort_1287347_2 | SOURCE | Mechanical Return Air 2
InPort_1287358_1 | SINK | Mechanical Return Air 2
OutPort_1287332_1 | SOURCE | Mechanical Return Air 2
InPort_1287450_1 | SINK | Mechanical Return Air 2
OutPort_1287332_2 | SOURCE | Mechanical Return Air 2
InPort_1287350_0 | SINK | Mechanical Return Air 2
OutPort_1287539_1 | SOURCE | Mechanical Return Air 2
InPort_1287418_2 | SINK | Mechanical Return Air 2
OutPort_1287350_1 | SOURCE | Mechanical Return Air 2
InPort_1287541_0 | SINK | Mechanical Return Air 2
OutPort_1287358_2 | SOURCE | Mechanical Return Air 2
InPort_1287414_1 | SINK | Mechanical Return Air 2
OutPort_1287416_1 | SOURCE | Mechanical Return Air 2
InPort_1287416_0 | SINK | Mechanical Return Air 2
OutPort_1287418_1 | SOURCE | Mechanical Return Air 2
InPort_1287437_0 | SINK | Mechanical Return Air 2
OutPort_1287450_2 | SOURCE | Mechanical Return Air 2
InPort_1287458_1 | SINK | Mechanical Return Air 2
OutPort_1287437_1 | SOURCE | Mechanical Return Air 2
InPort_1287452_0 | SINK | Mechanical Return Air 2
OutPort_1287479_1 | SOURCE | Mechanical Return Air 2
InPort_1287505_2 | SINK | Mechanical Return Air 2
OutPort_1287452_1 | SOURCE | Mechanical Return Air 2
InPort_1287481_0 | SINK | Mechanical Return Air 2
OutPort_1287458_2 | SOURCE | Mechanical Return Air 2
InPort_1287479_2 | SINK | Mechanical Return Air 2
OutPort_1287481_1 | SOURCE | Mechanical Return Air 2
InPort_1287501_1 | SINK | Mechanical Return Air 2
OutPort_1287503_1 | SOURCE | Mechanical Return Air 2
InPort_1287503_0 | SINK | Mechanical Return Air 2
OutPort_1287505_1 | SOURCE | Mechanical Return Air 2
InPort_1287539_2 | SINK | Mechanical Return Air 2
OutPort_1287541_1 | SOURCE | Mechanical Return Air 2
InPort_1287644_1 | SINK | Mechanical Outside Air 24
OutPort_1287649_0 | SOURCE | Mechanical Outside Air 24
InPort_1287648_1 | SINK | Mechanical Outside Air 24
OutPort_1287645_0 | SOURCE | Mechanical Outside Air 24
InPort_1287645_1 | SINK | Mechanical Outside Air 24
OutPort_1287647_1 | SOURCE | Mechanical Outside Air 24
InPort_1287647_1 | SINK | Mechanical Outside Air 24
OutPort_1287645_1 | SOURCE | Mechanical Outside Air 24
InPort_1287649_1 | SINK | Mechanical Outside Air 24
OutPort_1287648_2 | SOURCE | Mechanical Outside Air 24
InPort_1287776_0 | SINK | Mechanical Supply Air 2
OutPort_1287829_1 | SOURCE | Mechanical Supply Air 2
InPort_1287892_2 | SINK | Mechanical Supply Air 2
OutPort_1287776_1 | SOURCE | Mechanical Supply Air 2
InPort_1287831_0 | SINK | Mechanical Supply Air 2
OutPort_1287782_2 | SOURCE | Mechanical Supply Air 2
InPort_1287829_2 | SINK | Mechanical Supply Air 2
OutPort_1287831_1 | SOURCE | Mechanical Supply Air 2
InPort_1287886_1 | SINK | Mechanical Supply Air 2
OutPort_1287890_1 | SOURCE | Mechanical Supply Air 2
InPort_1287890_0 | SINK | Mechanical Supply Air 2
OutPort_1287892_1 | SOURCE | Mechanical Supply Air 2
InPort_1287927_1 | SINK | Mechanical Outside Air 6
OutPort_1287932_0 | SOURCE | Mechanical Outside Air 6
InPort_1287931_1 | SINK | Mechanical Outside Air 6
OutPort_1287928_0 | SOURCE | Mechanical Outside Air 6
InPort_1287928_1 | SINK | Mechanical Outside Air 6
OutPort_1287930_1 | SOURCE | Mechanical Outside Air 6
InPort_1287930_1 | SINK | Mechanical Outside Air 6
OutPort_1287928_1 | SOURCE | Mechanical Outside Air 6
InPort_1287932_1 | SINK | Mechanical Outside Air 6
OutPort_1287931_2 | SOURCE | Mechanical Outside Air 6
InPort_1288012_1 | SINK | Mechanical Outside Air 20
OutPort_1288010_2 | SOURCE | Mechanical Outside Air 20

# IfcFlowController: GLO_AIR_VENT:GLO_AIR_VENT-DN15 (2)
In: Level 1
Type - Material: <Unnamed>
Group: Baseino term. 2
Name (GLO_AIR_VENT:GLO_AIR_VENT-DN15:...)
1269560
1269575

# IfcFlowController: IMI_CV316_RGA___Slider_750_RFA_2022_LevelBased:CV316 RGA 3 way control valve DN50 Kvs40 PN16 bronze, IMI_CV316_RGA___Slider_750_RFA_2022_LevelBased:CV316 RGA 3 way control valve DN50 Kvs40 PN16 bronze:1243639
In: Level 1
Type - Material: <Unnamed>
Group: Baseino term. 2

# IfcFlowController: IMI_Hydronic_Engineering_CV316_RGA___Slider_750_RFA_2022_LevelBased:CV316 RGA 3 way control valve DN25 Kvs8 PN16 bronze, IMI_Hydronic_Engineering_CV316_RGA___Slider_750_RFA_2022_LevelBased:CV316 RGA 3 way control valve DN25 Kvs8 PN16 bronze:1259651
In: Level 1
Type - Material: <Unnamed>
Group: AHU 2

# IfcFlowController: IMI_Hydronic_Engineering_CV316_RGA___Slider_750_RFA_2022_LevelBased:CV316 RGA 3 way control valve DN50 Kvs31,5 PN16 bronze, IMI_Hydronic_Engineering_CV316_RGA___Slider_750_RFA_2022_LevelBased:CV316 RGA 3 way control valve DN50 Kvs31,5 PN16 bronze:1258949
In: Level 1
Type - Material: <Unnamed>
Group: AHU 2

# IfcFlowController: IMI_STAF-R_RFA_2022_LevelBased:STAF-R DN65 PN16, IMI_STAF-R_RFA_2022_LevelBased:STAF-R DN65 PN16:1286116
In: Level 1
Type - Material: MC_166_145_83_0_50, MC_171_141_69_0_50, MC_0_191_255_0_50, MC_166_0_0_0_50, MC_155_0_0_0_50
Group: Baseino term. 2

# IfcFlowController: IMI_TA-Comfort_WMC-HM-9340-03.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-03.836 (2)
Type - Material: MC_191_191_191_0_50, MC_238_238_238_0_50
Name (IMI_TA-Comfort_WMC-HM-9340-03.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-03.836:...) | In | Group
1066971 | Level 2 | Hydronic Supply 2; Hydronic Return 3
1217759 | 3A vėdinimas | Hydronic Supply 1; Hydronic Return 2

# IfcFlowController: IMI_TA-Comfort_WMC-HM-9340-06.836_RFA_2022_LevelBased (1):TA-Comfort WMC-HM-9340-06.836 (2)
In: Level 1
Type - Material: MC_191_191_191_0_50, MC_238_238_238_0_50
Name (IMI_TA-Comfort_WMC-HM-9340-06.836_RFA_2022_LevelBased (1):TA-Comfort WMC-HM-9340-06.836:...) | Group
1073472 | Hydronic Supply 1; Hydronic Return 2
1224334 | Hydronic Supply 2; Hydronic Return 3

# IfcFlowController: IMI_TA-Comfort_WMC-HM-9340-07.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-07.836 (2)
In: Level 2
Type - Material: MC_191_191_191_0_50, MC_238_238_238_0_50
Group: Hydronic Supply 1; Hydronic Return 2
Name (IMI_TA-Comfort_WMC-HM-9340-07.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-07.836:...)
1223080
1223517

# IfcFlowController: IMI_TA-Comfort_WMC-HM-9340-08.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-08.836, IMI_TA-Comfort_WMC-HM-9340-08.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-08.836:1226824
In: Level 2
Type - Material: MC_191_191_191_0_50, MC_238_238_238_0_50
Group: Hydronic Supply 1; Hydronic Return 2

# IfcFlowController: IMI_TA-Comfort_WMC-HM-9340-12.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-12.836 (3)
Type - Material: MC_191_191_191_0_50, MC_238_238_238_0_50
Name (IMI_TA-Comfort_WMC-HM-9340-12.836_RFA_2022_LevelBased:TA-Comfort WMC-HM-9340-12.836:...) | In | Group
1107324 | Level 1 | Hydronic Supply 1; Hydronic Return 2
1223374 | Level 2 | Hydronic Supply 2; Hydronic Return 3
1223999 | Level 1 | Hydronic Supply 1; Hydronic Return 2

# IfcFlowController: IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-20 (2)
In: Level 1
Type - Material: MC_191_191_191_0_50, MC_187_187_187_0_50, MC_255_0_0_0_50
Group: Baseino term. 2
Name (IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-20:...)
1273105
1273209

# IfcFlowController: IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-25 (4)
In: Level 1
Type - Material: MC_191_191_191_0_50, MC_187_187_187_0_50, MC_255_0_0_0_50
Group: AHU 2
Name (IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-25:...)
1259643
1259646
1259647
1259648

# IfcFlowController: IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-50 (4)
In: Level 1
Type - Material: MC_191_191_191_0_50, MC_187_187_187_0_50, MC_255_0_0_0_50
Group: AHU 2
Name (IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-50:...)
1258610
1258646
1258675
1258717

# IfcFlowController: IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-65 (4)
In: Level 1
Type - Material: MC_191_191_191_0_50, MC_187_187_187_0_50, MC_255_0_0_0_50
Group: Baseino term. 2
Name (IVR_S.p.A._IVR_954_RFA_2022_LevelBased (1):IVR 954-65:...)
1272221
1272249
1282814
1282850

# IfcFlowController: PKS_MANOMETER-VERT:Manometer-vert-DN20 (3)
In: Level 1
Type - Material: <Unnamed>, Default(1)
Group: Baseino term. 2
Name (PKS_MANOMETER-VERT:Manometer-vert-DN20:...)
1243711
1244379
1244453

# IfcFlowController: PKS_TERMOMETER-VERT:Manometer-vert-DN20 (4)
In: Level 1
Type - Material: <Unnamed>, Default(1)
Group: Baseino term. 2
Name (PKS_TERMOMETER-VERT:Manometer-vert-DN20:...)
1243450
1243704
1244091
1244531

# IfcFlowController: Tiemme_Tiemme_3660_RFA_2022_LevelBased:3500028, Tiemme_Tiemme_3660_RFA_2022_LevelBased:3500028:1272360
In: Level 1
Type - Material: <Unnamed>
Group: Baseino term. 2

# IfcFlowFitting: BKFU:BKFU (133)
Type - Material: <Unnamed>
Name (BKFU:BKFU:...) | In | Group
930092 | Level 2 | Mechanical Return Air 2
931599 | Level 1 | Mechanical Return Air 2
931696 | Level 1 | Mechanical Return Air 2
932333 | Level 1 | Mechanical Supply Air 2
932432 | Level 1 | Mechanical Supply Air 2
932548 | Level 1 | Mechanical Supply Air 2
932576 | Level 1 | Mechanical Return Air 2
957525 | Level 1 | Mechanical Return Air 2
968627 | Level 1 | Mechanical Return Air 2
968703 | Level 1 | Mechanical Return Air 2
968974 | Level 1 | Mechanical Supply Air 2
969224 | Level 1 | Mechanical Supply Air 2
969242 | Level 1 | Mechanical Supply Air 2
969434 | Level 1 | Mechanical Return Air 2
969483 | Level 1 | Mechanical Supply Air 2
969515 | Level 1 | Mechanical Supply Air 2
970253 | Level 2 | Mechanical Supply Air 2
970407 | Level 2 | Mechanical Supply Air 2
1001613 | Level 1 | Mechanical Return Air 2
1017222 | Level 1 | Mechanical Return Air 2
1017260 | Level 1 | Mechanical Return Air 2
1020173 | Level 2 | Mechanical Supply Air 2
1020208 | Level 2 | Mechanical Supply Air 2
1020309 | Level 2 | Mechanical Return Air 2
1021707 | Level 2 | Mechanical Return Air 2
1023859 | Level 1 | Mechanical Supply Air 2
1023909 | Level 1 | Mechanical Return Air 2
1023913 | Level 2 | Mechanical Return Air 2
1023961 | Level 1 | Mechanical Supply Air 2
1024492 | 3A vėdinimas | Mechanical Return Air 2
1025829 | Level 2 | Mechanical Return Air 2
1025892 | Level 2 | Mechanical Return Air 2
1026085 | Level 2 | Mechanical Supply Air 2
1026919 | Level 1 | Mechanical Supply Air 2
1027360 | Level 1 | Mechanical Return Air 2
1027400 | Level 1 | Mechanical Return Air 2
1027873 | Level 2 | Mechanical Return Air 2
1027877 | Level 2 | Mechanical Return Air 2
1029037 | 3A vėdinimas | Mechanical Return Air 2
1029524 | Level 2 | Mechanical Return Air 2
1029557 | Level 2 | Mechanical Return Air 2
1029593 | Level 2 | Mechanical Return Air 2
1029665 | Level 2 | Mechanical Return Air 2
1029669 | Level 2 | Mechanical Return Air 2
1029726 | Level 2 | Mechanical Return Air 2
1029745 | Level 2 | Mechanical Return Air 2
1029777 | Level 2 | Mechanical Return Air 2
1029882 | Level 2 | Mechanical Supply Air 2
1030141 | Level 1 | Mechanical Return Air 2
1030178 | Level 1 | Mechanical Return Air 2
1030191 | 3A vėdinimas | Mechanical Return Air 2
1031550 | Level 1 | Mechanical Outside Air 8
1032777 | Level 1 | Mechanical Supply Air 2
1033076 | Level 1 | Mechanical Return Air 2
1033096 | Level 1 | Mechanical Return Air 2
1076412 | Level 1 | Mechanical Return Air 2
1086644 | Level 1 | Mechanical Supply Air 2
1086753 | Level 1 | Mechanical Supply Air 2
1086757 | Level 1 | Mechanical Supply Air 2
1086995 | Level 1 | Mechanical Return Air 2
1095771 | 3A vėdinimas | Mechanical Return Air 2
1099704 | Level 1 | Mechanical Supply Air 2
1099724 | Level 1 | Mechanical Supply Air 2
1099759 | Level 1 | Mechanical Supply Air 2
1104038 | Level 1 | Mechanical Return Air 2
1104139 | Level 2 | Mechanical Return Air 2
1120521 | Level 1 | Mechanical Return Air 2
1120539 | Level 1 | Mechanical Return Air 2
1120713 | Level 1 | Mechanical Return Air 2
1120715 | Level 1 | Mechanical Return Air 2
1120744 | Level 1 | Mechanical Return Air 2
1123264 | Level 1 | Mechanical Supply Air 2
1145197 | Level 1 | Mechanical Supply Air 2
1145310 | Level 1 | Mechanical Supply Air 2
1145352 | Level 1 | Mechanical Supply Air 2
1145416 | Level 1 | Mechanical Supply Air 2
1173475 | Level 1 | Mechanical Supply Air 2
1174484 | Level 2 | Mechanical Supply Air 7
1174540 | Level 2 | Mechanical Supply Air 7
1174640 | Level 2 | Mechanical Supply Air 7
1175595 | Level 2 | Mechanical Return Air 2
1175681 | Level 2 | Mechanical Supply Air 2
1175759 | Level 2 | Mechanical Return Air 2
1175761 | 3A vėdinimas | Mechanical Return Air 2
1176029 | Level 2 | Mechanical Supply Air 4
1176077 | Level 2 | Mechanical Supply Air 4
1176191 | Level 2 | Mechanical Supply Air 4
1176257 | Level 2 | Mechanical Supply Air 4
1180307 | Level 2 | Mechanical Return Air 2
1180311 | Level 2 | Mechanical Return Air 2
1180558 | Level 2 | Mechanical Supply Air 2
1193875 | Level 1 | Mechanical Supply Air 2
1194350 | Level 2 | Mechanical Supply Air 7
1194405 | Level 2 | Mechanical Supply Air 7
1194407 | Level 2 | Mechanical Supply Air 7
1195622 | Level 1 | Mechanical Return Air 2
1195835 | Level 1 | Mechanical Return Air 2
1196158 | Level 1 | Mechanical Supply Air 2
1204048 | Level 1 | Mechanical Return Air 2
1210736 | Level 1 | Mechanical Return Air 2
1210801 | Level 1 | Mechanical Return Air 2
1210830 | Level 1 | Mechanical Return Air 2
1210834 | Level 1 | Mechanical Return Air 2
1210871 | Level 1 | Mechanical Return Air 2
1210909 | Level 1 | Mechanical Return Air 2
1211440 | Level 1 | Mechanical Supply Air 2
1211482 | Level 1 | Mechanical Supply Air 2
1211519 | Level 1 | Mechanical Supply Air 2
1211522 | Level 1 | Mechanical Supply Air 2
1215931 | Level 2 | Mechanical Supply Air 2
1215961 | Level 2 | Mechanical Supply Air 2
1215984 | Level 2 | Mechanical Supply Air 2
1216186 | Level 2 | Mechanical Return Air 2
1216287 | Level 2 | Mechanical Return Air 2
1216308 | Level 2 | Mechanical Return Air 2
1219111 | Level 1 | Mechanical Exhaust Air 1
1219123 | Level 1 | Mechanical Exhaust Air 1
1219206 | Level 1 | Mechanical Exhaust Air 1
1219217 | Level 1 | Mechanical Exhaust Air 1
1261776 | Level 1 | Mechanical Return Air 2
1261803 | Level 1 | Mechanical Supply Air 2
1261807 | Level 1 | Mechanical Supply Air 2
1262049 | Level 2 | Mechanical Supply Air 2
1262084 | Level 1 | Mechanical Supply Air 2
1267823 | Level 1 | Mechanical Supply Air 2
1267828 | Level 2 | Mechanical Supply Air 2
1267881 | Level 1 | Mechanical Supply Air 2
1267885 | Level 1 | Mechanical Supply Air 2
1287358 | Level 1 | Mechanical Return Air 2
1287418 | Level 1 | Mechanical Return Air 2
1287458 | Level 1 | Mechanical Return Air 2
1287505 | Level 1 | Mechanical Return Air 2
1287892 | Level 1 | Mechanical Supply Air 2

# IfcFlowFitting: M_Elbow - Generic:Standard (217)
Type - Material: <Unnamed>
Name (M_Elbow - Generic:Standard:...) | In | Group
1096277 | Level 1 | Hydronic Return 1
1098350 | 3A vėdinimas | Hydronic Return 1
1104577 | Level 1 | Hydronic Supply 1
1104642 | Level 1 | Hydronic Return 2
1108230 | Level 1 | Hydronic Supply 1
1108321 | Level 1 | Hydronic Return 2
1115023 | Level 2 | Hydronic Supply 1
1116516 | Level 2 | Hydronic Supply 2
1116543 | Level 2 | Hydronic Supply 2
1116819 | Level 1 | Hydronic Supply 2
1117430 | Level 2 | Hydronic Return 3
1117438 | Level 2 | Hydronic Return 3
1117525 | Level 1 | Hydronic Return 3
1118044 | Level 1 | Hydronic Supply 1
1118091 | Level 2 | Hydronic Supply 1
1118203 | Level 1 | Hydronic Supply 1
1118205 | Level 1 | Hydronic Supply 1
1118256 | Level 2 | Hydronic Return 2
1118260 | Level 1 | Hydronic Return 2
1118310 | Level 1 | Hydronic Return 2
1118328 | Level 1 | Hydronic Return 2
1118525 | Level 1 | Hydronic Return 2
1120132 | Level 2 | Hydronic Return 3
1120342 | Level 2 | Hydronic Supply 2
1140202 | Level 1 | VRF 2
1140210 | Level 1 | VRF 2
1140235 | Level 1 | VRF 2
1140275 | Level 1 | VRF 2
1140297 | Level 1 | VRF 2
1140320 | Level 1 | VRF 2
1140328 | Level 1 | VRF 2
1140359 | Level 1 | VRF 2
1140417 | Level 1 | VRF 2
1140421 | Level 1 | VRF 2
1145500 | Level 1 | Hydronic Return 1
1145508 | Level 1 | Hydronic Return 1
1145523 | Level 1 | Hydronic Return 1
1146006 | Level 1 | Hydronic Supply 1
1146030 | Level 1 | Hydronic Return 2
1146103 | Level 1 | Hydronic Return 2
1179621 | 3A vėdinimas | Hydronic Return 4
1179684 | 3A vėdinimas | VRF 2
1179692 | 3A vėdinimas | VRF 2
1179694 | 3A vėdinimas | VRF 2
1190952 | 3A vėdinimas | Hydronic Return 1
1190969 | 3A vėdinimas | Hydronic Return 1
1202819 | Level 2 | Hydronic Supply 2
1202825 | Level 2 | Hydronic Supply 2
1202849 | Level 1 | Hydronic Return 3
1202865 | Level 2 | Hydronic Return 3
1202869 | Level 2 | Hydronic Return 3
1202943 | Level 2 | Hydronic Return 3
1202959 | Level 2 | Hydronic Supply 2
1203329 | Level 2 | Hydronic Return 1
1203333 | Level 2 | Hydronic Return 1
1203337 | Level 2 | Hydronic Return 1
1203408 | Level 2 | Hydronic Supply 2
1203410 | Level 2 | Hydronic Supply 2
1203461 | Level 2 | Hydronic Return 3
1203532 | Level 2 | Hydronic Return 3
1203534 | Level 2 | Hydronic Return 3
1204409 | 3A vėdinimas | Hydronic Return 1
1204556 | Level 2 | Hydronic Return 1
1207489 | Level 1 | Hydronic Return 2
1207651 | Level 1 | Hydronic Supply 1
1207686 | Level 1 | Hydronic Return 2
1207752 | Level 1 | Hydronic Return 2
1207860 | 3A vėdinimas | Hydronic Return 1
1209609 | 3A vėdinimas | Hydronic Return 1
1209771 | 3A vėdinimas | Hydronic Return 1
1209856 | 3A vėdinimas | Hydronic Return 1
1210003 | 3A vėdinimas | Hydronic Return 1
1210042 | 3A vėdinimas | Hydronic Return 1
1210141 | 3A vėdinimas | Hydronic Return 1
1210146 | 3A vėdinimas | Hydronic Return 1
1210192 | 3A vėdinimas | Hydronic Return 1
1210321 | 3A vėdinimas | Hydronic Return 1
1210416 | 3A vėdinimas | Hydronic Return 1
1210935 | 3A vėdinimas | Hydronic Return 1
1210960 | 3A vėdinimas | Hydronic Return 1
1210999 | 3A vėdinimas | Hydronic Return 1
1211122 | 3A vėdinimas | Hydronic Return 1
1211188 | 3A vėdinimas | Hydronic Return 1
1211193 | Level 2 | Hydronic Return 1
1211259 | Level 1 | Hydronic Return 1
1211261 | Level 1 | Hydronic Return 1
1211295 | Level 1 | Hydronic Return 1
1211745 | 3A vėdinimas | Hydronic Return 1
1211749 | 3A vėdinimas | Hydronic Return 1
1211812 | 3A vėdinimas | Hydronic Return 1
1212688 | 3A vėdinimas | Hydronic Return 1
1217048 | Level 1 | Hydronic Return 1
1217050 | Level 1 | Hydronic Return 1
1217109 | Level 1 | Hydronic Return 1
1217400 | Level 1 | Hydronic Return 2
1217854 | 3A vėdinimas | Hydronic Return 2
1217924 | 3A vėdinimas | Hydronic Supply 1
1220135 | 3A vėdinimas | Hydronic Return 2
1223320 | Level 1 | Hydronic Supply 1
1223323 | Level 2 | Hydronic Supply 1
1223381 | Level 2 | Hydronic Supply 2
1223385 | Level 2 | Hydronic Return 3
1223441 | Level 2 | Hydronic Return 3
1223446 | Level 2 | Hydronic Return 3
1223472 | Level 2 | Hydronic Supply 2
1223477 | Level 2 | Hydronic Supply 2
1227508 | 3A vėdinimas | Hydronic Supply 1
1227513 | Level 2 | Hydronic Supply 1
1227630 | Level 2 | Hydronic Return 2
1227639 | Level 2 | Hydronic Return 2
1227644 | Level 2 | Hydronic Return 2
1227962 | Level 1 | Hydronic Return 3
1227992 | Level 1 | Hydronic Supply 2
1228113 | Level 1 | Hydronic Return 2
1228133 | Level 1 | Hydronic Supply 1
1228331 | Level 2 | Hydronic Return 2
1228355 | Level 2 | Hydronic Supply 1
1228455 | Level 2 | Hydronic Return 2
1228621 | Level 2 | Hydronic Supply 1
1228803 | Level 2 | Hydronic Return 2
1229015 | Level 2 | Hydronic Supply 1
1229251 | Level 1 | Hydronic Supply 1
1229301 | Level 1 | Hydronic Return 2
1229309 | Level 1 | Hydronic Return 2
1229389 | Level 1 | Hydronic Return 2
1229391 | Level 2 | Hydronic Return 2
1229415 | Level 1 | Hydronic Supply 1
1229417 | Level 2 | Hydronic Supply 1
1229488 | Level 2 | Hydronic Return 2
1243377 | Level 1 | Baseino term. 2
1243915 | Level 1 | Baseino term. 2
1244140 | Level 1 | Baseino term. 2
1244323 | Level 1 | Baseino term. 2
1244407 | Level 1 | Baseino term. 2
1244489 | Level 1 | Baseino term. 2
1244557 | Level 1 | Baseino term. 2
1245070 | Level 1 | Baseino term. 2
1245086 | Level 1 | Baseino term. 2
1245097 | Level 1 | Baseino term. 2
1245160 | Level 1 | Baseino term. 2
1245206 | Level 1 | Baseino term. 2
1245219 | Level 1 | Baseino term. 2
1245248 | Level 1 | Baseino term. 2
1254969 | Level 1 | Baseino term. 2
1254977 | Level 1 | Baseino term. 2
1254981 | Level 1 | Baseino term. 2
1255008 | Level 1 | Baseino term. 2
1255016 | Level 1 | Baseino term. 2
1255020 | Level 1 | Baseino term. 2
1258399 | Level 1 | AHU 2
1258423 | Level 1 | AHU 2
1258507 | Level 1 | AHU 2
1258533 | Level 1 | AHU 2
1258541 | Level 1 | AHU 2
1259203 | Level 1 | AHU 2
1259214 | Level 1 | AHU 2
1259292 | Level 1 | AHU 2
1259304 | Level 1 | AHU 2
1259334 | Level 1 | AHU 2
1259344 | Level 1 | AHU 2
1259853 | Level 1 | AHU 2
1259861 | Level 1 | AHU 2
1259902 | Level 1 | AHU 2
1259930 | Level 1 | AHU 2
1259941 | Level 1 | AHU 2
1259986 | Level 1 | AHU 2
1260063 | Level 1 | AHU 2
1260192 | Level 1 | AHU 2
1260232 | Level 1 | AHU 2
1260249 | Level 1 | AHU 2
1260255 | Level 1 | AHU 2
1260259 | Level 1 | AHU 2
1260552 | 3A vėdinimas | Hydronic Return 1
1260608 | 3A vėdinimas | Hydronic Return 1
1260619 | 3A vėdinimas | Hydronic Return 1
1269817 | Level 1 | Baseino term. 2
1269861 | Level 1 | Baseino term. 2
1271916 | Level 1 | Baseino term. 2
1272079 | Level 1 | Baseino term. 2
1272084 | Level 1 | Baseino term. 2
1272133 | Level 1 | Baseino term. 2
1272138 | Level 1 | Baseino term. 2
1272458 | Level 1 | Baseino term. 2
1272466 | Level 1 | Baseino term. 2
1272499 | Level 1 | Baseino term. 2
1272667 | Level 1 | Baseino term. 2
1272675 | Level 1 | Baseino term. 2
1272733 | Level 1 | Baseino term. 2
1272744 | Level 1 | Baseino term. 2
1272769 | Level 1 | Baseino term. 2
1272777 | Level 1 | Baseino term. 2
1272821 | Level 1 | Baseino term. 2
1273025 | Level 1 | Baseino term. 2
1273182 | Level 1 | Baseino term. 2
1286382 | Level 2 | Hydronic Supply 1
1286401 | Level 2 | Hydronic Supply 1
1286409 | Level 1 | Hydronic Supply 1
1286570 | Level 1 | Hydronic Supply 1
1286601 | Level 1 | Hydronic Supply 1
1286611 | Level 1 | Hydronic Supply 1
1286619 | Level 1 | Hydronic Supply 1
1286647 | Level 1 | Hydronic Supply 1
1286653 | Level 1 | Hydronic Supply 1
1286655 | Level 1 | Hydronic Supply 1
1286717 | Level 2 | Hydronic Return 2
1286757 | Level 1 | Hydronic Return 2
1286846 | Level 1 | Hydronic Return 2
1286899 | Level 1 | Hydronic Return 2
1286914 | Level 1 | Hydronic Return 2
1286922 | Level 1 | Hydronic Return 2
1286950 | Level 1 | Hydronic Return 2
1286956 | Level 1 | Hydronic Return 2
1286958 | Level 1 | Hydronic Return 2
1287204 | Level 1 | Hydronic Supply 1
1287209 | Level 1 | Hydronic Supply 1
1287253 | Level 1 | Hydronic Return 2
1287258 | Level 1 | Hydronic Return 2

# IfcFlowFitting: M_FabricAir_Round Elbow:Bend - 1x Diameter (7)
In: 3A vėdinimas
Type - Material: <Unnamed>
Group: Mechanical Supply Air 4
Name (M_FabricAir_Round Elbow:Bend - 1x Diameter:...)
1167790
1168609
1168749
1168751
1168913
1169039
1173232

# IfcFlowFitting: M_FabricAir_Round Endcap:Round Endcap, M_FabricAir_Round Endcap:Round Endcap:1168963
In: 3A vėdinimas
Type - Material: <Unnamed>
Group: Mechanical Supply Air 4

# IfcFlowFitting: M_Rectangular Elbow - Radius1:0.6 W (43)
Type - Material: <Unnamed>
Name (M_Rectangular Elbow - Radius1:0.6 W:...) | In | Group
955959 | Level 1 | Mechanical Return Air 2
956188 | Level 1 | Mechanical Supply Air 2
958433 | Level 1 | Mechanical Return Air 2
964441 | Level 1 | Mechanical Return Air 1
964602 | Level 1 | Mechanical Return Air 1
964660 | Level 1 | Mechanical Return Air 1
964683 | Level 1 | Mechanical Return Air 1
964745 | Level 1 | Mechanical Return Air 1
967117 | Level 1 | Mechanical Return Air 1
967374 | Level 2 | Mechanical Supply Air 4
1002740 | Level 2 | Mechanical Return Air 3
1002765 | Level 2 | Mechanical Return Air 3
1022823 | Level 1 | Mechanical Exhaust Air 2
1026240 | Level 2 | Mechanical Supply Air 2
1027327 | Level 1 | Mechanical Return Air 2
1027540 | Level 1 | Mechanical Supply Air 2
1027598 | Level 1 | Mechanical Supply Air 2
1031712 | Level 1 | Mechanical Exhaust Air 3
1031745 | Level 1 | Mechanical Exhaust Air 3
1031825 | Level 1 | Mechanical Exhaust Air 3
1077370 | Level 1 | Mechanical Return Air 2
1077380 | Level 1 | Mechanical Return Air 2
1077428 | Level 1 | Mechanical Supply Air 2
1078227 | Level 1 | Mechanical Return Air 2
1078303 | Level 1 | Mechanical Return Air 2
1095103 | 3A vėdinimas | Mechanical Return Air 2
1095721 | 3A vėdinimas | Mechanical Return Air 2
1123132 | Level 1 | Mechanical Supply Air 2
1123183 | Level 1 | Mechanical Supply Air 2
1145573 | Level 2 | Mechanical Supply Air 2
1146455 | Level 1 | Mechanical Return Air 2
1147268 | Level 2 | Mechanical Return Air 7
1169803 | Level 2 | Mechanical Supply Air 4
1186523 | Level 2 | Mechanical Supply Air 2
1186544 | Level 2 | Mechanical Return Air 2
1186703 | Level 1 | Mechanical Supply Air 2
1186729 | Level 1 | Mechanical Supply Air 2
1190664 | 3A vėdinimas | Mechanical Exhaust Air 3
1215265 | Level 1 | Mechanical Return Air 1
1215622 | Level 2 | Mechanical Supply Air 2
1215624 | Level 2 | Mechanical Supply Air 2
1265441 | Level 1 | Mechanical Return Air 2
1265468 | Level 1 | Mechanical Supply Air 2

# IfcFlowFitting: M_Rectangular Endcap:Standard (26)
Type - Material: <Unnamed>
Name (M_Rectangular Endcap:Standard:...) | In | Group
956300 | Level 1 | Mechanical Return Air 12
959020 | Level 1 | Mechanical Supply Air 2
962146 | Level 1 | Mechanical Return Air 12
963551 | Level 1 | Mechanical Outside Air 4
963553 | Level 1 | Mechanical Outside Air 1
963750 | Level 1 | Mechanical Outside Air 3
963752 | Level 1 | Mechanical Outside Air 3
964748 | Level 1 | Mechanical Return Air 1
964843 | Level 1 | Mechanical Return Air 1
964844 | Level 1 | Mechanical Return Air 1
965135 | Level 1 | Mechanical Exhaust Air 2
966670 | Level 1 | Mechanical Outside Air 7
1000902 | Level 2 | Mechanical Return Air 1
1001319 | Level 2 | Mechanical Return Air 1
1002573 | Level 2 | Mechanical Return Air 3
1022594 | Level 1 | Mechanical Outside Air 2
1022595 | Level 1 | Mechanical Outside Air 2
1026550 | Level 2 | Mechanical Return Air 2
1030676 | Level 1 | Mechanical Exhaust Air 2
1031764 | Level 1 | Mechanical Exhaust Air 3
1076783 | Level 1 | Mechanical Return Air 6
1076784 | Level 1 | Mechanical Return Air 6
1145628 | Level 2 | Mechanical Supply Air 2
1147631 | Level 2 | Mechanical Return Air 7
1216007 | Level 2 | Mechanical Supply Air 2
1216138 | 3A vėdinimas | Mechanical Return Air 2

# IfcFlowFitting: M_Rectangular Takeoff:Standard (5)
Type - Material: <Unnamed>
Name (M_Rectangular Takeoff:Standard:...) | In | Group
963402 | Level 1 | Mechanical Exhaust Air 4
1002718 | Level 2 | Mechanical Return Air 3
1027601 | Level 1 | Mechanical Supply Air 2
1030664 | Level 1 | Mechanical Exhaust Air 2
1193640 | Level 1 | Mechanical Return Air 2

# IfcFlowFitting: M_Rectangular Transition - Angle:45 Degree (4)
Type - Material: <Unnamed>
Name (M_Rectangular Transition - Angle:45 Degree:...) | In | Group
1052956 | Level 1 | Mechanical Supply Air 8
1186727 | Level 1 | Mechanical Supply Air 2
1193634 | Level 1 | Mechanical Return Air 2
1215625 | Level 2 | Mechanical Supply Air 2

# IfcFlowFitting: M_Rectangular Transition - Angle:60 Degree, M_Rectangular Transition - Angle:60 Degree:1022827
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 2

# IfcFlowFitting: M_Rectangular to Round Transition - Angle:45 Degree (6)
Type - Material: <Unnamed>
Name (M_Rectangular to Round Transition - Angle:45 Degree:...) | In | Group
957206 | Level 1 | Mechanical Supply Air 2
1095812 | Level 2 | Mechanical Supply Air 2
1168874 | Level 2 | Mechanical Supply Air 4
1173477 | Level 1 | Mechanical Supply Air 2
1195822 | Level 1 | Mechanical Return Air 2
1216144 | 3A vėdinimas | Mechanical Return Air 2

# IfcFlowFitting: M_Rectangular to Round Transition - Angle:60 Degree, M_Rectangular to Round Transition - Angle:60 Degree:1031555
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Outside Air 8

# IfcFlowFitting: M_Round Endcap:Standard (9)
Type - Material: <Unnamed>
Name (M_Round Endcap:Standard:...) | In | Group
969204 | Level 1 | Mechanical Supply Air 2
970196 | Level 2 | Mechanical Supply Air 2
974962 | Level 1 | Mechanical Supply Air 2
1020252 | Level 2 | Mechanical Supply Air 2
1025861 | Level 2 | Mechanical Return Air 2
1029612 | Level 2 | Mechanical Return Air 2
1029673 | Level 2 | Mechanical Return Air 2
1175223 | Level 2 | Mechanical Supply Air 7
1196210 | Level 1 | Mechanical Supply Air 2

# IfcFlowFitting: M_Round Takeoff:Standard (58)
Type - Material: <Unnamed>
Name (M_Round Takeoff:Standard:...) | In | Group
969097 | Level 1 | Mechanical Supply Air 2
969147 | Level 1 | Mechanical Supply Air 2
969202 | Level 1 | Mechanical Supply Air 2
970215 | Level 2 | Mechanical Supply Air 2
990901 | Level 1 | Mechanical Supply Air 2
1017257 | Level 1 | Mechanical Return Air 2
1020179 | Level 2 | Mechanical Supply Air 2
1020214 | Level 2 | Mechanical Supply Air 2
1021712 | Level 2 | Mechanical Return Air 2
1025898 | Level 2 | Mechanical Return Air 2
1026091 | Level 2 | Mechanical Supply Air 2
1026586 | Level 2 | Mechanical Return Air 2
1026923 | Level 1 | Mechanical Supply Air 2
1027365 | Level 1 | Mechanical Return Air 2
1029563 | Level 2 | Mechanical Return Air 2
1029599 | Level 2 | Mechanical Return Air 2
1029667 | Level 2 | Mechanical Return Air 2
1029671 | Level 2 | Mechanical Return Air 2
1029775 | Level 2 | Mechanical Return Air 2
1086527 | Level 1 | Mechanical Return Air 2
1086618 | Level 1 | Mechanical Supply Air 2
1087000 | Level 1 | Mechanical Return Air 2
1094964 | Level 2 | Mechanical Supply Air 2
1094968 | 3A vėdinimas | Mechanical Return Air 2
1120750 | Level 1 | Mechanical Return Air 2
1123269 | Level 1 | Mechanical Supply Air 2
1144305 | Level 1 | Mechanical Return Air 2
1144507 | Level 2 | Mechanical Return Air 2
1144610 | Level 2 | Mechanical Return Air 2
1169008 | 3A vėdinimas | Mechanical Supply Air 4
1169044 | 3A vėdinimas | Mechanical Supply Air 4
1175865 | Level 2 | Mechanical Supply Air 4
1176263 | Level 2 | Mechanical Supply Air 4
1179909 | Level 2 | Mechanical Supply Air 2
1179942 | Level 2 | Mechanical Supply Air 2
1180812 | Level 1 | Mechanical Supply Air 2
1193637 | Level 1 | Mechanical Return Air 2
1195684 | Level 1 | Mechanical Return Air 2
1204038 | Level 1 | Mechanical Return Air 2
1210704 | Level 1 | Mechanical Return Air 2
1210740 | Level 1 | Mechanical Return Air 2
1210875 | Level 1 | Mechanical Return Air 2
1210913 | Level 1 | Mechanical Return Air 2
1215879 | Level 2 | Mechanical Supply Air 2
1216059 | Level 2 | Mechanical Supply Air 2
1216101 | Level 2 | Mechanical Supply Air 2
1216250 | Level 2 | Mechanical Return Air 2
1216347 | Level 2 | Mechanical Return Air 2
1216380 | Level 2 | Mechanical Return Air 2
1261782 | Level 1 | Mechanical Return Air 2
1262082 | Level 1 | Mechanical Supply Air 2
1267866 | Level 1 | Mechanical Supply Air 2
1268281 | Level 2 | Mechanical Return Air 2
1268296 | Level 2 | Mechanical Return Air 2
1287347 | Level 1 | Mechanical Return Air 2
1287450 | Level 1 | Mechanical Return Air 2
1287709 | Level 1 | Mechanical Supply Air 2
1287782 | Level 1 | Mechanical Supply Air 2

# IfcFlowFitting: M_Round Transition - Angle:45 Degree (9)
Type - Material: <Unnamed>
Name (M_Round Transition - Angle:45 Degree:...) | In | Group
1017358 | Level 1 | Mechanical Return Air 2
1023856 | Level 1 | Mechanical Supply Air 2
1029742 | Level 2 | Mechanical Return Air 2
1086648 | Level 1 | Mechanical Supply Air 2
1144300 | Level 1 | Mechanical Return Air 2
1144561 | Level 2 | Mechanical Return Air 2
1145201 | Level 1 | Mechanical Supply Air 2
1180197 | Level 2 | Mechanical Return Air 2
1180892 | Level 1 | Mechanical Supply Air 2

# IfcFlowFitting: M_Tee - Generic:Standard (58)
Type - Material: <Unnamed>
Name (M_Tee - Generic:Standard:...) | In | Group
1118048 | Level 1 | Hydronic Supply 1
1118175 | Level 1 | Hydronic Supply 1
1118324 | Level 1 | Hydronic Return 2
1120065 | Level 2 | Hydronic Supply 2
1120128 | Level 2 | Hydronic Return 3
1120156 | Level 1 | Hydronic Supply 1
1120347 | Level 1 | Hydronic Supply 2
1120369 | Level 1 | Hydronic Return 3
1145981 | Level 1 | Hydronic Supply 1
1146107 | Level 1 | Hydronic Return 2
1203366 | Level 2 | Hydronic Supply 2
1203522 | Level 2 | Hydronic Return 3
1207537 | Level 1 | Hydronic Return 2
1207756 | Level 1 | Hydronic Return 2
1209826 | 3A vėdinimas | Hydronic Return 1
1210005 | 3A vėdinimas | Hydronic Return 1
1210246 | 3A vėdinimas | Hydronic Return 1
1210325 | 3A vėdinimas | Hydronic Return 1
1210346 | 3A vėdinimas | Hydronic Return 1
1210435 | 3A vėdinimas | Hydronic Return 1
1210939 | 3A vėdinimas | Hydronic Return 1
1210964 | 3A vėdinimas | Hydronic Return 1
1211023 | 3A vėdinimas | Hydronic Return 1
1211066 | Level 2 | Hydronic Return 1
