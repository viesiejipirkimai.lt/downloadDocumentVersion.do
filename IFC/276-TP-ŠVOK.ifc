Properties of the parts of a building model (IFC2X3), part 1 of 5

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: d68b49b4-8600-4959-a594-caa3d1fb3b51, NumberOfSaves: 1016], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: 276-TP-ŠVOK.ifc
Time: 2025-03-10T15:55:36
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (4)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 9300
Level 2 | Level 2 | 13200
3A vėdinimas | 3A vėdinimas | 17070
Stogas | Stogas | 19470

# IfcBuildingElementProxy: 45 laipsniu nuopjova 600x400:45 laipsniu nuopjova 600x400, 45 laipsniu nuopjova 600x400:45 laipsniu nuopjova 600x400:1189791
In: Stogas
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 3

# IfcBuildingElementProxy: Baseino sausintuvas 3000:Baseino sausintuvas 3000, Baseino sausintuvas 3000:Baseino sausintuvas 3000:960829
In: Level 1
Type - Material: <Unnamed>

# IfcBuildingElementProxy: GOLD F PX-14-AD-10001943704_1:GOLD F PX-14-AD-10001943704_1, GOLD F PX-14-AD-10001943704_1:GOLD F PX-14-AD-10001943704_1:1139991
In: Level 1
Type - Material: <Unnamed>

# IfcBuildingElementProxy: Grundfos_MAGNA1_RFA_2022_LevelBased:MAGNA1 50-60 F PN6 - 99221333, Grundfos_MAGNA1_RFA_2022_LevelBased:MAGNA1 50-60 F PN6 - 99221333:1252661
In: Level 1
Type - Material: MC_33_33_33_0_50, MC_221_221_221_0_50, MC_166_0_41_0_50, MC_84_84_84_0_50
Group: Baseino term. 2

# IfcBuildingElementProxy: HVAC-Indoor_AC-LG-Cassette_4_Way_2x2:By Type (17)
In: Level 1
Type - Classification: D3060300 Uniformat (Uniformat); Material: Metal - LG - Off White, Metal - Steel
Name (HVAC-Indoor_AC-LG-Cassette_4_Way_2x2:By Type:...) | Group
1085160 | Hydronic Return 1
1085226 | Hydronic Return 1
1085238 | Hydronic Return 1
1085287 | Hydronic Return 1
1085295 | Hydronic Return 3
1085817 | Hydronic Return 1
1085875 | Hydronic Return 1
1085885 | Hydronic Return 1
1086118 | Hydronic Return 1
1086126 | Hydronic Return 1
1086180 | Hydronic Return 1
1086207 | Hydronic Return 1
1096918 | Hydronic Return 1
1096987 | Hydronic Return 1
1097659 | Hydronic Return 1
1190768 | Hydronic Return 3
1207188 | Hydronic Return 1

# IfcBuildingElementProxy: HVAC-Outdoor-LG-MultiV_S_ARUM036GSS5:ARUM036GSS5 (2)
In: 3A vėdinimas
Type - Classification: D3040 Uniformat (Uniformat); Material: Metal - LG - Light Gray, Metal - LG - Light Tan, Metal - LG - Steel, Miscellaneous - LG - Clearance
Name (HVAC-Outdoor-LG-MultiV_S_ARUM036GSS5:ARUM036GSS5:...)
1179488
1260644 | Group: Other 1

# IfcBuildingElementProxy: Halton_EFC_RFA_2022_LevelBased:EFC-100 (8)
Type - Material: <Unnamed>
Name (Halton_EFC_RFA_2022_LevelBased:EFC-100:...) | In | Group
1266934 | Level 1 | Mechanical Outside Air 12
1267023 | Level 1 | Mechanical Outside Air 5
1267665 | Level 1 | Mechanical Outside Air 10
1267715 | Level 1 | Mechanical Outside Air 13
1267744 | Level 1 | Mechanical Outside Air 18
1268038 | Level 2 | Mechanical Outside Air 21
1287648 | Level 2 | Mechanical Outside Air 24
1288010 | Level 2 | Mechanical Outside Air 20

# IfcBuildingElementProxy: Halton_EFC_RFA_2022_LevelBased:EFC-125 (12)
Type - Material: <Unnamed>
Name (Halton_EFC_RFA_2022_LevelBased:EFC-125:...) | In | Group
1175109 | Level 2 | Mechanical Supply Air 7
1261845 | Level 1 | Mechanical Supply Air 7
1261914 | Level 1 | Mechanical Return Air 2
1261969 | Level 1 | Mechanical Return Air 2
1262156 | Level 1 | Mechanical Supply Air 2
1262175 | Level 1 | Mechanical Supply Air 2
1266903 | Level 1 | Mechanical Outside Air 11
1267187 | Level 1 | Mechanical Outside Air 14
1267211 | Level 1 | Mechanical Outside Air 15
1267218 | Level 1 | Mechanical Outside Air 17
1267517 | Level 2 | Mechanical Supply Air 2
1287931 | Level 1 | Mechanical Outside Air 6

# IfcBuildingElementProxy: Halton_EFC_RFA_2022_LevelBased:EFC-160 (10)
Type - Material: <Unnamed>
Name (Halton_EFC_RFA_2022_LevelBased:EFC-160:...) | In | Group
981188 | Level 1 | Mechanical Return Air 2
1261045 | Level 1 | Mechanical Return Air 2
1261070 | Level 1 | Mechanical Supply Air 2
1261587 | Level 1 | Mechanical Return Air 2
1261606 | Level 1 | Mechanical Supply Air 2
1265626 | Level 1 | Mechanical Supply Air 2
1267250 | Level 1 | Mechanical Outside Air 16
1267257 | Level 1 | Mechanical Outside Air 19
1267480 | Level 2 | Mechanical Return Air 2
1268064 | Level 2 | Mechanical Outside Air 22

# IfcBuildingElementProxy: Halton_EFC_RFA_2022_LevelBased:EFC-200 (7)
Type - Material: <Unnamed>
Name (Halton_EFC_RFA_2022_LevelBased:EFC-200:...) | In | Group
1179964 | Level 2 | Mechanical Return Air 2
1181011 | Level 2 | Mechanical Supply Air 2
1186422 | Level 2 | Mechanical Supply Air 2
1265487 | Level 1 | Mechanical Supply Air 2
1267899 | Level 2 | Mechanical Supply Air 2
1267942 | Level 2 | Mechanical Supply Air 2
1267957 | Level 2 | Mechanical Supply Air 2

# IfcBuildingElementProxy: Lindab_DJP_RFA_2022_LevelBased (1):DJP 1200x1400, Lindab_DJP_RFA_2022_LevelBased (1):DJP 1200x1400:1271304
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Return Air 1

# IfcBuildingElementProxy: Swegon_AB_CADENZA_1447_length=2450_mm_RFA_2022_LevelBased:Stačiakampis triukšmo slopintuvas 1447-1400x1000, l=2450, Swegon_AB_CADENZA_1447_length=2450_mm_RFA_2022_LevelBased:Stačiakampis triukšmo slopintuvas 1447-1400x1000, l=2450:995232
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 2

# IfcBuildingElementProxy: Swegon_AB_CADENZA_1637_length=1850_mm_RFA_2022_LevelBased:Stačiakampis triukšmo slopintuvas 1600x1000, l=1850 (4)
In: Level 1
Type - Material: <Unnamed>
Name (Swegon_AB_CADENZA_1637_length=1850_mm_RFA_2022_LevelBased:Stačiakampis triukšmo slopintuvas 1600x1000, l=1850:...) | Group
1170882 | Mechanical Return Air 1
1171437 | Mechanical Return Air 1
1171589 | Mechanical Supply Air 4
1171736 | Mechanical Supply Air 4

# IfcBuildingElementProxy: Swegon_AB_CADENZA_636_length=1850_mm_RFA_2022_LevelBased:Triukšmo slopintuvas 600x400, l=1850 (2)
In: Level 1
Type - Material: <Unnamed>
Name (Swegon_AB_CADENZA_636_length=1850_mm_RFA_2022_LevelBased:Triukšmo slopintuvas 600x400, l=1850:...) | Group
1123083 | Mechanical Supply Air 2
1146535 | Mechanical Return Air 2

# IfcBuildingElementProxy: Swegon_AB_CRTc_RFA_2022_LevelBased:CRTc 125 (2)
In: Level 1
Type - Material: <Unnamed>
Name (Swegon_AB_CRTc_RFA_2022_LevelBased:CRTc 125:...) | Group
1200580 | Mechanical Supply Air 9
1208352 | Mechanical Return Air 8

# IfcBuildingElementProxy: Swegon_AB_CRTc_RFA_2022_LevelBased:Motorizuota uždarymo sklendė (plastikinė) d200, NC, Swegon_AB_CRTc_RFA_2022_LevelBased:Motorizuota uždarymo sklendė (plastikinė) d200, NC:1219427
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 1

# IfcBuildingElementProxy: Swegon_AB_LARGOa_0736_I U_=300_mm_RFA_2022_LevelBased:Kampinis triukšmo slopintuvas 700-2200-300, Swegon_AB_LARGOa_0736_I U_=300_mm_RFA_2022_LevelBased:Kampinis triukšmo slopintuvas 700-2200-300:1172902
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Outside Air 9

# IfcBuildingElementProxy: Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 125 (18)
Type - Material: <Unnamed>
Name (Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 125:...) | In | Group
973453 | Level 1 | Mechanical Return Air 2
973480 | Level 1 | Mechanical Return Air 2
973529 | Level 1 | Mechanical Return Air 2
973544 | Level 1 | Mechanical Return Air 2
974661 | Level 1 | Mechanical Supply Air 2
974770 | Level 1 | Mechanical Return Air 2
974797 | Level 1 | Mechanical Return Air 2
987446 | Level 1 | Mechanical Supply Air 2
987493 | Level 1 | Mechanical Return Air 2
1017873 | Level 2 | Mechanical Supply Air 2
1020311 | Level 2 | Mechanical Return Air 2
1027896 | Level 2 | Mechanical Return Air 2
1086667 | Level 1 | Mechanical Supply Air 2
1175315 | Level 2 | Mechanical Supply Air 7
1180272 | Level 2 | Mechanical Return Air 2
1195713 | Level 1 | Mechanical Return Air 2
1268218 | Level 2 | Mechanical Return Air 2
1287479 | Level 1 | Mechanical Return Air 2

# IfcBuildingElementProxy: Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 160 (9)
Type - Material: <Unnamed>
Name (Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 160:...) | In | Group
970631 | Level 2 | Mechanical Supply Air 2
974710 | Level 1 | Mechanical Return Air 2
975038 | Level 1 | Mechanical Supply Air 2
987778 | Level 1 | Mechanical Return Air 2
1023626 | Level 1 | Mechanical Return Air 2
1024885 | 3A vėdinimas | Mechanical Return Air 2
1268196 | Level 2 | Mechanical Return Air 2
1287539 | Level 1 | Mechanical Return Air 2
1287829 | Level 1 | Mechanical Supply Air 2

# IfcBuildingElementProxy: Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 200 (15)
Type - Material: <Unnamed>
Name (Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 200:...) | In | Group
974684 | Level 1 | Mechanical Supply Air 2
987656 | Level 2 | Mechanical Supply Air 2
987713 | Level 2 | Mechanical Supply Air 2
989040 | Level 1 | Mechanical Supply Air 2
1017217 | Level 1 | Mechanical Return Air 2
1020273 | Level 2 | Mechanical Supply Air 2
1029630 | Level 2 | Mechanical Return Air 2
1029790 | Level 2 | Mechanical Return Air 2
1204087 | Level 1 | Mechanical Return Air 2
1215808 | Level 2 | Mechanical Supply Air 2
1215956 | Level 2 | Mechanical Supply Air 2
1215979 | Level 2 | Mechanical Supply Air 2
1216181 | Level 2 | Mechanical Return Air 2
1216282 | Level 2 | Mechanical Return Air 2
1216303 | Level 2 | Mechanical Return Air 2

# IfcBuildingElementProxy: Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 250, Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 250:974736
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Supply Air 2

# IfcBuildingElementProxy: Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 315 (3)
Type - Material: <Unnamed>
Name (Swegon_AB_SIRIa_RFA_2019_LevelBased:SIRIa 315:...) | In | Group
1000159 | Level 1 | Mechanical Supply Air 2
1176214 | Level 2 | Mechanical Supply Air 4
1196074 | Level 1 | Mechanical Return Air 2

# IfcBuildingElementProxy: Swegon_AB_SORDO-A_Class_EI30_EI60__L=_800_mm_RFA_2022_LevelBased (4):Triukšmo slopintuvas d160, l=800, Swegon_AB_SORDO-A_Class_EI30_EI60__L=_800_mm_RFA_2022_LevelBased (4):Triukšmo slopintuvas d160, l=800:1146499
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Return Air 2

# IfcBuildingElementProxy: Swegon_AB_SORDO-A__Class_EI30_EI60_L=1100_mm_RFA_2022_LevelBased (2):Triukšmo slopintuvas d315, l=1100, Swegon_AB_SORDO-A__Class_EI30_EI60_L=1100_mm_RFA_2022_LevelBased (2):Triukšmo slopintuvas d315, l=1100:1121680
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Return Air 2

# IfcBuildingElementProxy: Systemair_FDR-3G-_-G()_RFA_2022_LevelBased (1):FDR-3G-250-G(), Systemair_FDR-3G-_-G()_RFA_2022_LevelBased (1):FDR-3G-250-G():1180004
In: Level 2
Type - Material: MC_84_84_84_0_50, MC_187_187_187_0_50, MC_152_152_152_0_50
Group: Mechanical Return Air 2

# IfcBuildingElementProxy: Systemair_FDR-3G-_-G()_RFA_2022_LevelBased (1):FDR-3G-315-G() (6)
In: Level 1
Type - Material: MC_84_84_84_0_50, MC_187_187_187_0_50, MC_152_152_152_0_50
Name (Systemair_FDR-3G-_-G()_RFA_2022_LevelBased (1):FDR-3G-315-G():...) | Group
983901 | Mechanical Return Air 2
983920 | Mechanical Supply Air 2
1030234 | Mechanical Return Air 2
1265284 | Mechanical Return Air 2
1265305 | Mechanical Supply Air 2
1265577 | Mechanical Return Air 2

# IfcBuildingElementProxy: Systemair_K_RFA_2022_LevelBased (1):K 125 M sileo 50Hz, Systemair_K_RFA_2022_LevelBased (1):K 125 M sileo 50Hz:1202225
In: Level 1
Type - Material: MC_128_128_128_0_50, MC_187_187_187_0_50
Group: Mechanical Return Air 8

# IfcBuildingElementProxy: Systemair_K_RFA_2022_LevelBased (1):K 200 L sileo 50Hz, Systemair_K_RFA_2022_LevelBased (1):K 200 L sileo 50Hz:1219698
In: Level 1
Type - Material: MC_128_128_128_0_50, MC_187_187_187_0_50
Group: Mechanical Exhaust Air 1

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-1400x1000-BST, Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-1400x1000-BST:987031
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Exhaust Air 2

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-1600x1000-BST (3)
Type - Material: <Unnamed>
Name (Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-1600x1000-BST:...) | In | Group
987058 | Level 1 | Mechanical Supply Air 4
987077 | Level 1 | Mechanical Return Air 1
1270044 | Level 2 | Mechanical Supply Air 4

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-300x200-BST (4)
Type - Material: <Unnamed>
Name (Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-300x200-BST:...) | In | Group
1268410 | Level 2 | Mechanical Supply Air 2
1268437 | 3A vėdinimas | Mechanical Return Air 2
1268560 | Level 2 | Mechanical Supply Air 2
1268591 | 3A vėdinimas | Mechanical Return Air 2

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-400x200-BST (3)
In: Level 2
Type - Material: <Unnamed>
Name (Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-400x200-BST:...) | Group
1180037 | Mechanical Supply Air 2
1186376 | Mechanical Supply Air 2
1186398 | Mechanical Return Air 2

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-400x300-BST, Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-400x300-BST:1265504
In: Level 1
Type - Material: <Unnamed>
Group: Mechanical Supply Air 2

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-600x400-BST (5)
In: Level 1
Type - Material: <Unnamed>
Name (Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-600x400-BST:...) | Group
1051971 | Mechanical Return Air 2
1051985 | Mechanical Supply Air 2
1147114 | Mechanical Exhaust Air 3
1265370 | Mechanical Supply Air 2
1265385 | Mechanical Return Air 2

# IfcBuildingElementProxy: Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-800x300-BST, Systemair_S-SA2-_-BST_RFA_2022_LevelBased (2):S-SA2-800x300-BST:1268950
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Return Air 3

# IfcBuildingElementProxy: Systemair_TUNE-S-_-M0_RFA_2022_LevelBased (6):TUNE-S-200x100-M0, Systemair_TUNE-S-_-M0_RFA_2022_LevelBased (6):TUNE-S-200x100-M0:1175042
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Supply Air 1

# IfcBuildingElementProxy: Systemair_TUNE-S-_-M0_RFA_2022_LevelBased (6):TUNE-S-300x300-M0, Systemair_TUNE-S-_-M0_RFA_2022_LevelBased (6):TUNE-S-300x300-M0:1147672
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Return Air 7

# IfcBuildingElementProxy: Systemair_TUNE-S-_-M0_RFA_2022_LevelBased (6):TUNE-S-800x300-M0, Systemair_TUNE-S-_-M0_RFA_2022_LevelBased (6):TUNE-S-800x300-M0:1004646
In: Level 2
Type - Material: <Unnamed>
Group: Mechanical Return Air 3

# IfcBuildingElementProxy: VEAB_PGV_4-2.5_RFA_2022_LevelBased:PGV 400x200-4-2.5, VEAB_PGV_4-2.5_RFA_2022_LevelBased:PGV 400x200-4-2.5:1188571
In: Level 2
Type - Material: MC_191_191_191_0_50
Group: Mechanical Supply Air 2

# IfcCovering: Duct Insulation:Duct Wrap (152)
Type - PredefinedType: INSULATION
Material: Insulation - Duct Wrap
Name (Duct Insulation:Duct Wrap:...) | In
964952 | Level 1
964955 | Level 1
964959 | Level 1
964960 | Level 1
965583 | Level 1
965584 | Level 1
966083 | Level 1
966085 | Level 1
968039 | Level 1
968040 | Level 1
968041 | Level 1
968042 | Level 1
968043 | Level 1
968044 | Level 1
968045 | Level 1
968046 | Level 1
968048 | Level 1
968049 | Level 1
968050 | Level 1
968051 | Level 1
968052 | Level 1
968054 | Level 1
968059 | 3A vėdinimas
968061 | 3A vėdinimas
968062 | 3A vėdinimas
973436 | Level 1
973437 | Level 1
973439 | Level 1
973441 | Level 1
973445 | Level 1
987037 | Level 1
987063 | Level 2
987081 | Level 1
994166 | Level 2
1000894 | Level 2
1000904 | Level 2
1001321 | Level 2
1002574 | Level 2
1002788 | Level 2
1002789 | Level 2
1002790 | Level 2
1002791 | Level 2
1002792 | Level 2
1002793 | Level 2
1004649 | Level 2
1004650 | Level 2
1022605 | Level 1
1022606 | Level 1
1022607 | Level 1
1022686 | Level 1
1022825 | Level 1
1022826 | Level 1
1022829 | Level 1
1030678 | 3A vėdinimas
1031554 | Level 1
1031557 | Level 1
1052958 | Level 1
1103936 | Level 2
1103937 | Level 2
1103938 | Level 1
1103939 | Level 2
1103940 | Level 2
1143287 | Level 2
1169805 | 3A vėdinimas
1170929 | Level 1
1170930 | Level 1
1171464 | Level 2
1171465 | Level 2
1171648 | Level 2
1171649 | Level 2
1171771 | Level 1
1171772 | Level 1
1173014 | Level 1
1173015 | Level 1
1173974 | Level 1
1173975 | Level 1
1173976 | Level 1
1173977 | Level 1
1173978 | Level 1
1173979 | Level 1
1173982 | Level 1
1173983 | Level 1
1173985 | Level 1
1173986 | Level 1
1173987 | Level 1
1173989 | Level 1
1173991 | Level 1
1173992 | Level 1
1173993 | Level 1
1173994 | Level 1
1173995 | Level 1
1173996 | Level 1
1173997 | Level 1
1173998 | Level 1
1173999 | Level 1
1174000 | Level 1
1174001 | Level 1
1174002 | Level 1
1174003 | Level 1
1174004 | Level 1
1174005 | Level 1
1174006 | Level 1
1174007 | Level 1
1174008 | Level 1
1174009 | Level 1
1174010 | Level 1
1174011 | Level 1
1174012 | Level 1
1174013 | Level 1
1174014 | Level 1
1174015 | Level 1
1174016 | Level 1
1174134 | Level 1
1174135 | Level 1
1174136 | Level 1
1174137 | Level 1
1174138 | Level 1
1174139 | Level 1
1174140 | Level 1
1174141 | Level 1
1174142 | Level 1
1174143 | Level 1
1193407 | Level 2
1196295 | Level 1
1196296 | Level 1
1196297 | Level 1
1196298 | Level 1
1208414 | Level 1
1208415 | Level 1
1208416 | Level 1
1208417 | Level 1
1208418 | Level 1
1208419 | Level 1
1208641 | Level 1
1208642 | Level 1
1208643 | Level 1
1208644 | Level 1
1208645 | Level 1
1208646 | Level 1
1208647 | Level 1
1208648 | Level 1
1215176 | Level 2
1215207 | 3A vėdinimas
1215267 | 3A vėdinimas
1265443 | Level 1
1265470 | Level 1
1268969 | Level 2
1268971 | Level 2
1270047 | 3A vėdinimas
1270049 | 3A vėdinimas
1271307 | Level 2
1271308 | Level 2

# IfcCovering: Pipe Insulation:Fiberglass (542)
Type - PredefinedType: INSULATION
Material: Insulation - Fiberglass
Name (Pipe Insulation:Fiberglass:...) | In
1143299 | Level 1
1143300 | Level 1
1143301 | Level 1
1143302 | Level 1
1143303 | Level 1
1143304 | Level 1
1143305 | Level 1
1143306 | Level 1
1143308 | Level 1
1143309 | Level 1
1143310 | Level 1
1143311 | Level 1
1143312 | Level 1
1143313 | Level 1
1143314 | Level 1
1143317 | Level 1
1143318 | Level 1
1143320 | Level 1
1143321 | Level 1
1143322 | Level 1
1143336 | Level 2
1143340 | Level 2
1143370 | Level 2
1143371 | Level 1
1143372 | Level 2
1143373 | Level 1
1143374 | Level 1
1143385 | Level 1
1143386 | Level 1
1143388 | Level 1
1143389 | Level 1
1143391 | Level 2
1143392 | Level 2
1143393 | Level 2
1143394 | Level 1
1143395 | Level 1
1143396 | Level 1
1143397 | Level 1
1143399 | Level 2
1143410 | Level 2
1143420 | Level 1
1143421 | Level 2
1143422 | Level 1
1143423 | Level 1
1143424 | Level 1
1143427 | Level 1
1143432 | Level 1
1143433 | Level 1
1143434 | Level 1
1143435 | Level 1
1143436 | Level 1
1143437 | Level 1
1143439 | Level 1
1143440 | Level 1
1143441 | Level 1
1143442 | Level 1
1143443 | Level 1
1143444 | Level 1
1143445 | Level 1
1143446 | Level 1
1143447 | Level 1
1143448 | Level 1
1143449 | Level 1
1143451 | Level 1
1143457 | Level 1
1143466 | Level 2
1143495 | Level 1
1143504 | Level 1
1143506 | Level 1
1143507 | Level 1
1143508 | Level 1
1143509 | Level 1
1143512 | Level 1
1143514 | Level 1
1143515 | Level 1
1143516 | Level 1
1143517 | Level 1
1143518 | Level 1
1143519 | Level 1
1143522 | Level 1
1143523 | Level 1
1143524 | Level 1
1143525 | Level 1
1143526 | Level 1
1143527 | Level 1
1143528 | Level 1
1143529 | Level 1
1143530 | Level 1
1143531 | Level 1
1146196 | Level 1
1146198 | Level 1
1146206 | Level 1
1146207 | Level 1
1146208 | Level 1
1146209 | Level 1
1146211 | Level 1
1146215 | Level 1
1146217 | Level 1
1146218 | Level 1
1202824 | Level 2
1202827 | Level 2
1202853 | Level 2
1202867 | Level 2
1202868 | Level 2
1202871 | Level 2
1203369 | Level 2
1203371 | Level 2
1203525 | Level 2
1203527 | Level 2
1203546 | Level 2
1203547 | Level 2
1203548 | Level 2
1203549 | Level 2
1203550 | Level 2
1203551 | Level 2
1203552 | Level 2
1203553 | Level 2
1203554 | Level 2
1203555 | Level 2
1203556 | Level 2
1203557 | Level 2
1203558 | Level 2
1203559 | Level 2
1203560 | Level 2
1203561 | Level 2
1207491 | Level 1
1207540 | Level 1
1207542 | Level 1
1207653 | Level 1
1207766 | Level 1
1207767 | Level 1
1207768 | Level 1
1207769 | Level 1
1207770 | Level 1
1207771 | Level 1
1207772 | Level 1
1207773 | Level 1
1207774 | Level 1
1217772 | 3A vėdinimas
1217773 | Level 2
1217775 | 3A vėdinimas
1217776 | Level 2
1217858 | Level 2
1217926 | 3A vėdinimas
1220139 | 3A vėdinimas
1223070 | Level 2
1223071 | Level 1
1223072 | Level 2
1223073 | Level 1
1223258 | Level 1
1223322 | Level 1
1223327 | Level 1
1223387 | Level 2
1223388 | Level 2
1223389 | Level 1
1223390 | Level 2
1223391 | Level 1
1223392 | Level 2
1223445 | Level 1
1223450 | Level 1
1223476 | Level 1
1223481 | Level 1
1227512 | Level 2
1227515 | Level 2
1227537 | 3A vėdinimas
1227540 | 3A vėdinimas
1227632 | Level 2
1227633 | Level 2
1227643 | Level 2
1227648 | Level 2
1227744 | Level 1
1227747 | Level 1
1227754 | Level 1
1227757 | Level 1
1227790 | Level 1
1227793 | Level 1
1227836 | Level 2
1227839 | Level 2
1227876 | Level 2
1227879 | Level 2
1227888 | Level 1
1227891 | Level 1
1227894 | Level 1
1227897 | Level 1
1227914 | Level 1
1227917 | Level 1
1227920 | Level 1
1227923 | Level 1
1227966 | Level 1
1227996 | Level 1
1228117 | Level 1
1228137 | Level 1
1228459 | Level 2
1228625 | Level 2
1229242 | Level 1
1229244 | Level 1
1229429 | Level 1
1229430 | Level 1
1229431 | Level 1
1229432 | Level 1
1229433 | Level 1
1229434 | Level 1
1229435 | Level 2
1229436 | Level 1
1229437 | Level 2
1229438 | Level 1
1229440 | Level 2
1229441 | Level 2
1229442 | Level 1
1229443 | Level 1
1229444 | Level 1
1229445 | Level 1
1229446 | Level 1
1229447 | Level 1
1229448 | Level 1
1229449 | Level 1
1229450 | Level 1
1229451 | Level 1
1229452 | Level 1
1229453 | Level 1
1229454 | Level 1
1229455 | Level 1
1229456 | Level 1
1229457 | Level 1
1229492 | Level 1
1229496 | Level 1
1229499 | Level 1
1257682 | Level 1
1257683 | Level 1
1257685 | Level 1
1257686 | Level 1
1257689 | Level 1
1257690 | Level 1
1257692 | Level 1
1257693 | Level 1
1257695 | Level 1
1257696 | Level 1
1257698 | Level 1
1257701 | Level 1
1257702 | Level 1
1257706 | Level 1
1257707 | Level 1
1257709 | Level 1
1257710 | Level 1
1257714 | Level 1
1257715 | Level 1
1257716 | Level 1
1257718 | Level 1
1257719 | Level 1
1257722 | Level 1
1257723 | Level 1
1257724 | Level 1
1257726 | Level 1
1257727 | Level 1
1257729 | Level 1
1257730 | Level 1
1257731 | Level 1
1257733 | Level 1
1257734 | Level 1
1257736 | Level 1
1257737 | Level 1
1257738 | Level 1
1257739 | Level 1
1257743 | Level 1
1257754 | Level 1
1257756 | Level 1
1257757 | Level 1
1257759 | Level 1
1257760 | Level 1
1257761 | Level 1
1257762 | Level 1
1257763 | Level 1
1257764 | Level 1
1257765 | Level 1
1257766 | Level 1
1257767 | Level 1
1257768 | Level 1
1257769 | Level 1
1257770 | Level 1
1257771 | Level 1
1257772 | Level 1
1257773 | Level 1
1257777 | Level 1
1257780 | Level 1
1257793 | Level 1
1257798 | Level 1
1257803 | Level 1
1257810 | Level 1
1257811 | Level 1
1257812 | Level 1
1257813 | Level 1
1257814 | Level 1
1257815 | Level 1
1257816 | Level 1
1257817 | Level 1
1257818 | Level 1
1257819 | Level 1
1259065 | Level 1
1259067 | Level 1
1259069 | Level 1
1259070 | Level 1
1259071 | Level 1
1259072 | Level 1
1259081 | Level 1
1259082 | Level 1
1259084 | Level 1
1259086 | Level 1
1259087 | Level 1
1259088 | Level 1
1259659 | Level 1
1259661 | Level 1
1259667 | Level 1
1259670 | Level 1
1259672 | Level 1
1259673 | Level 1
1259674 | Level 1
1259893 | Level 1
1260339 | Level 1
1260340 | Level 1
1260341 | Level 1
1260342 | Level 1
1260343 | Level 1
1260344 | Level 1
1260345 | Level 1
1260346 | Level 1
1260347 | Level 1
1260348 | Level 1
1260349 | Level 1
1260350 | Level 1
1260351 | Level 1
1260352 | Level 1
1260353 | Level 1
1260354 | Level 1
1260355 | Level 1
1260356 | Level 1
1260357 | Level 1
1260358 | Level 1
1260359 | Level 1
1260360 | Level 1
1260361 | Level 1
1260362 | Level 1
1260363 | Level 1
1260364 | Level 1
1260365 | Level 1
1260366 | Level 1
1260367 | Level 1
1260368 | Level 1
1260369 | Level 1
1260370 | Level 1
1260371 | Level 1
1260372 | Level 1
1260373 | Level 1
1260374 | Level 1
1260375 | Level 1
1260376 | Level 1
1260377 | Level 1
1260378 | Level 1
1260379 | Level 1
1260380 | Level 1
1260381 | Level 1
1260382 | Level 1
1260383 | Level 1
1260384 | Level 1
1260385 | Level 1
1260386 | Level 1
1260387 | Level 1
1260388 | Level 1
1260389 | Level 1
1260390 | Level 1
1260391 | Level 1
1260392 | Level 1
1269986 | Level 1
1269987 | Level 1
1269988 | Level 1
1269989 | Level 1
1270011 | Level 1
1270012 | Level 1
1270013 | Level 1
1270016 | Level 1
1270017 | Level 1
1270018 | Level 1
1271823 | Level 1
1271827 | Level 1
1271836 | Level 1
1271840 | Level 1
1271918 | Level 1
1271966 | Level 1
1271970 | Level 1
1271979 | Level 1
1271982 | Level 1
1271985 | Level 1
1271988 | Level 1
1271991 | Level 1
1271997 | Level 1
1272003 | Level 1
1272006 | Level 1
1272083 | Level 1
1272086 | Level 1
1272137 | Level 1
1272140 | Level 1
1272225 | Level 1
1272253 | Level 1
1272364 | Level 1
1272372 | Level 1
1273004 | Level 1
1273165 | Level 1
1273324 | Level 1
1273325 | Level 1
1273326 | Level 1
1273327 | Level 1
1273328 | Level 1
1273329 | Level 1
1273330 | Level 1
1273331 | Level 1
1273332 | Level 1
1273333 | Level 1
1273334 | Level 1
1273335 | Level 1
1273336 | Level 1
1273337 | Level 1
1282689 | Level 1
1282691 | Level 1
1282694 | Level 1
1282744 | Level 1
1282772 | Level 1
1282818 | Level 1
1282821 | Level 1
1282854 | Level 1
1282855 | Level 1
1282942 | Level 1
1282946 | Level 1
1286120 | Level 1
1286121 | Level 1
1286158 | Level 1
1286159 | Level 1
1286160 | Level 1
1286161 | Level 1
1286162 | Level 1
1286163 | Level 1
1286164 | Level 1
1286165 | Level 1
1286166 | Level 1
1286167 | Level 1
1286168 | Level 1
1286169 | Level 1
1286170 | Level 1
1286171 | Level 1
1286172 | Level 1
1286173 | Level 1
1286174 | Level 1
1286175 | Level 1
1286176 | Level 1
1286177 | Level 1
1286178 | Level 1
1286179 | Level 1
1286180 | Level 1
1286181 | Level 1
1286182 | Level 1
1286183 | Level 1
1286184 | Level 1
1286185 | Level 1
1286186 | Level 1
1286187 | Level 1
1286188 | Level 1
1286189 | Level 1
1286190 | Level 1
1286191 | Level 1
1286192 | Level 1
1286193 | Level 1
1286194 | Level 1
1286195 | Level 1
1286196 | Level 1
1286197 | Level 1
1286236 | Level 1
1286239 | Level 1
1286242 | Level 1
1286245 | Level 1
1286575 | Level 1
1286581 | Level 1
1286667 | Level 2
1286668 | Level 1
1286669 | Level 1
1286670 | Level 2
1286671 | Level 2
1286672 | Level 1
1286673 | Level 1
1286674 | Level 1
1286675 | Level 1
1286676 | Level 1
1286677 | Level 1
1286678 | Level 1
1286679 | Level 1
1286680 | Level 1
1286681 | Level 1
1286682 | Level 1
1286683 | Level 1
1286684 | Level 1
1286685 | Level 1
1286686 | Level 1
1286687 | Level 1
1286688 | Level 1
1286841 | Level 1
1286850 | Level 1
1286858 | Level 1
1286990 | Level 1
1286991 | Level 2
1286992 | Level 1
1286993 | Level 2
1286994 | Level 2
1286995 | Level 1
1286996 | Level 1
1286997 | Level 1
1286998 | Level 1
1286999 | Level 1
1287000 | Level 1
1287001 | Level 1
1287002 | Level 1
1287003 | Level 1
1287004 | Level 1
1287005 | Level 1
1287006 | Level 1
1287007 | Level 1
1287008 | Level 1
1287009 | Level 1
1287022 | Level 1
1287025 | Level 1
1287028 | Level 1
1287031 | Level 1
1287034 | Level 1
1287037 | Level 1
1287108 | Level 1
1287111 | Level 1
1287114 | Level 1
1287117 | Level 1
1287126 | Level 1
1287129 | Level 1
1287132 | Level 1
1287135 | Level 1
1287208 | Level 1
1287211 | Level 1
1287257 | Level 1
1287260 | Level 1

# IfcDistributionPort (3760)
Description: Flow
Name | FlowDirection | Group
InPort_927171_0 | SINK | Mechanical Return Air 2
OutPort_983901_1 | SOURCE | Mechanical Return Air 2
InPort_1076412_1 | SINK | Mechanical Return Air 2
OutPort_927171_1 | SOURCE | Mechanical Return Air 2
InPort_927447_0 | SINK | Mechanical Supply Air 2
OutPort_983920_1 | SOURCE | Mechanical Supply Air 2
InPort_1267823_1 | SINK | Mechanical Supply Air 2
OutPort_927447_1 | SOURCE | Mechanical Supply Air 2
InPort_929316_0 | SINK | Mechanical Supply Air 2
OutPort_1267899_1 | SOURCE | Mechanical Supply Air 2
InPort_1029882_1 | SINK | Mechanical Supply Air 2
OutPort_929316_1 | SOURCE | Mechanical Supply Air 2
InPort_929345_0 | SINK | Mechanical Supply Air 2
OutPort_987656_1 | SOURCE | Mechanical Supply Air 2
InPort_970196_1 | SINK | Mechanical Supply Air 2
OutPort_929345_1 | SOURCE | Mechanical Supply Air 2
InPort_970215_1 | SINK | Mechanical Supply Air 2
OutPort_929345_2 | SOURCE | Mechanical Supply Air 2
InPort_1026091_1 | SINK | Mechanical Supply Air 2
OutPort_929345_3 | SOURCE | Mechanical Supply Air 2
InPort_1180004_1 | SINK | Mechanical Return Air 2
OutPort_929793_0 | SOURCE | Mechanical Return Air 2
InPort_929793_1 | SINK | Mechanical Return Air 2
OutPort_1026586_2 | SOURCE | Mechanical Return Air 2
InPort_929809_0 | SINK | Mechanical Return Air 2
OutPort_930092_1 | SOURCE | Mechanical Return Air 2
InPort_1180197_2 | SINK | Mechanical Return Air 2
OutPort_929809_1 | SOURCE | Mechanical Return Air 2
InPort_1268281_1 | SINK | Mechanical Return Air 2
OutPort_929809_2 | SOURCE | Mechanical Return Air 2
InPort_930092_2 | SINK | Mechanical Return Air 2
OutPort_930041_0 | SOURCE | Mechanical Return Air 2
InPort_930041_1 | SINK | Mechanical Return Air 2
OutPort_1029726_2 | SOURCE | Mechanical Return Air 2
InPort_1021712_1 | SINK | Mechanical Return Air 2
OutPort_930041_2 | SOURCE | Mechanical Return Air 2
InPort_1268218_1 | SINK | Mechanical Return Air 2
OutPort_930128_0 | SOURCE | Mechanical Return Air 2
InPort_930128_1 | SINK | Mechanical Return Air 2
OutPort_1025898_2 | SOURCE | Mechanical Return Air 2
InPort_1268196_1 | SINK | Mechanical Return Air 2
OutPort_930182_0 | SOURCE | Mechanical Return Air 2
InPort_930182_1 | SINK | Mechanical Return Air 2
OutPort_1268296_2 | SOURCE | Mechanical Return Air 2
InPort_930295_0 | SINK | Mechanical Return Air 2
OutPort_1180272_1 | SOURCE | Mechanical Return Air 2
InPort_1180311_2 | SINK | Mechanical Return Air 2
OutPort_930295_1 | SOURCE | Mechanical Return Air 2
InPort_1029557_2 | SINK | Mechanical Return Air 2
OutPort_930573_0 | SOURCE | Mechanical Return Air 2
InPort_930573_1 | SINK | Mechanical Return Air 2
OutPort_1029563_2 | SOURCE | Mechanical Return Air 2
InPort_930668_0 | SINK | Mechanical Return Air 2
OutPort_1179964_1 | SOURCE | Mechanical Return Air 2
InPort_1144561_2 | SINK | Mechanical Return Air 2
OutPort_930668_1 | SOURCE | Mechanical Return Air 2
InPort_1144610_1 | SINK | Mechanical Return Air 2
OutPort_930668_2 | SOURCE | Mechanical Return Air 2
InPort_1145201_2 | SINK | Mechanical Supply Air 2
OutPort_931381_0 | SOURCE | Mechanical Supply Air 2
InPort_931381_1 | SINK | Mechanical Supply Air 2
OutPort_1026919_2 | SOURCE | Mechanical Supply Air 2
InPort_969202_1 | SINK | Mechanical Supply Air 2
OutPort_931381_7 | SOURCE | Mechanical Supply Air 2
InPort_1180812_1 | SINK | Mechanical Supply Air 2
OutPort_931381_8 | SOURCE | Mechanical Supply Air 2
InPort_931404_0 | SINK | Mechanical Supply Air 2
OutPort_974736_1 | SOURCE | Mechanical Supply Air 2
InPort_969204_1 | SINK | Mechanical Supply Air 2
OutPort_931404_1 | SOURCE | Mechanical Supply Air 2
InPort_969097_1 | SINK | Mechanical Supply Air 2
OutPort_931404_2 | SOURCE | Mechanical Supply Air 2
InPort_969147_1 | SINK | Mechanical Supply Air 2
OutPort_931404_3 | SOURCE | Mechanical Supply Air 2
InPort_931419_0 | SINK | Mechanical Supply Air 2
OutPort_974661_1 | SOURCE | Mechanical Supply Air 2
InPort_968974_2 | SINK | Mechanical Supply Air 2
OutPort_931419_1 | SOURCE | Mechanical Supply Air 2
InPort_931474_0 | SINK | Mechanical Return Air 2
OutPort_931696_2 | SOURCE | Mechanical Return Air 2
InPort_968703_2 | SINK | Mechanical Return Air 2
OutPort_931474_1 | SOURCE | Mechanical Return Air 2
InPort_1144300_2 | SINK | Mechanical Return Air 2
OutPort_931553_0 | SOURCE | Mechanical Return Air 2
InPort_931553_1 | SINK | Mechanical Return Air 2
OutPort_1144305_2 | SOURCE | Mechanical Return Air 2
InPort_1017257_1 | SINK | Mechanical Return Air 2
OutPort_931553_2 | SOURCE | Mechanical Return Air 2
InPort_931567_0 | SINK | Mechanical Return Air 2
OutPort_1261914_2 | SOURCE | Mechanical Return Air 2
InPort_931599_2 | SINK | Mechanical Return Air 2
OutPort_931567_1 | SOURCE | Mechanical Return Air 2
InPort_931591_0 | SINK | Mechanical Return Air 2
OutPort_931599_1 | SOURCE | Mechanical Return Air 2
InPort_968627_2 | SINK | Mechanical Return Air 2
OutPort_931591_1 | SOURCE | Mechanical Return Air 2
InPort_931682_0 | SINK | Mechanical Return Air 2
OutPort_974797_1 | SOURCE | Mechanical Return Air 2
InPort_931696_1 | SINK | Mechanical Return Air 2
OutPort_931682_1 | SOURCE | Mechanical Return Air 2
InPort_931986_0 | SINK | Mechanical Supply Air 2
OutPort_1265487_1 | SOURCE | Mechanical Supply Air 2
InPort_1032777_1 | SINK | Mechanical Supply Air 2
OutPort_931986_1 | SOURCE | Mechanical Supply Air 2
InPort_932135_0 | SINK | Mechanical Return Air 2
OutPort_987493_1 | SOURCE | Mechanical Return Air 2
InPort_932576_2 | SINK | Mechanical Return Air 2
OutPort_932135_1 | SOURCE | Mechanical Return Air 2
InPort_1023856_2 | SINK | Mechanical Supply Air 2
OutPort_932163_0 | SOURCE | Mechanical Supply Air 2
InPort_932163_1 | SINK | Mechanical Supply Air 2
OutPort_1023859_2 | SOURCE | Mechanical Supply Air 2
InPort_1086618_1 | SINK | Mechanical Supply Air 2
OutPort_932163_2 | SOURCE | Mechanical Supply Air 2
InPort_1193875_2 | SINK | Mechanical Supply Air 2
OutPort_932193_0 | SOURCE | Mechanical Supply Air 2
InPort_932193_1 | SINK | Mechanical Supply Air 2
OutPort_1017873_1 | SOURCE | Mechanical Supply Air 2
InPort_1086667_1 | SINK | Mechanical Supply Air 2
OutPort_932257_0 | SOURCE | Mechanical Supply Air 2
InPort_932257_1 | SINK | Mechanical Supply Air 2
OutPort_1086648_1 | SOURCE | Mechanical Supply Air 2
InPort_932307_0 | SINK | Mechanical Supply Air 2
OutPort_987446_1 | SOURCE | Mechanical Supply Air 2
InPort_932333_2 | SINK | Mechanical Supply Air 2
OutPort_932307_1 | SOURCE | Mechanical Supply Air 2
InPort_932322_0 | SINK | Mechanical Supply Air 2
OutPort_932333_1 | SOURCE | Mechanical Supply Air 2
InPort_969483_2 | SINK | Mechanical Supply Air 2
OutPort_932322_1 | SOURCE | Mechanical Supply Air 2
InPort_932386_0 | SINK | Mechanical Supply Air 2
OutPort_1086644_1 | SOURCE | Mechanical Supply Air 2
InPort_1086753_1 | SINK | Mechanical Supply Air 2
OutPort_932386_1 | SOURCE | Mechanical Supply Air 2
InPort_932402_0 | SINK | Mechanical Supply Air 2
OutPort_1086753_2 | SOURCE | Mechanical Supply Air 2
InPort_1086757_2 | SINK | Mechanical Supply Air 2
OutPort_932402_1 | SOURCE | Mechanical Supply Air 2
InPort_932432_1 | SINK | Mechanical Supply Air 2
OutPort_932413_0 | SOURCE | Mechanical Supply Air 2
InPort_932413_1 | SINK | Mechanical Supply Air 2
OutPort_1086757_1 | SOURCE | Mechanical Supply Air 2
InPort_932426_0 | SINK | Mechanical Supply Air 2
OutPort_932432_2 | SOURCE | Mechanical Supply Air 2
InPort_932548_1 | SINK | Mechanical Supply Air 2
OutPort_932426_1 | SOURCE | Mechanical Supply Air 2
InPort_932542_0 | SINK | Mechanical Supply Air 2
OutPort_932548_2 | SOURCE | Mechanical Supply Air 2
InPort_969515_2 | SINK | Mechanical Supply Air 2
OutPort_932542_1 | SOURCE | Mechanical Supply Air 2
InPort_932568_0 | SINK | Mechanical Return Air 2
OutPort_932576_1 | SOURCE | Mechanical Return Air 2
InPort_969434_2 | SINK | Mechanical Return Air 2
OutPort_932568_1 | SOURCE | Mechanical Return Air 2
InPort_934410_0 | SINK | Mechanical Return Air 2
OutPort_1027360_1 | SOURCE | Mechanical Return Air 2
InPort_1027365_2 | SINK | Mechanical Return Air 2
OutPort_934410_1 | SOURCE | Mechanical Return Air 2
InPort_973480_1 | SINK | Mechanical Return Air 2
OutPort_934421_0 | SOURCE | Mechanical Return Air 2
InPort_934421_1 | SINK | Mechanical Return Air 2
OutPort_974628_1 | SOURCE | Mechanical Return Air 2
InPort_951806_0 | SINK | Mechanical Return Air 2
OutPort_987778_1 | SOURCE | Mechanical Return Air 2
InPort_1104038_2 | SINK | Mechanical Return Air 2
OutPort_951806_1 | SOURCE | Mechanical Return Air 2
InPort_1023859_1 | SINK | Mechanical Supply Air 2
OutPort_951836_0 | SOURCE | Mechanical Supply Air 2
InPort_951836_1 | SINK | Mechanical Supply Air 2
OutPort_1261803_1 | SOURCE | Mechanical Supply Air 2
InPort_952450_0 | SINK | Mechanical Supply Air 2
OutPort_1267823_2 | SOURCE | Mechanical Supply Air 2
InPort_1267828_1 | SINK | Mechanical Supply Air 2
OutPort_952450_1 | SOURCE | Mechanical Supply Air 2
InPort_1215808_1 | SINK | Mechanical Supply Air 2
OutPort_952535_0 | SOURCE | Mechanical Supply Air 2
InPort_952535_1 | SINK | Mechanical Supply Air 2
OutPort_1215879_2 | SOURCE | Mechanical Supply Air 2
InPort_952572_0 | SINK | Mechanical Supply Air 2
OutPort_970631_1 | SOURCE | Mechanical Supply Air 2
InPort_970407_2 | SINK | Mechanical Supply Air 2
OutPort_952572_1 | SOURCE | Mechanical Supply Air 2
InPort_953960_0 | SINK | Mechanical Return Air 2
OutPort_1210736_1 | SOURCE | Mechanical Return Air 2
InPort_1210740_2 | SINK | Mechanical Return Air 2
OutPort_953960_1 | SOURCE | Mechanical Return Air 2
InPort_973453_1 | SINK | Mechanical Return Air 2
OutPort_953979_0 | SOURCE | Mechanical Return Air 2
InPort_953979_1 | SINK | Mechanical Return Air 2
OutPort_974615_1 | SOURCE | Mechanical Return Air 2
InPort_953997_0 | SINK | Mechanical Return Air 2
OutPort_1210909_2 | SOURCE | Mechanical Return Air 2
InPort_1210913_2 | SINK | Mechanical Return Air 2
OutPort_953997_1 | SOURCE | Mechanical Return Air 2
InPort_973529_1 | SINK | Mechanical Return Air 2
OutPort_954007_0 | SOURCE | Mechanical Return Air 2
InPort_954007_1 | SINK | Mechanical Return Air 2
OutPort_974602_1 | SOURCE | Mechanical Return Air 2
InPort_973544_1 | SINK | Mechanical Return Air 2
OutPort_954033_0 | SOURCE | Mechanical Return Air 2
InPort_954033_1 | SINK | Mechanical Return Air 2
OutPort_974647_1 | SOURCE | Mechanical Return Air 2
InPort_955891_0 | SINK | Mechanical Return Air 2
OutPort_1051971_1 | SOURCE | Mechanical Return Air 2
InPort_955959_1 | SINK | Mechanical Return Air 2
OutPort_955891_1 | SOURCE | Mechanical Return Air 2
InPort_955952_0 | SINK | Mechanical Return Air 2
OutPort_1146535_1 | SOURCE | Mechanical Return Air 2
InPort_1265441_2 | SINK | Mechanical Return Air 2
OutPort_955952_1 | SOURCE | Mechanical Return Air 2
InPort_1146537_0 | SINK | Mechanical Return Air 2
OutPort_955959_2 | SOURCE | Mechanical Return Air 2
InPort_956174_0 | SINK | Mechanical Supply Air 2
OutPort_1051985_1 | SOURCE | Mechanical Supply Air 2
InPort_956188_1 | SINK | Mechanical Supply Air 2
OutPort_956174_1 | SOURCE | Mechanical Supply Air 2
InPort_1287709_1 | SINK | Mechanical Supply Air 2
OutPort_956174_4 | SOURCE | Mechanical Supply Air 2
InPort_956181_0 | SINK | Mechanical Supply Air 2
OutPort_956188_2 | SOURCE | Mechanical Supply Air 2
InPort_1265468_2 | SINK | Mechanical Supply Air 2
OutPort_956181_1 | SOURCE | Mechanical Supply Air 2
Port_956294_0 | SOURCEANDSINK | Mechanical Supply Air 8
Port_1052956_1 | SOURCEANDSINK | Mechanical Supply Air 8
Port_956294_1 | SOURCEANDSINK | Mechanical Supply Air 8
InPort_956295_0 | SINK | Mechanical Exhaust Air 2
OutPort_965135_1 | SOURCE | Mechanical Exhaust Air 2
InPort_1022827_1 | SINK | Mechanical Exhaust Air 2
OutPort_956295_1 | SOURCE | Mechanical Exhaust Air 2
InPort_963750_1 | SINK | Mechanical Outside Air 3
OutPort_956296_0 | SOURCE | Mechanical Outside Air 3
InPort_956296_1 | SINK | Mechanical Outside Air 3
OutPort_963752_1 | SOURCE | Mechanical Outside Air 3
InPort_956297_0 | SINK | Mechanical Return Air 12
OutPort_962146_1 | SOURCE | Mechanical Return Air 12
InPort_956300_1 | SINK | Mechanical Return Air 12
OutPort_956297_1 | SOURCE | Mechanical Return Air 12
Port_956303_0 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1171589_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_956303_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_987058_1 | SOURCEANDSINK | Mechanical Supply Air 4
InPort_963551_1 | SINK | Mechanical Outside Air 4
OutPort_956304_0 | SOURCE | Mechanical Outside Air 4
InPort_956304_1 | SINK | Mechanical Outside Air 4
OutPort_1204800_1 | SOURCE | Mechanical Outside Air 4
InPort_1170882_1 | SINK | Mechanical Return Air 1
OutPort_956448_0 | SOURCE | Mechanical Return Air 1
InPort_956448_1 | SINK | Mechanical Return Air 1
OutPort_987077_2 | SOURCE | Mechanical Return Air 1
InPort_981188_2 | SINK | Mechanical Return Air 2
OutPort_957035_0 | SOURCE | Mechanical Return Air 2
InPort_957035_1 | SINK | Mechanical Return Air 2
OutPort_977085_1 | SOURCE | Mechanical Return Air 2
InPort_1195822_1 | SINK | Mechanical Return Air 2
OutPort_957133_0 | SOURCE | Mechanical Return Air 2
InPort_957133_1 | SINK | Mechanical Return Air 2
OutPort_1195835_1 | SOURCE | Mechanical Return Air 2
InPort_957188_0 | SINK | Mechanical Supply Air 2
OutPort_1000159_1 | SOURCE | Mechanical Supply Air 2
InPort_1173475_1 | SINK | Mechanical Supply Air 2
OutPort_957188_1 | SOURCE | Mechanical Supply Air 2
InPort_957206_0 | SINK | Mechanical Supply Air 2
OutPort_1265372_0 | SOURCE | Mechanical Supply Air 2
InPort_1265307_0 | SINK | Mechanical Supply Air 2
OutPort_957206_1 | SOURCE | Mechanical Supply Air 2
InPort_957300_0 | SINK | Mechanical Supply Air 2
OutPort_1211519_2 | SOURCE | Mechanical Supply Air 2
InPort_1211522_2 | SINK | Mechanical Supply Air 2
OutPort_957300_1 | SOURCE | Mechanical Supply Air 2
InPort_957308_0 | SINK | Mechanical Supply Air 2
OutPort_990901_2 | SOURCE | Mechanical Supply Air 2
InPort_1211519_1 | SINK | Mechanical Supply Air 2
OutPort_957308_1 | SOURCE | Mechanical Supply Air 2
InPort_957525_1 | SINK | Mechanical Return Air 2
OutPort_981190_0 | SOURCE | Mechanical Return Air 2
InPort_974712_0 | SINK | Mechanical Return Air 2
OutPort_957525_2 | SOURCE | Mechanical Return Air 2
InPort_1146448_0 | SINK | Mechanical Return Air 2
OutPort_958433_1 | SOURCE | Mechanical Return Air 2
InPort_958433_2 | SINK | Mechanical Return Air 2
OutPort_1077354_0 | SOURCE | Mechanical Return Air 2
InPort_1077380_2 | SINK | Mechanical Return Air 2
OutPort_958495_0 | SOURCE | Mechanical Return Air 2
InPort_958495_1 | SINK | Mechanical Return Air 2
InPort_1120750_1 | SINK | Mechanical Return Air 2
OutPort_958495_2 | SOURCE | Mechanical Return Air 2
InPort_958591_0 | SINK | Mechanical Return Air 6
OutPort_1076783_1 | SOURCE | Mechanical Return Air 6
InPort_1076784_1 | SINK | Mechanical Return Air 6
OutPort_958591_1 | SOURCE | Mechanical Return Air 6
InPort_958618_0 | SINK | Mechanical Supply Air 2
InPort_959020_1 | SINK | Mechanical Supply Air 2
OutPort_958618_1 | SOURCE | Mechanical Supply Air 2
Port_959139_0 | SOURCEANDSINK | Mechanical Supply Air 3
Port_959139_1 | SOURCEANDSINK | Mechanical Supply Air 3
InPort_959319_0 | SINK | Mechanical Supply Air 2
OutPort_1267866_2 | SOURCE | Mechanical Supply Air 2
InPort_1267885_2 | SINK | Mechanical Supply Air 2
OutPort_959319_1 | SOURCE | Mechanical Supply Air 2
InPort_1287782_1 | SINK | Mechanical Supply Air 2
OutPort_959319_2 | SOURCE | Mechanical Supply Air 2
InPort_1023626_1 | SINK | Mechanical Return Air 2
OutPort_959710_0 | SOURCE | Mechanical Return Air 2
InPort_959710_1 | SINK | Mechanical Return Air 2
OutPort_987240_1 | SOURCE | Mechanical Return Air 2
InPort_961935_0 | SINK | Mechanical Return Air 1
OutPort_964843_1 | SOURCE | Mechanical Return Air 1
InPort_964844_1 | SINK | Mechanical Return Air 1
OutPort_961935_1 | SOURCE | Mechanical Return Air 1
InPort_967117_1 | SINK | Mechanical Return Air 1
OutPort_962666_0 | SOURCE | Mechanical Return Air 1
InPort_962666_1 | SINK | Mechanical Return Air 1
OutPort_964441_2 | SOURCE | Mechanical Return Air 1
Port_963143_0 | SOURCEANDSINK | Mechanical Exhaust Air 4
Port_963143_1 | SOURCEANDSINK | Mechanical Exhaust Air 4
Port_963402_1 | SOURCEANDSINK | Mechanical Exhaust Air 4
Port_963402_0 | SOURCEANDSINK | Mechanical Exhaust Air 4
InPort_963553_1 | SINK | Mechanical Outside Air 1
OutPort_963487_0 | SOURCE | Mechanical Outside Air 1
InPort_963487_1 | SINK | Mechanical Outside Air 1
OutPort_1207116_1 | SOURCE | Mechanical Outside Air 1
InPort_964441_1 | SINK | Mechanical Return Air 1
OutPort_964432_0 | SOURCE | Mechanical Return Air 1
InPort_964432_1 | SINK | Mechanical Return Air 1
OutPort_964602_1 | SOURCE | Mechanical Return Air 1
InPort_964602_2 | SINK | Mechanical Return Air 1
OutPort_964648_0 | SOURCE | Mechanical Return Air 1
InPort_964648_1 | SINK | Mechanical Return Air 1
OutPort_964660_1 | SOURCE | Mechanical Return Air 1
InPort_964660_2 | SINK | Mechanical Return Air 1
OutPort_964655_0 | SOURCE | Mechanical Return Air 1
InPort_964655_1 | SINK | Mechanical Return Air 1
OutPort_964683_1 | SOURCE | Mechanical Return Air 1
InPort_964683_2 | SINK | Mechanical Return Air 1
OutPort_964676_0 | SOURCE | Mechanical Return Air 1
InPort_964676_1 | SINK | Mechanical Return Air 1
OutPort_964745_1 | SOURCE | Mechanical Return Air 1
InPort_964745_2 | SINK | Mechanical Return Air 1
OutPort_964702_0 | SOURCE | Mechanical Return Air 1
InPort_964702_1 | SINK | Mechanical Return Air 1
OutPort_964748_1 | SOURCE | Mechanical Return Air 1
Port_965602_0 | SOURCEANDSINK | Mechanical Supply Air 8
Port_965602_1 | SOURCEANDSINK | Mechanical Supply Air 8
Port_1052956_2 | SOURCEANDSINK | Mechanical Supply Air 8
InPort_966670_1 | SINK | Mechanical Outside Air 7
OutPort_966139_0 | SOURCE | Mechanical Outside Air 7
InPort_966139_1 | SINK | Mechanical Outside Air 7
OutPort_1218336_1 | SOURCE | Mechanical Outside Air 7
Port_966178_0 | SOURCEANDSINK | Mechanical Outside Air 8
Port_1031550_1 | SOURCEANDSINK | Mechanical Outside Air 8
Port_966178_1 | SOURCEANDSINK | Mechanical Outside Air 8
Port_966197_0 | SOURCEANDSINK | Mechanical Outside Air 8
Port_1031550_2 | SOURCEANDSINK | Mechanical Outside Air 8
Port_966197_1 | SOURCEANDSINK | Mechanical Outside Air 8
Port_1031555_1 | SOURCEANDSINK | Mechanical Outside Air 8
Port_966409_0 | SOURCEANDSINK | Mechanical Outside Air 8
Port_966409_1 | SOURCEANDSINK | Mechanical Outside Air 8
Port_1031555_0 | SOURCEANDSINK | Mechanical Outside Air 8
InPort_967067_0 | SINK | Mechanical Exhaust Air 2
OutPort_995232_1 | SOURCE | Mechanical Exhaust Air 2
InPort_967067_1 | SINK | Mechanical Exhaust Air 2
OutPort_1030676_1 | SOURCE | Mechanical Exhaust Air 2
InPort_967067_2 | SINK | Mechanical Exhaust Air 2
OutPort_1030664_0 | SOURCE | Mechanical Exhaust Air 2
InPort_987079_0 | SINK | Mechanical Return Air 1
OutPort_967117_2 | SOURCE | Mechanical Return Air 1
InPort_967315_0 | SINK | Mechanical Return Air 1
OutPort_1271304_1 | SOURCE | Mechanical Return Air 1
OutPort_967315_1 | SOURCE | Mechanical Return Air 1
Port_967358_0 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1169803_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_967358_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_967374_2 | SOURCEANDSINK | Mechanical Supply Air 4
InPort_1176263_1 | SINK | Mechanical Supply Air 4
OutPort_967358_2 | SOURCE | Mechanical Supply Air 4
Port_967369_0 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1270044_2 | SOURCEANDSINK | Mechanical Supply Air 4
Port_967369_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1168874_0 | SOURCEANDSINK | Mechanical Supply Air 4
Port_967374_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1270046_0 | SOURCEANDSINK | Mechanical Supply Air 4
InPort_967728_0 | SINK | Mechanical Supply Air 2
OutPort_1215622_2 | SOURCE | Mechanical Supply Air 2
InPort_1216007_1 | SINK | Mechanical Supply Air 2
OutPort_967728_1 | SOURCE | Mechanical Supply Air 2
InPort_1215879_1 | SINK | Mechanical Supply Air 2
OutPort_967728_3 | SOURCE | Mechanical Supply Air 2
InPort_1216059_1 | SINK | Mechanical Supply Air 2
OutPort_967728_4 | SOURCE | Mechanical Supply Air 2
InPort_1216101_1 | SINK | Mechanical Supply Air 2
OutPort_967728_5 | SOURCE | Mechanical Supply Air 2
InPort_1095812_1 | SINK | Mechanical Supply Air 2
OutPort_967750_0 | SOURCE | Mechanical Supply Air 2
InPort_967750_1 | SINK | Mechanical Supply Air 2
OutPort_1175681_1 | SOURCE | Mechanical Supply Air 2
InPort_1023909_1 | SINK | Mechanical Return Air 2
OutPort_968197_0 | SOURCE | Mechanical Return Air 2
InPort_968197_1 | SINK | Mechanical Return Air 2
OutPort_1261776_1 | SOURCE | Mechanical Return Air 2
InPort_968621_1 | SINK | Mechanical Return Air 2
OutPort_968625_1 | SOURCE | Mechanical Return Air 2
InPort_968625_0 | SINK | Mechanical Return Air 2
OutPort_968627_1 | SOURCE | Mechanical Return Air 2
InPort_968699_1 | SINK | Mechanical Return Air 2
OutPort_968701_1 | SOURCE | Mechanical Return Air 2
InPort_968701_0 | SINK | Mechanical Return Air 2
OutPort_968703_1 | SOURCE | Mechanical Return Air 2
InPort_968970_1 | SINK | Mechanical Supply Air 2
OutPort_968972_1 | SOURCE | Mechanical Supply Air 2
InPort_968972_0 | SINK | Mechanical Supply Air 2
OutPort_968974_1 | SOURCE | Mechanical Supply Air 2
InPort_969084_0 | SINK | Mechanical Supply Air 2
OutPort_969097_2 | SOURCE | Mechanical Supply Air 2
InPort_969224_2 | SINK | Mechanical Supply Air 2
OutPort_969084_1 | SOURCE | Mechanical Supply Air 2
InPort_969121_0 | SINK | Mechanical Supply Air 2
OutPort_969147_2 | SOURCE | Mechanical Supply Air 2
InPort_969242_2 | SINK | Mechanical Supply Air 2
OutPort_969121_1 | SOURCE | Mechanical Supply Air 2
InPort_974738_0 | SINK | Mechanical Supply Air 2
OutPort_969202_2 | SOURCE | Mechanical Supply Air 2
InPort_969220_1 | SINK | Mechanical Supply Air 2
OutPort_969222_1 | SOURCE | Mechanical Supply Air 2
InPort_969222_0 | SINK | Mechanical Supply Air 2
OutPort_969224_1 | SOURCE | Mechanical Supply Air 2
InPort_969238_1 | SINK | Mechanical Supply Air 2
OutPort_969240_1 | SOURCE | Mechanical Supply Air 2
InPort_969240_0 | SINK | Mechanical Supply Air 2
OutPort_969242_1 | SOURCE | Mechanical Supply Air 2
InPort_969304_1 | SINK | Mechanical Supply Air 2
OutPort_1032763_0 | SOURCE | Mechanical Supply Air 2
InPort_969430_1 | SINK | Mechanical Return Air 2
OutPort_969432_1 | SOURCE | Mechanical Return Air 2
InPort_969432_0 | SINK | Mechanical Return Air 2
OutPort_969434_1 | SOURCE | Mechanical Return Air 2
InPort_969463_1 | SINK | Mechanical Supply Air 2
OutPort_969465_1 | SOURCE | Mechanical Supply Air 2
InPort_969465_0 | SINK | Mechanical Supply Air 2
OutPort_1193875_1 | SOURCE | Mechanical Supply Air 2
InPort_969479_1 | SINK | Mechanical Supply Air 2
OutPort_969481_1 | SOURCE | Mechanical Supply Air 2
InPort_969481_0 | SINK | Mechanical Supply Air 2
OutPort_969483_1 | SOURCE | Mechanical Supply Air 2
InPort_969511_1 | SINK | Mechanical Supply Air 2
OutPort_969513_1 | SOURCE | Mechanical Supply Air 2
InPort_969513_0 | SINK | Mechanical Supply Air 2
OutPort_969515_1 | SOURCE | Mechanical Supply Air 2
InPort_969540_1 | SINK | Mechanical Return Air 2
OutPort_969542_1 | SOURCE | Mechanical Return Air 2
InPort_969542_0 | SINK | Mechanical Return Air 2
OutPort_1025829_1 | SOURCE | Mechanical Return Air 2
InPort_969556_1 | SINK | Mechanical Return Air 2
OutPort_969558_1 | SOURCE | Mechanical Return Air 2
InPort_969558_0 | SINK | Mechanical Return Air 2
OutPort_1025892_1 | SOURCE | Mechanical Return Air 2
InPort_969596_1 | SINK | Mechanical Return Air 2
OutPort_969598_1 | SOURCE | Mechanical Return Air 2
InPort_969598_0 | SINK | Mechanical Return Air 2
OutPort_1180307_1 | SOURCE | Mechanical Return Air 2
InPort_970207_0 | SINK | Mechanical Supply Air 2
OutPort_970215_2 | SOURCE | Mechanical Supply Air 2
InPort_970253_2 | SINK | Mechanical Supply Air 2
OutPort_970207_1 | SOURCE | Mechanical Supply Air 2
InPort_1026085_2 | SINK | Mechanical Supply Air 2
OutPort_970224_0 | SOURCE | Mechanical Supply Air 2
InPort_970224_1 | SINK | Mechanical Supply Air 2
OutPort_1026091_2 | SOURCE | Mechanical Supply Air 2
InPort_970249_1 | SINK | Mechanical Supply Air 2
OutPort_970251_1 | SOURCE | Mechanical Supply Air 2
InPort_970251_0 | SINK | Mechanical Supply Air 2
OutPort_970253_1 | SOURCE | Mechanical Supply Air 2
InPort_970267_1 | SINK | Mechanical Supply Air 2
OutPort_970269_1 | SOURCE | Mechanical Supply Air 2
InPort_970269_0 | SINK | Mechanical Supply Air 2
OutPort_1026085_1 | SOURCE | Mechanical Supply Air 2
InPort_970286_1 | SINK | Mechanical Supply Air 2
OutPort_970288_0 | SOURCE | Mechanical Supply Air 2
InPort_970288_1 | SINK | Mechanical Supply Air 2
OutPort_1029882_2 | SOURCE | Mechanical Supply Air 2
InPort_970364_1 | SINK | Mechanical Supply Air 2
OutPort_1215923_0 | SOURCE | Mechanical Supply Air 2
InPort_970403_1 | SINK | Mechanical Supply Air 2
OutPort_970405_1 | SOURCE | Mechanical Supply Air 2
InPort_970405_0 | SINK | Mechanical Supply Air 2
OutPort_970407_1 | SOURCE | Mechanical Supply Air 2
InPort_970631_2 | SINK | Mechanical Supply Air 2
OutPort_970633_1 | SOURCE | Mechanical Supply Air 2
InPort_970633_0 | SINK | Mechanical Supply Air 2
OutPort_1094964_2 | SOURCE | Mechanical Supply Air 2
InPort_973455_0 | SINK | Mechanical Return Air 2
OutPort_973453_2 | SOURCE | Mechanical Return Air 2
InPort_1210736_2 | SINK | Mechanical Return Air 2
OutPort_973455_1 | SOURCE | Mechanical Return Air 2
InPort_973482_1 | SINK | Mechanical Return Air 2
OutPort_973480_2 | SOURCE | Mechanical Return Air 2
InPort_1027360_2 | SINK | Mechanical Return Air 2
OutPort_973482_0 | SOURCE | Mechanical Return Air 2
InPort_973531_1 | SINK | Mechanical Return Air 2
OutPort_973529_2 | SOURCE | Mechanical Return Air 2
InPort_1210909_1 | SINK | Mechanical Return Air 2
OutPort_973531_0 | SOURCE | Mechanical Return Air 2
InPort_973546_0 | SINK | Mechanical Return Air 2
OutPort_973544_2 | SOURCE | Mechanical Return Air 2
InPort_1210871_1 | SINK | Mechanical Return Air 2
OutPort_973546_1 | SOURCE | Mechanical Return Air 2
InPort_974661_2 | SINK | Mechanical Supply Air 2
OutPort_1262177_0 | SOURCE | Mechanical Supply Air 2
InPort_1262156_1 | SINK | Mechanical Supply Air 2
OutPort_974663_0 | SOURCE | Mechanical Supply Air 2
InPort_974663_1 | SINK | Mechanical Supply Air 2
OutPort_1180892_1 | SOURCE | Mechanical Supply Air 2
InPort_1265489_0 | SINK | Mechanical Supply Air 2
OutPort_974684_1 | SOURCE | Mechanical Supply Air 2
InPort_974684_2 | SINK | Mechanical Supply Air 2
OutPort_974686_0 | SOURCE | Mechanical Supply Air 2
InPort_974686_1 | SINK | Mechanical Supply Air 2
OutPort_1145416_2 | SOURCE | Mechanical Supply Air 2
InPort_1195855_0 | SINK | Mechanical Return Air 2
OutPort_974710_1 | SOURCE | Mechanical Return Air 2
InPort_974710_2 | SINK | Mechanical Return Air 2
OutPort_974712_1 | SOURCE | Mechanical Return Air 2
InPort_974736_2 | SINK | Mechanical Supply Air 2
OutPort_974738_1 | SOURCE | Mechanical Supply Air 2
InPort_1261916_0 | SINK | Mechanical Return Air 2
OutPort_974770_1 | SOURCE | Mechanical Return Air 2
InPort_974770_2 | SINK | Mechanical Return Air 2
OutPort_974772_1 | SOURCE | Mechanical Return Air 2
InPort_974772_0 | SINK | Mechanical Return Air 2
OutPort_1261969_1 | SOURCE | Mechanical Return Air 2
InPort_974797_2 | SINK | Mechanical Return Air 2
OutPort_974799_1 | SOURCE | Mechanical Return Air 2
InPort_974799_0 | SINK | Mechanical Return Air 2
OutPort_1017358_1 | SOURCE | Mechanical Return Air 2
InPort_1261587_1 | SINK | Mechanical Return Air 2
OutPort_974894_0 | SOURCE | Mechanical Return Air 2
InPort_974894_1 | SINK | Mechanical Return Air 2
OutPort_1087000_2 | SOURCE | Mechanical Return Air 2
InPort_974942_0 | SINK | Mechanical Supply Air 2
OutPort_975038_1 | SOURCE | Mechanical Supply Air 2
InPort_974962_1 | SINK | Mechanical Supply Air 2
OutPort_974942_1 | SOURCE | Mechanical Supply Air 2
InPort_975038_2 | SINK | Mechanical Supply Air 2
OutPort_975040_1 | SOURCE | Mechanical Supply Air 2
InPort_975040_0 | SINK | Mechanical Supply Air 2
OutPort_1211440_1 | SOURCE | Mechanical Supply Air 2
InPort_981190_1 | SINK | Mechanical Return Air 2
OutPort_981188_1 | SOURCE | Mechanical Return Air 2
InPort_983901_2 | SINK | Mechanical Return Air 2
OutPort_983903_1 | SOURCE | Mechanical Return Air 2
Port_983901_3 | SOURCEANDSINK
Port_983901_4 | SOURCEANDSINK
InPort_983903_0 | SINK | Mechanical Return Air 2
OutPort_1120521_1 | SOURCE | Mechanical Return Air 2
InPort_983920_2 | SINK | Mechanical Supply Air 2
OutPort_983922_1 | SOURCE | Mechanical Supply Air 2
Port_983920_3 | SOURCEANDSINK
Port_983920_4 | SOURCEANDSINK
InPort_983922_0 | SINK | Mechanical Supply Air 2
OutPort_1267881_1 | SOURCE | Mechanical Supply Air 2
InPort_987031_1 | SINK | Mechanical Exhaust Air 2
OutPort_1022676_0 | SOURCE | Mechanical Exhaust Air 2
InPort_995234_0 | SINK | Mechanical Exhaust Air 2
OutPort_987031_2 | SOURCE | Mechanical Exhaust Air 2
Port_987058_2 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1171770_0 | SOURCEANDSINK | Mechanical Supply Air 4
Port_987060_0 | SOURCEANDSINK | Mechanical Supply Air 4
Port_1171736_1 | SOURCEANDSINK | Mechanical Supply Air 4
Port_987060_1 | SOURCEANDSINK | Mechanical Supply Air 4
InPort_987077_1 | SINK | Mechanical Return Air 1
OutPort_987079_1 | SOURCE | Mechanical Return Air 1
InPort_987446_2 | SINK | Mechanical Supply Air 2
OutPort_987448_1 | SOURCE | Mechanical Supply Air 2
InPort_987448_0 | SINK | Mechanical Supply Air 2
OutPort_1023856_1 | SOURCE | Mechanical Supply Air 2
InPort_987493_2 | SINK | Mechanical Return Air 2
OutPort_987495_1 | SOURCE | Mechanical Return Air 2
InPort_987495_0 | SINK | Mechanical Return Air 2
OutPort_1086527_2 | SOURCE | Mechanical Return Air 2
InPort_987512_0 | SINK | Mechanical Supply Air 2
OutPort_1086618_2 | SOURCE | Mechanical Supply Air 2
InPort_1086648_2 | SINK | Mechanical Supply Air 2
OutPort_987512_1 | SOURCE | Mechanical Supply Air 2
InPort_987656_2 | SINK | Mechanical Supply Air 2
OutPort_987658_0 | SOURCE | Mechanical Supply Air 2
InPort_987658_1 | SINK | Mechanical Supply Air 2
OutPort_1179909_2 | SOURCE | Mechanical Supply Air 2
InPort_1267901_0 | SINK | Mechanical Supply Air 2
OutPort_987713_1 | SOURCE | Mechanical Supply Air 2
InPort_987713_2 | SINK | Mechanical Supply Air 2
OutPort_1181013_0 | SOURCE | Mechanical Supply Air 2
InPort_1181011_2 | SINK | Mechanical Supply Air 2
OutPort_987715_0 | SOURCE | Mechanical Supply Air 2
InPort_987715_1 | SINK | Mechanical Supply Air 2
OutPort_1180558_1 | SOURCE | Mechanical Supply Air 2
InPort_987778_2 | SINK | Mechanical Return Air 2
OutPort_987780_0 | SOURCE | Mechanical Return Air 2
InPort_987780_1 | SINK | Mechanical Return Air 2
OutPort_1001613_1 | SOURCE | Mechanical Return Air 2
InPort_1086527_1 | SINK | Mechanical Return Air 2
OutPort_987780_3 | SOURCE | Mechanical Return Air 2
InPort_987800_0 | SINK | Mechanical Supply Air 2
OutPort_989040_1 | SOURCE | Mechanical Supply Air 2
InPort_1196158_1 | SINK | Mechanical Supply Air 2
OutPort_987800_1 | SOURCE | Mechanical Supply Air 2
InPort_989040_2 | SINK | Mechanical Supply Air 2
OutPort_989042_1 | SOURCE | Mechanical Supply Air 2
InPort_989042_0 | SINK | Mechanical Supply Air 2
OutPort_1287709_2 | SOURCE | Mechanical Supply Air 2
InPort_990783_1 | SINK
InPort_990901_1 | SINK | Mechanical Supply Air 2
OutPort_1000161_2 | SOURCE | Mechanical Supply Air 2
InPort_990952_1 | SINK
InPort_991046_1 | SINK | Mechanical Return Air 2
OutPort_991048_1 | SOURCE | Mechanical Return Air 2
InPort_991048_0 | SINK | Mechanical Return Air 2
OutPort_1029557_1 | SOURCE | Mechanical Return Air 2
InPort_995232_2 | SINK | Mechanical Exhaust Air 2
OutPort_995234_1 | SOURCE | Mechanical Exhaust Air 2
InPort_999655_0 | SINK | Mechanical Supply Air 2
OutPort_1265504_2 | SOURCE | Mechanical Supply Air 2
InPort_1141671_1 | SINK | Mechanical Supply Air 2
OutPort_999655_1 | SOURCE | Mechanical Supply Air 2
InPort_1000159_2 | SINK | Mechanical Supply Air 2
OutPort_1000161_1 | SOURCE | Mechanical Supply Air 2
InPort_1000161_0 | SINK | Mechanical Supply Air 2
OutPort_1265305_1 | SOURCE | Mechanical Supply Air 2
InPort_1000671_0 | SINK | Mechanical Return Air 1
OutPort_1000902_1 | SOURCE | Mechanical Return Air 1
OutPort_1000671_1 | SOURCE | Mechanical Return Air 1
