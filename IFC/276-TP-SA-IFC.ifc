Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Custom, SurfaceGeometryAddOnView], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: On], Option [Convert 2D symbols of Doors and Windows: On], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: C:\Users\Gediminas\Desktop\K7A 0317.ifc
Time: 2025-03-17T11:48:36
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 22.0.0 INT FULL Windows version (IFC add-on version: 3006 INT FULL).
Authorization: The authorising person

# IfcSite, Undefined
RefLatitude: 55, 42, 55, 600000; RefLongitude: 21, 7, 29, 200000; RefElevation: 9300 mm

# IfcBuildingStorey, -3. Story
In: Undefined
Elevation: -12000 mm

# IfcBuildingStorey: Level:1/4" Head (3)
In: Undefined
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
-2. Story | -2. Story | -8000
-1. Story | -1. Story | -4000
3. Story | 3. Story | 10800

# IfcBuildingStorey: Level:8mm Head (3)
In: Undefined
Name | LongName | Elevation (mm)
COKOLINIS | Level 1 | 0
PIRMAS | Level 2 | 3900
1A ANT | 3A vėdinimas | 7800

# IfcSpace: pow. wew. sumowane do pow. użytkowej i netto (suche), 1A01
In: 1A ANT
LongName: LAIPTINĖ; InteriorOrExteriorSpace: INTERNAL
Pset_SpaceCommon - Category: pow. wew. sumowane do pow. użytkowej i netto (suche)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 (4)
In: COKOLINIS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 10 (23)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material
4 x Wall-896 | COKOLINIS | 100 % wypełnienia 323726692
Wall-897 | COKOLINIS | 100 % wypełnienia 323726692
6 x Wall-896 | PIRMAS | 100 % wypełnienia 323726692
5 x Wall-897 | PIRMAS | 100 % wypełnienia 323726692
2 x Wall-895 | PIRMAS | 100 % wypełnienia 323726692
4 x Wall-897 | PIRMAS | 100 % wypełnienia 323726692 (2)
Wall-897 | PIRMAS | 100 % wypełnienia 323726692 (3)

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 110 (14)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material
2 x Wall-896 | COKOLINIS | 100 % wypełnienia 323726692
9 x Wall-895 | COKOLINIS | 100 % wypełnienia 323726692
Wall-897 | COKOLINIS | 100 % wypełnienia 323726692 (2)
2 x Wall-895 | PIRMAS | 100 % wypełnienia 323726692

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 130 (17)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
3 x Wall-895 | COKOLINIS
Wall-896 | COKOLINIS
7 x Wall-897 | PIRMAS
5 x Wall-895 | PIRMAS
Wall-896 | PIRMAS

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 150 (3)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Wall-899 | COKOLINIS
Wall-900 | COKOLINIS
Wall-898 | PIRMAS

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 170 (2)
In: PIRMAS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 20 (10)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Wall-895 | PIRMAS
6 x Wall-897 | PIRMAS
Wall-898 | PIRMAS
Wall-898 | 1A ANT

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 20 x 20 (25)
In: PIRMAS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 200 (17)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Wall-908 | 1A ANT
3 x Wall-908 | 3. Story
Wall-907 | 3. Story
2 x Wall-913 | 3. Story
Wall-905 | 3. Story
Wall-906 | 3. Story
2 x Wall-909 | 3. Story
2 x Wall-910 | 3. Story
2 x Wall-911 | 3. Story
2 x Wall-912 | 3. Story

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 250 (23)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
4 x Wall-896 | COKOLINIS
3 x Wall-895 | COKOLINIS
2 x Wall-900 | COKOLINIS
Wall-896 | PIRMAS
3 x Wall-902 | PIRMAS
Wall-895 | PIRMAS
Wall-906 | PIRMAS
2 x Wall-904 | PIRMAS
Wall-900 | PIRMAS
Wall-900 | 1A ANT
3 x Wall-896 | 1A ANT
Wall-895 | 1A ANT

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 270 (11)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Wall-895 | COKOLINIS
6 x Wall-895 | PIRMAS
4 x Wall-896 | PIRMAS

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 30 (5)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material
Wall-895 | COKOLINIS | 100 % wypełnienia 323726692 (2)
3 x Wall-895 | COKOLINIS | 100 % wypełnienia 323726692
Wall-897 | PIRMAS | 100 % wypełnienia 323726692

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 300 (17)
In: COKOLINIS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
3 x Wall-904
3 x Wall-896
4 x Wall-895
4 x Wall-898
Wall-905
Wall-906
Wall-907

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 400 x 400 (5)
In: COKOLINIS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 5, Wall-897
In: PIRMAS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 50 (4)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Wall-898 | COKOLINIS
2 x Wall-895 | PIRMAS

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 500 (2)
In: 1A ANT
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 520, Wall-897
In: 1A ANT
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 540 (2)
In: COKOLINIS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 570 (6)
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Material
Wall-902 | 100 % wypełnienia 323726692 (2)
Wall-904 | 100 % wypełnienia 323726692
Wall-903 | 100 % wypełnienia 323726692
Wall-900 | 100 % wypełnienia 323726692
Wall-905 | 100 % wypełnienia 323726692
Wall-901 | 100 % wypełnienia 323726692

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 640 (3)
In: COKOLINIS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x Wall-901
Wall-900

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 850, Wall-895
In: COKOLINIS
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 90 (29)
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
8 x Wall-895 | COKOLINIS
5 x Wall-896 | COKOLINIS
3 x Wall-898 | COKOLINIS
6 x Wall-897 | COKOLINIS
5 x Wall-897 | PIRMAS
2 x Wall-896 | PIRMAS

# IfcBuildingElementProxy: 100 % wypełnienia 323726692 D110 (25)
In: 3. Story
Material: 100 % wypełnienia 323726692
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 100 (115)
In: -1. Story
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
Strop-109
Strop-206
Strop-103
Strop-099
Strop-112
Strop-102
Strop-093
Strop-097
Strop-108
Strop-095
Strop-106
Strop-091
Strop-101
Strop-100
Strop-105
Strop-110
Strop-111
Strop-104
Strop-107
Strop-098
Strop-094
Strop-092
Strop-212
Strop-205
Strop-204
Strop-203
Strop-202
Strop-201
Strop-200
Strop-199
Strop-198
Strop-197
2 x Strop-120
Strop-194
Strop-211
Strop-192
Strop-191
Strop-190
Strop-189
Strop-188
Strop-187
Strop-186
Strop-185
Strop-184
Strop-183
Strop-182
Strop-181
Strop-180
Strop-179
Strop-210
Strop-208
Strop-209
Strop-175
Strop-174
Strop-173
Strop-172
Strop-171
Strop-170
Strop-169
Strop-168
Strop-167
Strop-207
Strop-165
Strop-164
Strop-163
Strop-162
Strop-161
Strop-160
Strop-159
Strop-158
Strop-157
Strop-156
Strop-155
Strop-154
Strop-153
Strop-152
Strop-151
Strop-150
Strop-149
Strop-148
Strop-147
Strop-146
Strop-145
Strop-144
Strop-143
Strop-142
Strop-141
Strop-140
Strop-139
Strop-138
Strop-137
Strop-136
Strop-135
Strop-134
Strop-133
Strop-132
Strop-131
Strop-130
Strop-129
Strop-128
Strop-127
Strop-126
Strop-125
Strop-124
Strop-123
Strop-122
Strop-121
Strop-119
Strop-118
Strop-117
Strop-116
Strop-115
Strop-114
Strop-113

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 150 (2)
In: COKOLINIS
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 1950, Strop-088
In: COKOLINIS
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 20, Strop-090
In: 1A ANT
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 200 (7)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Strop-089 | COKOLINIS
Strop-094 | PIRMAS
Strop-093 | PIRMAS
Strop-089 | PIRMAS
2 x Strop-090 | 1A ANT

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 250 (5)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Strop-089 | COKOLINIS
2 x Strop-091 | PIRMAS
Strop-090 | PIRMAS
Strop-091 | 1A ANT

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 2836, Strop-088
In: COKOLINIS
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 300 (5)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Wall-898 | -1. Story
Strop-089 | PIRMAS
3 x Strop-090 | 1A ANT

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 350 (16)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Strop-127 | COKOLINIS
Strop-125 | COKOLINIS
Strop-124 | COKOLINIS
Strop-123 | COKOLINIS
Strop-126 | COKOLINIS
Strop-122 | COKOLINIS
Strop-128 | COKOLINIS
Strop-129 | COKOLINIS
Strop-131 | COKOLINIS
Strop-130 | COKOLINIS
6 x Strop-089 | PIRMAS

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 400 x 1500 (4)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Słup-092 | -1. Story
2 x Słup-092 | COKOLINIS

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 4500, Strop-095
In: COKOLINIS
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 490 (2)
In: 1A ANT
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 50 (5)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Strop-091 | PIRMAS
2 x Strop-091 | 1A ANT
Strop-092 | 1A ANT

# IfcBuildingElementProxy: 100 % wypełnienia 378753490 600 (10)
Material: 100 % wypełnienia 378753490
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Strop-097 | -3. Story
Strop-099 | -3. Story
Strop-119 | -3. Story
2 x Strop-140 | -3. Story
Strop-089 | COKOLINIS
Strop-108 | COKOLINIS
Strop-089 | PIRMAS
Strop-089 | 1A ANT

# IfcBuildingElementProxy: Aluminium, Strop-089
In: COKOLINIS
Material: Aluminium (5)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Audience Seating 22 (2)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Basin 22 (12)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
4 x Obiekt-0366 | COKOLINIS
8 x Obiekt-0366 | PIRMAS

# IfcBuildingElementProxy: Bench 22 (3)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Obiekt-0360 | COKOLINIS
2 x Obiekt-0360 | PIRMAS

# IfcBuildingElementProxy: Boat Trailer #1534, Obiekt-0347
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Brass/Bronze 2885399790 20 x 20 (28)
Material: Brass/Bronze 2885399790
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
20 x Słup-092 | -1. Story
8 x Słup-093 | PIRMAS

# IfcBuildingElementProxy: Brass/Bronze 2885399790 32 x 32 (10)
In: COKOLINIS
Material: Brass/Bronze 2885399790
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Brass/Bronze 2885399790 400 x 400 (21)
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Material
7 x Słup-092 | Brass/Bronze 2885399790 (2)
5 x Słup-093 | Brass/Bronze 2885399790
8 x Słup-092 | Brass/Bronze 2885399790
Słup-092 | Brass/Bronze 2885399790 (3)

# IfcBuildingElementProxy: Brass/Bronze 2885399790 400 x 600 (7)
In: COKOLINIS
Material: Brass/Bronze 2885399790 (2)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Brass/Bronze 2885399790 400 x 900, Słup-093
In: COKOLINIS
Material: Brass/Bronze 2885399790 (3)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Chair 06 22 (2)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ciągła + kreski i kropki 361632836 20 (3)
In: PIRMAS
Material: Ciągła + kreski i kropki 361632836
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
Wall-902
Wall-901
Wall-900

# IfcBuildingElementProxy: Clock 22 (2)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Concrete Block - Filler (8)
Material: Concrete Block - Filler
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
3 x Mesh-011 | COKOLINIS
4 x Mesh-013 | 3. Story
Mesh-014 | 3. Story

# IfcBuildingElementProxy: Cupboard 22, Obiekt-0367
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Digital Board 22 (3)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Obiekt-0361 | COKOLINIS
2 x Obiekt-0361 | PIRMAS

# IfcBuildingElementProxy: Door 22 (38)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
4 x Drzwi-249 | COKOLINIS
Drzwi-257 | COKOLINIS
D2C0 | COKOLINIS | Pset_FireRatingProperties - FireResistanceRating: C0 S200
4 x D1 | COKOLINIS
3 x D1EW | COKOLINIS | Pset_FireRatingProperties - FireResistanceRating: EW30- C0
LD1 | COKOLINIS
3 x D1C0 | COKOLINIS | Pset_FireRatingProperties - FireResistanceRating: C0 S200
EW 30-C0 | COKOLINIS | Pset_FireRatingProperties - FireResistanceRating: C0 S200
Drzwi-252 | PIRMAS
7 x D1 | PIRMAS
3 x D1C0 | PIRMAS | Pset_FireRatingProperties - FireResistanceRating: C0 S200
Drzwi-247 | PIRMAS
2 x Drzwi-250 | PIRMAS
2 x D1C1 | PIRMAS | Pset_FireRatingProperties - FireResistanceRating: C1 S200
Drzwi-257 | PIRMAS
2 x Drzwi-258 | 1A ANT
D1 | 1A ANT

# IfcBuildingElementProxy: Door with Transom 22 (4)
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x Dv
Drzwi-257
DT

# IfcBuildingElementProxy: Double Door 22 (5)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | FireResistanceRating
D3C3 | COKOLINIS | C3S200
D3EW | COKOLINIS | EW30-C0
D3C3 | COKOLINIS | EW30-C0
D3EW | PIRMAS | EW30-C0
VV11 | PIRMAS | C3S200

# IfcBuildingElementProxy: Double Door Asymmetric 22 (2)
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Double Door with Transom 22 (2)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | FireResistanceRating
VV10 | COKOLINIS | C3S200
VV12 | PIRMAS | C3 S200

# IfcBuildingElementProxy: Elevator 22, Obiekt-0360
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Empty Fill 400723991 90, Wall-897
In: PIRMAS
Material: Empty Fill 400723991
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Exterior Double Sliding Door 22 (5)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x LfD | COKOLINIS
2 x LfD | PIRMAS
LfD | 1A ANT

# IfcBuildingElementProxy: Hand Dryer 22 (4)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
3 x Obiekt-0366 | COKOLINIS
Obiekt-0366 | PIRMAS

# IfcBuildingElementProxy: Horizontal Multi-Sash Window 22, L18
In: 1A ANT
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Lockers 22 (6)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
4 x Obiekt-0360 | COKOLINIS
2 x Obiekt-0360 | PIRMAS

# IfcBuildingElementProxy: Metal Mesh 20, Strop-108
In: COKOLINIS
Material: Metal Mesh
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Model Element 1, Pyramid:Pyramid:1595826
In: COKOLINIS
Material: Default Form
Pset_BuildingElementProxyCommon - Reference: Pyramid; sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Office Workstation Solo 22 (18)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
13 x Obiekt-0369 | COKOLINIS
5 x Obiekt-0369 | PIRMAS

# IfcBuildingElementProxy: Partition Panel 22 (8)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Pelne 271654779 200 (3)
Material: Pelne 271654779
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Strop-112 | -1. Story
Strop-108 | COKOLINIS

# IfcBuildingElementProxy: Pelne 271654779 50, Strop-108
In: PIRMAS
Material: Pelne 271654779
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Pelne 2985241961 193 (3)
Material: Pelne 2985241961
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Po³aæ-347 | COKOLINIS
2 x Po³aæ-347 | PIRMAS

# IfcBuildingElementProxy: Pelne 2985241961 20 (2)
In: 3. Story
Material: Pelne 2985241961
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Pelne 2985241961 249 (2)
In: COKOLINIS
Material: Pelne 2985241961
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Pelne 2985241961 30 (10)
Material: Pelne 2985241961
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
5 x Po³aæ-350 | 1A ANT
5 x Po³aæ-350 | 3. Story

# IfcBuildingElementProxy: Pelne 2985241961 350 (6)
In: 3. Story
Material: Pelne 2985241961
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Pelne 8756817 150, Wall-898
In: PIRMAS
Material: Pelne 8756817
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Puste 7019220, Obiekt-0368
In: 1A ANT
Material: Puste 7019220 (3)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Pyramid:Pyramid, Pyramid:Pyramid:1595826
In: -2. Story
Material: IFC Building Material
Pset_BuildingElementProxyCommon - Reference: Pyramid; sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Railing Type (21)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material
RAILING - 009 | -3. Story | Wypełnienie Puste 367153625 (6)
RAILING - 007 | PIRMAS | Wypełnienie Puste 367153625 (22)
RAILING - 008 | PIRMAS | Wypełnienie Puste 367153625 (18)
RAILING - 004 | PIRMAS | Puste 7019220 (118), Aluminium (15), Puste 877736882 (17), Pelne 3213109178 (15)
RAILING - 004 | PIRMAS | Pelne 336193678 (5), Aluminium (9), Puste 877736882 (9), Pelne 3213109178 (7), Puste 7019220 (52)
RAILING - 006 | PIRMAS | Pelne 3213109178 (17), Puste 877736882 (5)
RAILING - 005 | PIRMAS | Steel 4065202783 (2), Puste 877736882 (3), Wypełnienie Puste 367153625 (5), Dachówka 360859804 (3)
RAILING - 004 | PIRMAS | Aluminium (3), Puste 877736882 (3)
RAILING - 005 | PIRMAS | Steel 4065202783 (3), Puste 877736882 (5), Wypełnienie Puste 367153625 (10), Dachówka 360859804 (4)
RAILING - 006 | PIRMAS | Pelne 3213109178 (83), Puste 877736882 (5)
RAILING - 005 | PIRMAS | Steel 4065202783 (3), Wypełnienie Puste 367153625 (10), Puste 877736882 (3), Dachówka 360859804 (4)
RAILING - 004 | PIRMAS | Pelne 3213109178 (210), Puste 877736882 (3)
RAILING - 006 | PIRMAS | Pelne 3213109178 (17), Puste 877736882 (6)
RAILING - 006 | PIRMAS | Pelne 3213109178 (158), Puste 877736882 (9)
RAILING - 006 | PIRMAS | Pelne 3213109178 (34), Puste 877736882 (8)
RAILING - 004 | PIRMAS | Pelne 3213109178 (25), Puste 877736882
RAILING - 005 | PIRMAS | Steel 4065202783 (6), Wypełnienie Puste 367153625 (28), Puste 877736882 (6), Dachówka 360859804 (10)
RAILING - 006 | PIRMAS | Pelne 3213109178 (211), Steel, Galvanized (28), Puste 877736882 (30)
RAILING - 005 | 3. Story | Pelne 3213109178 (275), Pelne 269422880 (13)
RAILING - 005 | 3. Story | Pelne 3213109178 (100), Pelne 269422880 (7)
RAILING - 005 | 3. Story | Pelne 3213109178 (50), Pelne 269422880 (5)

# IfcBuildingElementProxy: SIENA 1 540, Wall-901
In: -1. Story
Material: Pelne 3213109178, Steel 272440816 (2), izolacja miekka 328125958
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Shower Kit 22 (9)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Stair Type (10)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material
2 x STAIR - 013 | COKOLINIS | beton maly 360589493, 100 % wypełnienia 533917132 (26)
2 x STAIR - 014 | COKOLINIS | Pelne 275581273
STAIR - 013 | COKOLINIS | beton maly 360589493 (3), Pelne 3213109178 (52)
STAIR - 013 | PIRMAS | beton maly 360589493, Pelne 3213109178 (26)
2 x STAIR - 016 | PIRMAS | beton zbrojony 4194059734, Concrete, Cast-in-Place gray (7)
STAIR - 013 | PIRMAS | beton maly 360589493, tynki zewnętrzne 320780862 (13)
STAIR - 013 | 1A ANT | beton maly 360589493, Pelne 3213109178 (26)

# IfcBuildingElementProxy: Steel 272440816 20 (2)
In: 1A ANT
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Material
Wall-897 | Steel 272440816 (2)
Wall-897 | Steel 272440816

# IfcBuildingElementProxy: Steel 272440816 30 (270)
In: PIRMAS
Material: Steel 272440816
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Text 3D 22 (2)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Toilet Paper Dispenser 22 (3)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Tree Model Detailed 22 (19)
In: -1. Story
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Triple Window 22, VV9
In: 1A ANT
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Urinal 22 (3)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x Obiekt-0365 | COKOLINIS
Obiekt-0365 | PIRMAS

# IfcBuildingElementProxy: Vertical Gable Louver 22 (4)
In: COKOLINIS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Vertical Multi-Sash Window 22 (32)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
2 x L12 | COKOLINIS
L11 | COKOLINIS
L13 | COKOLINIS
L14 | COKOLINIS
L10 | COKOLINIS
4 x L8 | COKOLINIS
L4 | COKOLINIS
L7 | COKOLINIS
2 x L5 | COKOLINIS
2 x L6 | COKOLINIS
L3 | COKOLINIS
5 x L1 | COKOLINIS
L9 | COKOLINIS
L17 | COKOLINIS
L2 | COKOLINIS
3 x L15 | PIRMAS
4 x L16 | PIRMAS

# IfcBuildingElementProxy: Vertical Sliding Garage Door 22 (2)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
LV1 | COKOLINIS
LV2 | PIRMAS

# IfcBuildingElementProxy: WC 22 (3)
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: WC Disabled 22 (4)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Obiekt-0367 | COKOLINIS
3 x Obiekt-0367 | PIRMAS

# IfcBuildingElementProxy: Wall Mounted Ladder 22 (2)
In: 1A ANT
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Washer 22, Obiekt-0367
In: PIRMAS
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Window 22 (16)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
Okno-112 | -1. Story
VV3 | COKOLINIS
VV2 | COKOLINIS
2 x VENT | COKOLINIS
VV1 | COKOLINIS
VV1A | COKOLINIS
Okno-113 | COKOLINIS
VV7 | PIRMAS
VV8 | PIRMAS
VV5 | PIRMAS
VV6 | PIRMAS
VV4 | PIRMAS
3 x VID | PIRMAS

# IfcBuildingElementProxy: beton zbrojony 4194059734 150 (3)
In: -1. Story
Material: beton zbrojony 4194059734
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
Wall-898
Wall-899
Wall-900

# IfcBuildingElementProxy: drewno 2782445217 120 x 20 (95)
In: 1A ANT
Material: drewno 2782445217
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: drewno 2782445217 300 x 20 (3)
In: 1A ANT
Material: drewno 2782445217
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: drewno 2782445217 32 x 32 (5)
In: COKOLINIS
Material: drewno 2782445217
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: drewno 2782445217 400 x 400 (4)
In: PIRMAS
Material: drewno 2782445217
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: izolacja miękka 1265117515 200, Strop-109
In: COKOLINIS
Material: izolacja miękka 1265117515
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: izolacja miękka 1265117515 600 (46)
In: -3. Story
Material: izolacja miękka 1265117515
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
Strop-131
2 x Strop-132
14 x Strop-102
Strop-134
Strop-128
Strop-129
Strop-127
Strop-092
Strop-123
Strop-137
Strop-125
Strop-126
Strop-130
Strop-140
Strop-141
Strop-098
Strop-100
Strop-101
Strop-103
Strop-105
Strop-106
Strop-107
Strop-109
Strop-110
Strop-112
Strop-113
Strop-117
Strop-118
Strop-142
Strop-120
Strop-135
Strop-136
