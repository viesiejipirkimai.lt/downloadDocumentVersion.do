Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcDistributionPort (1873)
Name | FlowDirection | Group
Port_5234360_1 | SOURCEANDSINK | V1 3 (1)
Port_5233018_0 | SOURCEANDSINK | V1 3 (1)
Port_5233020_2 | SOURCEANDSINK | V1 3 (1)
Port_5233018_1 | SOURCEANDSINK | V1 3 (1)
Port_5233028_1 | SOURCEANDSINK | V1 3 (1)
Port_5233066_0 | SOURCEANDSINK | V1 3 (1)
Port_5233230_2 | SOURCEANDSINK | V1 3 (1)
Port_5233066_1 | SOURCEANDSINK | V1 3 (1)
Port_5233334_1 | SOURCEANDSINK | V1 3 (1)
Port_5233181_0 | SOURCEANDSINK | V1 3 (1)
Port_5233230_1 | SOURCEANDSINK | V1 3 (1)
Port_5233181_1 | SOURCEANDSINK | V1 3 (1)
Port_5233194_1 | SOURCEANDSINK | V1 3 (1)
Port_5233218_0 | SOURCEANDSINK | V12 1
Port_5248990_1 | SOURCEANDSINK | V12 1
Port_5233218_1 | SOURCEANDSINK | V12 1
Port_5233330_3 | SOURCEANDSINK | V12 1
Port_5233221_0 | SOURCEANDSINK | V12 1
Port_5233330_1 | SOURCEANDSINK | V12 1
Port_5233221_1 | SOURCEANDSINK | V12 1
Port_5233307_2 | SOURCEANDSINK | V12 1
Port_5233334_2 | SOURCEANDSINK | V1 3 (1)
Port_5361451_0 | SOURCEANDSINK | V1 3 (1)
Port_5234358_1 | SOURCEANDSINK | V1 3 (1)
Port_5374039_0 | SOURCEANDSINK | V1 3 (1)
Port_5234360_2 | SOURCEANDSINK | V1 3 (1)
Port_5328197_1 | SOURCEANDSINK | V1 3 (1)
Port_5248990_2 | SOURCEANDSINK | V12 1
Port_5249018_1 | SOURCEANDSINK | V12 1
Port_5248990_3 | SOURCEANDSINK
Port_5249018_0 | SOURCEANDSINK | V12 1
Port_5249330_2 | SOURCEANDSINK | T3 2
Port_5250354_0 | SOURCEANDSINK | T3 2
Port_5249341_0 | SOURCEANDSINK | T3 2
Port_5250963_2 | SOURCEANDSINK | T3 2
Port_5249341_1 | SOURCEANDSINK | T3 2
Port_5250965_2 | SOURCEANDSINK | T3 2
Port_5249392_2 | SOURCEANDSINK | V1 3 (1)
Port_5249802_0 | SOURCEANDSINK | V1 3 (1)
Port_5249802_1 | SOURCEANDSINK | V1 3 (1)
Port_5250193_2 | SOURCEANDSINK | V1 3 (1)
Port_5250128_0 | SOURCEANDSINK | V1 3 (1)
Port_5250193_1 | SOURCEANDSINK | V1 3 (1)
Port_5250128_1 | SOURCEANDSINK | V1 3 (1)
Port_5250262_1 | SOURCEANDSINK | V1 3 (1)
Port_5250250_0 | SOURCEANDSINK | V1 3 (1)
Port_5250262_2 | SOURCEANDSINK | V1 3 (1)
Port_5250250_1 | SOURCEANDSINK | V1 3 (1)
Port_5345412_1 | SOURCEANDSINK | V1 3 (1)
Port_5250339_0 | SOURCEANDSINK | T3 2
Port_5250386_1 | SOURCEANDSINK | T3 2
Port_5250339_1 | SOURCEANDSINK | T3 2
Port_5250963_1 | SOURCEANDSINK | T3 2
Port_5250354_1 | SOURCEANDSINK | T3 2
Port_5250386_2 | SOURCEANDSINK | T3 2
Port_5250957_0 | SOURCEANDSINK | T3 2
Port_5250957_1 | SOURCEANDSINK | T3 2
Port_5250965_1 | SOURCEANDSINK | T3 2
Port_5251185_0 | SOURCEANDSINK | V1 3 (1)
Port_5329409_1 | SOURCEANDSINK | V1 3 (1)
Port_5251185_1 | SOURCEANDSINK | V1 3 (1)
Port_5345412_3 | SOURCEANDSINK | V1 3 (1)
Port_5252746_2 | SOURCEANDSINK | V1 3 (1)
Port_5252748_1 | SOURCEANDSINK | V1 3 (1)
Port_5252746_3 | SOURCEANDSINK
Port_5252748_0 | SOURCEANDSINK | V1 3 (1)
Port_5252904_2 | SOURCEANDSINK | V1 3 (1)
Port_5252904_1 | SOURCEANDSINK | V1 3 (1)
Port_5252906_1 | SOURCEANDSINK | V1 3 (1)
Port_5254320_1 | SOURCEANDSINK | T3 1
Port_5254322_1 | SOURCEANDSINK | T3 1
Port_5254320_2 | SOURCEANDSINK | T3 1
Port_5255607_0 | SOURCEANDSINK | T3 1
Port_5254823_1 | SOURCEANDSINK | V1 3 (1)
Port_5254825_1 | SOURCEANDSINK | V1 3 (1)
Port_5254823_2 | SOURCEANDSINK | V1 3 (1)
Port_5263737_0 | SOURCEANDSINK | V1 3 (1)
Port_5255457_2 | SOURCEANDSINK | T3 1
Port_5255607_1 | SOURCEANDSINK | T3 1
Port_5255457_3 | SOURCEANDSINK
Port_5263617_1 | SOURCEANDSINK | T3 1
Port_5263986_0 | SOURCEANDSINK | T3 1
Port_5263617_2 | SOURCEANDSINK | T3 1
Port_5263619_1 | SOURCEANDSINK | T3 1
Port_5263735_2 | SOURCEANDSINK | V1 3 (1)
Port_5263737_1 | SOURCEANDSINK | V1 3 (1)
Port_5263735_3 | SOURCEANDSINK
Port_5263984_1 | SOURCEANDSINK | T3 1
Port_5386551_0 | SOURCEANDSINK | T3 1
Port_5263984_2 | SOURCEANDSINK
Port_5263986_1 | SOURCEANDSINK
Port_5263984_3 | SOURCEANDSINK
Port_5264072_1 | SOURCEANDSINK | V1 3 (1)
Port_5264079_1 | SOURCEANDSINK | V1 3 (1)
Port_5264072_2 | SOURCEANDSINK | V1 3 (1)
Port_5264906_0 | SOURCEANDSINK | V1 3 (1)
Port_5264131_1 | SOURCEANDSINK | T3 1
Port_5264175_1 | SOURCEANDSINK | T3 1
Port_5264131_2 | SOURCEANDSINK | T3 1
Port_5264952_0 | SOURCEANDSINK | T3 1
Port_5264250_1 | SOURCEANDSINK | T3 1
Port_5264259_1 | SOURCEANDSINK | T3 1
Port_5264250_2 | SOURCEANDSINK | T3 1
Port_5265050_0 | SOURCEANDSINK | T3 1
Port_5264292_1 | SOURCEANDSINK | V1 3 (1)
Port_5264343_1 | SOURCEANDSINK | V1 3 (1)
Port_5264292_2 | SOURCEANDSINK | V1 3 (1)
Port_5265114_0 | SOURCEANDSINK | V1 3 (1)
Port_5264467_1 | SOURCEANDSINK | V1 3 (1)
Port_5330451_0 | SOURCEANDSINK | V1 3 (1)
Port_5264467_2 | SOURCEANDSINK | V1 3 (1)
Port_5264469_1 | SOURCEANDSINK | V1 3 (1)
Port_5264503_2 | SOURCEANDSINK | T3 3
Port_5329957_1 | SOURCEANDSINK | T3 3
Port_5264887_2 | SOURCEANDSINK | V1 3 (1)
Port_5264906_1 | SOURCEANDSINK | V1 3 (1)
Port_5264887_3 | SOURCEANDSINK
Port_5264937_2 | SOURCEANDSINK
Port_5264952_1 | SOURCEANDSINK
Port_5264937_3 | SOURCEANDSINK
Port_5265038_2 | SOURCEANDSINK
Port_5265050_1 | SOURCEANDSINK
Port_5265038_3 | SOURCEANDSINK
Port_5265098_2 | SOURCEANDSINK | V1 3 (1)
Port_5265114_1 | SOURCEANDSINK | V1 3 (1)
Port_5265098_3 | SOURCEANDSINK
Port_5285358_2 | SOURCEANDSINK | V12 1
Port_5285619_2 | SOURCEANDSINK | V12 1
Port_5285811_2 | SOURCEANDSINK | V12 1
Port_5286019_2 | SOURCEANDSINK | V12 1
InPort_5303171_2 | SINK | T4 5
OutPort_5303500_1 | SOURCE | T4 5
Port_5323584_1 | SOURCEANDSINK | V1 3 (1)
Port_5323586_1 | SOURCEANDSINK | V1 3 (1)
Port_5325250_1 | SOURCEANDSINK | V1 3 (1)
Port_5327239_1 | SOURCEANDSINK | V1 3 (1)
Port_5325250_2 | SOURCEANDSINK | V1 3 (1)
Port_5325254_1 | SOURCEANDSINK | T3 7
Port_5326735_0 | SOURCEANDSINK | T3 7
Port_5325254_2 | SOURCEANDSINK | T3 7
Port_5325361_1 | SOURCEANDSINK | V1 3 (1)
Port_5327344_1 | SOURCEANDSINK | V1 3 (1)
Port_5325361_2 | SOURCEANDSINK | V1 3 (1)
Port_5325365_1 | SOURCEANDSINK | T3 7
Port_5325371_0 | SOURCEANDSINK | T3 7
Port_5325365_2 | SOURCEANDSINK | T3 7
Port_5325369_0 | SOURCEANDSINK | V1 3 (1)
Port_5327339_3 | SOURCEANDSINK | V1 3 (1)
Port_5325369_1 | SOURCEANDSINK | V1 3 (1)
Port_5327373_1 | SOURCEANDSINK | V1 3 (1)
Port_5325371_1 | SOURCEANDSINK | T3 7
Port_5326779_3 | SOURCEANDSINK | T3 7
Port_5326735_1 | SOURCEANDSINK | T3 7
Port_5326749_1 | SOURCEANDSINK | T3 7
Port_5326749_2 | SOURCEANDSINK | T3 7
Port_5326780_0 | SOURCEANDSINK | T3 7
Port_5326779_1 | SOURCEANDSINK | T3 7
Port_5327477_0 | SOURCEANDSINK | T3 7
Port_5326779_2 | SOURCEANDSINK | T3 7
Port_5326780_1 | SOURCEANDSINK | T3 7
Port_5327204_1 | SOURCEANDSINK | V1 3 (1)
Port_5327340_0 | SOURCEANDSINK | V1 3 (1)
Port_5327204_2 | SOURCEANDSINK | V1 3 (1)
Port_5327231_0 | SOURCEANDSINK | V1 3 (1)
Port_5327231_1 | SOURCEANDSINK | V1 3 (1)
Port_5327278_1 | SOURCEANDSINK | V1 3 (1)
Port_5327239_0 | SOURCEANDSINK | V1 3 (1)
Port_5327278_2 | SOURCEANDSINK | V1 3 (1)
Port_5327339_1 | SOURCEANDSINK | V1 3 (1)
Port_5327446_0 | SOURCEANDSINK | V1 3 (1)
Port_5327339_2 | SOURCEANDSINK | V1 3 (1)
Port_5327340_1 | SOURCEANDSINK | V1 3 (1)
Port_5327344_0 | SOURCEANDSINK | V1 3 (1)
Port_5327373_2 | SOURCEANDSINK | V1 3 (1)
Port_5327446_1 | SOURCEANDSINK | V1 3 (1)
Port_5327507_1 | SOURCEANDSINK | V1 3 (1)
Port_5327477_1 | SOURCEANDSINK | T3 7
Port_5327540_1 | SOURCEANDSINK | T3 7
Port_5327499_0 | SOURCEANDSINK | V1 3 (1)
Port_5327507_2 | SOURCEANDSINK | V1 3 (1)
Port_5327499_1 | SOURCEANDSINK | V1 3 (1)
Port_5327765_1 | SOURCEANDSINK | V1 3 (1)
Port_5327532_0 | SOURCEANDSINK | T3 7
Port_5327540_2 | SOURCEANDSINK | T3 7
Port_5327532_1 | SOURCEANDSINK | T3 7
Port_5327601_1 | SOURCEANDSINK | T3 7
Port_5327589_0 | SOURCEANDSINK | T3 7
Port_5327601_2 | SOURCEANDSINK | T3 7
Port_5327589_1 | SOURCEANDSINK | T3 7
Port_5327663_1 | SOURCEANDSINK | T3 7
Port_5327605_0 | SOURCEANDSINK | T3 5
Port_5327659_2 | SOURCEANDSINK | T3 5
Port_5327605_1 | SOURCEANDSINK | T3 5
Port_5327663_2 | SOURCEANDSINK | T3 5
Port_5327630_0 | SOURCEANDSINK | T3 5
Port_5328588_1 | SOURCEANDSINK | T3 5
Port_5327630_1 | SOURCEANDSINK | T3 5
Port_5327659_1 | SOURCEANDSINK | T3 5
Port_5327632_2 | SOURCEANDSINK | T3 3
Port_5327633_1 | SOURCEANDSINK | T3 3
Port_5327632_3 | SOURCEANDSINK | T3 3
Port_5328590_0 | SOURCEANDSINK | T3 3
Port_5327759_0 | SOURCEANDSINK | V1 3 (1)
Port_5328647_1 | SOURCEANDSINK | V1 3 (1)
Port_5327759_1 | SOURCEANDSINK | V1 3 (1)
Port_5328223_1 | SOURCEANDSINK | V1 3 (1)
Port_5327765_2 | SOURCEANDSINK | V1 3 (1)
Port_5328649_0 | SOURCEANDSINK | V1 3 (1)
Port_5327918_0 | SOURCEANDSINK | V1 3 (1)
Port_5328223_2 | SOURCEANDSINK | V1 3 (1)
Port_5327918_1 | SOURCEANDSINK | V1 3 (1)
Port_5328227_3 | SOURCEANDSINK | V1 3 (1)
Port_5328197_0 | SOURCEANDSINK | V1 3 (1)
Port_5328227_1 | SOURCEANDSINK | V1 3 (1)
Port_5328227_2 | SOURCEANDSINK | V1 3 (1)
Port_5328228_1 | SOURCEANDSINK | V1 3 (1)
Port_5328228_0 | SOURCEANDSINK | V1 3 (1)
Port_5374038_1 | SOURCEANDSINK | V1 3 (1)
Port_5328588_2 | SOURCEANDSINK | T3 3
Port_5328590_1 | SOURCEANDSINK | T3 3
Port_5328647_2 | SOURCEANDSINK | V1 3 (1)
Port_5328649_1 | SOURCEANDSINK | V1 3 (1)
Port_5329311_0 | SOURCEANDSINK | V1 3 (1)
Port_5329409_2 | SOURCEANDSINK | V1 3 (1)
Port_5329311_1 | SOURCEANDSINK | V1 3 (1)
Port_5329867_0 | SOURCEANDSINK | V1 3 (1)
Port_5329905_1 | SOURCEANDSINK | V1 3 (1)
Port_5329867_1 | SOURCEANDSINK | V1 3 (1)
Port_5329907_3 | SOURCEANDSINK | V1 3 (1)
Port_5329902_0 | SOURCEANDSINK | V1 3 (1)
Port_5329907_1 | SOURCEANDSINK | V1 3 (1)
Port_5329907_2 | SOURCEANDSINK | V1 3 (1)
Port_5329908_1 | SOURCEANDSINK | V1 3 (1)
Port_5329908_0 | SOURCEANDSINK | V1 3 (1)
Port_5330449_1 | SOURCEANDSINK | V1 3 (1)
Port_5329922_0 | SOURCEANDSINK | T3 6
Port_5329960_1 | SOURCEANDSINK | T3 6
Port_5329922_1 | SOURCEANDSINK | T3 6
Port_5329962_3 | SOURCEANDSINK | T3 6
Port_5329957_0 | SOURCEANDSINK | T3 3
Port_5330468_1 | SOURCEANDSINK | T3 3
Port_5329962_1 | SOURCEANDSINK | T3 3
Port_5330470_0 | SOURCEANDSINK | T3 3
Port_5329962_2 | SOURCEANDSINK | T3 3
Port_5329963_1 | SOURCEANDSINK | T3 3
Port_5330050_1 | SOURCEANDSINK | V1 3 (1)
Port_5330109_1 | SOURCEANDSINK | V1 3 (1)
Port_5330449_2 | SOURCEANDSINK | V1 3 (1)
Port_5330451_1 | SOURCEANDSINK | V1 3 (1)
Port_5330449_3 | SOURCEANDSINK
Port_5330468_2 | SOURCEANDSINK
Port_5330470_1 | SOURCEANDSINK
Port_5330468_3 | SOURCEANDSINK
Port_5331248_0 | SOURCEANDSINK | T3 1
Port_5331256_2 | SOURCEANDSINK | T3 1
Port_5331248_1 | SOURCEANDSINK | T3 1
Port_5331285_0 | SOURCEANDSINK | V1 3 (3)
Port_5331291_2 | SOURCEANDSINK | V1 3 (3)
Port_5331285_1 | SOURCEANDSINK | V1 3 (3)
Port_5335786_1 | SOURCEANDSINK | V1 3 (1)
Port_5335788_1 | SOURCEANDSINK | V1 3 (1)
Port_5335841_2 | SOURCEANDSINK | T3 2
Port_5386756_1 | SOURCEANDSINK | T3 2
OutPort_5343848_1 | SOURCE | Other 4
Port_5345412_2 | SOURCEANDSINK | V1 3 (1)
Port_5345436_0 | SOURCEANDSINK | V1 3 (1)
Port_5345436_1 | SOURCEANDSINK | V1 3 (1)
Port_5345456_2 | SOURCEANDSINK | V1 3 (1)
Port_5345448_0 | SOURCEANDSINK | V1 3 (1)
Port_5345456_1 | SOURCEANDSINK | V1 3 (1)
Port_5345448_1 | SOURCEANDSINK | V1 3 (1)
Port_5346124_1 | SOURCEANDSINK | V1 3 (1)
Port_5345458_0 | SOURCEANDSINK | V1 3 (1)
Port_5346124_2 | SOURCEANDSINK | V1 3 (1)
Port_5345458_1 | SOURCEANDSINK | V1 3 (1)
Port_5345939_1 | SOURCEANDSINK | V1 3 (1)
Port_5345939_2 | SOURCEANDSINK | T3 8
Port_5346318_0 | SOURCEANDSINK | V1 14
Port_5346318_1 | SOURCEANDSINK | V1 14
Port_5346321_1 | SOURCEANDSINK | V1 14
Port_5348499_0 | SOURCEANDSINK | V1 3 (1)
Port_5348731_2 | SOURCEANDSINK | V1 3 (1)
Port_5348499_1 | SOURCEANDSINK | V1 3 (1)
Port_5348507_1 | SOURCEANDSINK | V1 3 (1)
Port_5348501_0 | SOURCEANDSINK | V1 3 (1)
Port_5348731_1 | SOURCEANDSINK | V1 3 (1)
Port_5348501_1 | SOURCEANDSINK | V1 3 (1)
Port_5348735_3 | SOURCEANDSINK | V1 3 (1)
Port_5348503_1 | SOURCEANDSINK | V1 3 (1)
Port_5349204_1 | SOURCEANDSINK | V1 3 (1)
Port_5348503_2 | SOURCEANDSINK | V1 3 (1)
Port_5348507_2 | SOURCEANDSINK | V1 3 (1)
Port_5349204_0 | SOURCEANDSINK | V1 3 (1)
Port_5348509_0 | SOURCEANDSINK | T3 1
Port_5349111_2 | SOURCEANDSINK | T3 1
Port_5348509_1 | SOURCEANDSINK | T3 1
Port_5348517_1 | SOURCEANDSINK | T3 1
Port_5348513_1 | SOURCEANDSINK | T3 1
Port_5349180_1 | SOURCEANDSINK | T3 1
Port_5348513_2 | SOURCEANDSINK | T3 1
Port_5348517_2 | SOURCEANDSINK | T3 1
Port_5349180_0 | SOURCEANDSINK | T3 1
Port_5348525_0 | SOURCEANDSINK | T3 1
Port_5349111_1 | SOURCEANDSINK | T3 1
Port_5348525_1 | SOURCEANDSINK | T3 1
Port_5349113_3 | SOURCEANDSINK | T3 1
Port_5348726_0 | SOURCEANDSINK | V1 3 (1)
Port_5348735_1 | SOURCEANDSINK | V1 3 (1)
Port_5348735_2 | SOURCEANDSINK | V1 3 (1)
Port_5348736_0 | SOURCEANDSINK | V1 3 (1)
Port_5348736_1 | SOURCEANDSINK | V1 3 (1)
Port_5348868_2 | SOURCEANDSINK | V1 3 (1)
Port_5349108_0 | SOURCEANDSINK | T3 1
Port_5349113_1 | SOURCEANDSINK | T3 1
Port_5349113_2 | SOURCEANDSINK | T3 1
Port_5349114_0 | SOURCEANDSINK | T3 1
Port_5349114_1 | SOURCEANDSINK | T3 1
Port_5349165_2 | SOURCEANDSINK | T3 1
Port_5361451_1 | SOURCEANDSINK | V1 3 (1)
Port_5367370_2 | SOURCEANDSINK | V1 3 (1)
Port_5367483_0 | SOURCEANDSINK | V1 3 (1)
Port_5367481_1 | SOURCEANDSINK | V1 3 (1)
Port_5367483_1 | SOURCEANDSINK | V1 3 (1)
Port_5371541_2 | SOURCEANDSINK | V1 3 (1)
Port_5372647_0 | SOURCEANDSINK | V1 3 (1)
Port_5371588_0 | SOURCEANDSINK | V1 3 (1)
Port_5372649_2 | SOURCEANDSINK | V1 3 (1)
Port_5372647_1 | SOURCEANDSINK | V1 3 (1)
Port_5372649_1 | SOURCEANDSINK | V1 3 (1)
InPort_5373236_1 | SINK | V1 3 (1)
OutPort_5373480_0 | SOURCE | V1 3 (1)
InPort_5373237_1 | SINK | V1 3 (1)
OutPort_5373236_2 | SOURCE | V1 3 (1)
Port_5373236_3 | SOURCEANDSINK
Port_5373237_0 | SOURCEANDSINK | V1 3 (1)
Port_5373496_2 | SOURCEANDSINK | V1 3 (1)
Port_5373239_0 | SOURCEANDSINK | V1 3 (1)
Port_5373478_2 | SOURCEANDSINK | V1 3 (1)
Port_5373239_1 | SOURCEANDSINK | V1 3 (1)
Port_5373478_1 | SOURCEANDSINK | V1 3 (1)
Port_5373480_1 | SOURCEANDSINK | V1 3 (1)
Port_5373496_1 | SOURCEANDSINK | V1 3 (1)
Port_5373498_1 | SOURCEANDSINK | V1 3 (1)
Port_5373498_0 | SOURCEANDSINK | V1 3 (1)
Port_5374046_1 | SOURCEANDSINK | V1 3 (1)
Port_5373598_0 | SOURCEANDSINK | V1 3 (1)
Port_5374046_2 | SOURCEANDSINK | V1 3 (1)
Port_5373598_1 | SOURCEANDSINK | V1 3 (1)
Port_5374048_2 | SOURCEANDSINK | V1 3 (1)
Port_5374036_0 | SOURCEANDSINK | V1 3 (1)
Port_5374038_3 | SOURCEANDSINK | V1 3 (1)
Port_5374036_1 | SOURCEANDSINK | V1 3 (1)
Port_5374048_1 | SOURCEANDSINK | V1 3 (1)
Port_5374038_2 | SOURCEANDSINK | V1 3 (1)
Port_5374039_1 | SOURCEANDSINK | V1 3 (1)
Port_5386147_0 | SOURCEANDSINK | T3 1
Port_5386200_1 | SOURCEANDSINK | T3 1
Port_5386147_1 | SOURCEANDSINK | T3 1
Port_5386202_3 | SOURCEANDSINK | T3 1
Port_5386149_0 | SOURCEANDSINK | T3 1
Port_5386200_2 | SOURCEANDSINK | T3 1
Port_5386149_1 | SOURCEANDSINK | T3 1
Port_5386155_1 | SOURCEANDSINK | T3 1
Port_5386153_0 | SOURCEANDSINK | T3 1
Port_5386155_2 | SOURCEANDSINK | T3 1
Port_5386153_1 | SOURCEANDSINK | T3 1
Port_5386195_0 | SOURCEANDSINK | T3 1
Port_5386202_1 | SOURCEANDSINK | T3 1
Port_5386202_2 | SOURCEANDSINK | T3 1
Port_5386537_1 | SOURCEANDSINK | T3 1
Port_5386378_0 | SOURCEANDSINK | T3 1
Port_5386544_2 | SOURCEANDSINK | T3 1
Port_5386378_1 | SOURCEANDSINK | T3 1
Port_5386550_3 | SOURCEANDSINK | T3 1
Port_5386380_0 | SOURCEANDSINK | T3 1
Port_5386544_1 | SOURCEANDSINK | T3 1
Port_5386380_1 | SOURCEANDSINK | T3 1
Port_5386537_0 | SOURCEANDSINK | T3 1
Port_5386550_1 | SOURCEANDSINK | T3 1
Port_5386550_2 | SOURCEANDSINK | T3 1
Port_5386551_1 | SOURCEANDSINK | T3 1
Port_5386598_0 | SOURCEANDSINK | T3 2
Port_5386772_2 | SOURCEANDSINK | T3 2
Port_5386598_1 | SOURCEANDSINK | T3 2
Port_5386776_3 | SOURCEANDSINK | T3 2
Port_5386600_0 | SOURCEANDSINK | T3 2
Port_5386772_1 | SOURCEANDSINK | T3 2
Port_5386600_1 | SOURCEANDSINK | T3 2
Port_5386606_2 | SOURCEANDSINK | T3 2
Port_5386602_0 | SOURCEANDSINK | T3 2
Port_5386606_1 | SOURCEANDSINK | T3 2
Port_5386602_1 | SOURCEANDSINK | T3 2
Port_5386756_0 | SOURCEANDSINK | T3 2
Port_5386776_1 | SOURCEANDSINK | T3 2
Port_5386776_2 | SOURCEANDSINK | T3 2
Port_5386777_1 | SOURCEANDSINK | T3 2
Port_5386816_0 | SOURCEANDSINK | T3 2
Port_5386967_2 | SOURCEANDSINK | T3 2
Port_5386816_1 | SOURCEANDSINK | T3 2
Port_5386973_3 | SOURCEANDSINK | T3 2
Port_5386818_0 | SOURCEANDSINK | T3 2
Port_5386967_1 | SOURCEANDSINK | T3 2
Port_5386818_1 | SOURCEANDSINK | T3 2
Port_5386824_1 | SOURCEANDSINK | T3 2
Port_5386822_0 | SOURCEANDSINK | T3 2
Port_5386824_2 | SOURCEANDSINK | T3 2
Port_5386822_1 | SOURCEANDSINK | T3 2
Port_5386964_0 | SOURCEANDSINK | T3 2
Port_5386973_1 | SOURCEANDSINK | T3 2
Port_5386973_2 | SOURCEANDSINK | T3 2
Port_5386974_1 | SOURCEANDSINK | T3 2
OutPort_5388167_2 | SOURCE

# IfcElementAssembly: Pipe Fittings Assembly:Pipe Fittings 002, Pipe Fittings Assembly:Pipe Fittings 002:5098485
In: -1 Baseino dugnas
Pset_QuantityTakeOff - Reference: Pipe Fittings 002

# IfcElementAssembly: Pipe Fittings Assembly:Pipe Fittings 003, Pipe Fittings Assembly:Pipe Fittings 003:5098633
In: -1 Baseino dugnas
Pset_QuantityTakeOff - Reference: Pipe Fittings 003

# IfcElementAssembly: Pipe Fittings Assembly:Pipe Fittings 005, Pipe Fittings Assembly:Pipe Fittings 005:5102014
In: 0. Cokolinis Vandentiekis
Pset_QuantityTakeOff - Reference: Pipe Fittings 005

# IfcElementAssembly: Pipe Fittings Assembly:Praustuvu pajungimo fitingai, Pipe Fittings Assembly:Praustuvu pajungimo fitingai:5098128
In: -1 Baseino dugnas
Pset_QuantityTakeOff - Reference: Praustuvu pajungimo fitingai

# IfcFlowController: BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 1" - DCA7 (6)
In: 0. Cokolinis Vandentiekis
Type - Material: <Unnamed>, Metal - BSS - DZR Brass, Plastic - BSS- Black, Steel, Chrome Plated
Type - Pset_ElementShading - Color: Black & Bronze
Type - Pset_ManufacturerTypeInformation - ModelReference: BOSS Solenoid DCA; Manufacturer: BSS Industrial; ProductionYear: 2021
Classification: D30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Solenoidinis voztuvas 1" - DCA7; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please record on commissioning; SerialNumber: Please record on commissioning
Name (BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 1" - DCA7:...) | Group
5248990 | V12 1
5252746 | V1 3 (1)
5264887 | V1 3 (1)
5264937 | T3 1
5265038 | T3 1
5265098 | V1 3 (1)

# IfcFlowController: BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 1/2" - DCA4 (3)
In: 0. Cokolinis Vandentiekis
Type - Material: T3, Metal - BSS - DZR Brass, Plastic - BSS- Black, Steel, Chrome Plated
Type - Pset_ElementShading - Color: Black & Bronze
Type - Pset_ManufacturerTypeInformation - ModelReference: BOSS Solenoid DCA; Manufacturer: BSS Industrial; ProductionYear: 2021
Classification: D30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Solenoidinis voztuvas 1/2" - DCA4; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please record on commissioning; SerialNumber: Please record on commissioning
Name (BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 1/2" - DCA4:...) | Group
5263984 | T3 1
5330449 | V1 3 (1)
5330468 | T3 3

# IfcFlowController: BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 3/4" - DCA6 (2)
In: 0. Cokolinis Vandentiekis
Type - Material: T3, Metal - BSS - DZR Brass, Plastic - BSS- Black, Steel, Chrome Plated
Type - Pset_ElementShading - Color: Black & Bronze
Type - Pset_ManufacturerTypeInformation - ModelReference: BOSS Solenoid DCA; Manufacturer: BSS Industrial; ProductionYear: 2021
Classification: D30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Solenoidinis voztuvas 3/4" - DCA6; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please record on commissioning; SerialNumber: Please record on commissioning
Name (BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 3/4" - DCA6:...) | Group
5255457 | T3 1; T3 2
5263735 | V1 3 (1)

# IfcFlowController: Backflow_Preventer-DC-Zurn_Wilkins-Model_950XL-(0.75-2_Inch):Atbulinio srauto vožtuvas D50, Backflow_Preventer-DC-Zurn_Wilkins-Model_950XL-(0.75-2_Inch):Atbulinio srauto vožtuvas D50:5229649
In: 0. Cokolinis Vandentiekis
Type - Material: Paint - Zurn - Brass, Paint - Zurn - Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zurn Wilkins
Classification: D2090800 Uniformat (Uniformat); Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: Atbulinio srauto vožtuvas D50; sets with these values: 2

# IfcFlowController: Butterfly_Valve_600700_RB_Brass-M3_000001:Family with type catalog (4)
In: 0. Cokolinis Vandentiekis
Type - Material: Ottone-RBS-CW617N-UNI_EN_12165
Type - Pset_ManufacturerTypeInformation - Manufacturer: Rubinetterie Bresciane Bonomi
Pset_DistributionFlowElementCommon - Reference: Family with type catalog; sets with these values: 2
Group: V12 1
Name (Butterfly_Valve_600700_RB_Brass-M3_000001:Family with type catalog:...)
5285358
5285619
5285811
5286019

# IfcFlowController: Çalpara Çek Vana:DN 65, Çalpara Çek Vana:DN 65:5218264
In: 0. Cokolinis Vandentiekis
Type - Material: GG25, Civata
Type - Pset_ManufacturerTypeInformation - Manufacturer: Duyar Vana
Pset_DistributionFlowElementCommon - Reference: DN 65; sets with these values: 2
Group: V1 4

# IfcFlowController: DANFOSS MTCV:DN20, DANFOSS MTCV:DN20:5303171
In: 0. Cokolinis Vandentiekis
Type - Material: Danfoss Латунь, T4, Plastic - Danfoss - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: Danfoss
Pset_DistributionFlowElementCommon - Reference: DN20; sets with these values: 2
Group: T4 6; T4 5

# IfcFlowController: Danfoss_X1666_RFA_2020_LevelBased (1)1:Ventilis DN25 (3)
In: 0. Cokolinis Vandentiekis
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Danfoss
Pset_DistributionFlowElementCommon - Reference: Ventilis DN25; sets with these values: 2
Name (Danfoss_X1666_RFA_2020_LevelBased (1)1:Ventilis DN25:...) | Group
5187509 | V12 1
5187573 | V12 1
5227030 | V1 3 (1)

# IfcFlowController: Danfoss_X1666_RFA_2020_LevelBased (1):Ventilis DN20, Danfoss_X1666_RFA_2020_LevelBased (1):Ventilis DN20:5104336
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Danfoss
Pset_DistributionFlowElementCommon - Reference: Ventilis DN20; sets with these values: 2
Group: V1 8

# IfcFlowController: Danfoss_X1666_RFA_2020_LevelBased (1):Ventilis DN32, Danfoss_X1666_RFA_2020_LevelBased (1):Ventilis DN32:5131531
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Danfoss
Pset_DistributionFlowElementCommon - Reference: Ventilis DN32; sets with these values: 2
Group: V1 3 (1)

# IfcFlowController: Flanšinė sklendė:DN65 (2)
In: 0. Cokolinis Vandentiekis
Type - Material: K. ketus, Plienas, Kalus ketus
Type - Pset_ManufacturerTypeInformation - Manufacturer: Brymec
Pset_DistributionFlowElementCommon - Reference: DN65; sets with these values: 2
Pset_PipeConnectionFlanged - FlangeThickness: 16.9 mm
Name (Flanšinė sklendė:DN65:...) | Group
5104325 | V1 8; V1 4
5104326 | V1 7; V1 1

# IfcFlowController: HL_Abdichtgarnitur_HL0540.4E:HL0540.4E_Main Component (10)
In: 1. Pirmas
Type - Material: Plactic - Black, Foil
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL0540.4E_Main Component; sets with these values: 2
Name (HL_Abdichtgarnitur_HL0540.4E:HL0540.4E_Main Component:...)
4770613
4785074
4785098
4785203
4819022
4850312
4850323
4850334
4850343
5348013

# IfcFlowController: HL_Aufstockelement_HL0540.2E:HL0540.2E_Main Component (10)
In: 1. Pirmas
Type - Material: Stainless Steel, Plactic - Gray
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL0540.2E_Main Component; sets with these values: 2
Name (HL_Aufstockelement_HL0540.2E:HL0540.2E_Main Component:...)
4770612
4785073
4785097
4785202
4819021
4850311
4850322
4850333
4850342
5348012

# IfcFlowController: HL_Befestigungswinkel_HL0540.3E:HL0540.3E_Main Component (30)
In: 1. Pirmas
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL0540.3E_Main Component; sets with these values: 2
Name (HL_Befestigungswinkel_HL0540.3E:HL0540.3E_Main Component:...)
4770615
4770616
4770617
4785076
4785077
4785078
4785100
4785101
4785102
4785205
4785206
4785207
4819024
4819025
4819026
4850314
4850315
4850316
4850325
4850326
4850327
4850336
4850337
4850338
4850345
4850346
4850347
5348015
5348016
5348017

# IfcFlowController: HL_Bodenablaufkörper_HL540K:HL540K_Main Component (10)
In: 1. Pirmas
Type - Material: Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL540K_Main Component; sets with these values: 2
Name (HL_Bodenablaufkörper_HL540K:HL540K_Main Component:...)
4770611
4785072
4785096
4785201
4819020
4850310
4850321
4850332
4850341
5348011

# IfcFlowController: HL_Einlaufrost_HL066Q.1E:HL066Q.1E (10)
In: 1. Pirmas
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Pset_DistributionFlowElementCommon - Reference: HL066Q.1E; sets with these values: 2
Name (HL_Einlaufrost_HL066Q.1E:HL066Q.1E:...)
4770610
4785071
4785095
4785200
4819019
4850309
4850320
4850331
4850340
5348010

# IfcFlowController: HL_Geruchverschluss_HL2040:HL2040_Main Component (10)
In: 1. Pirmas
Type - Material: Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL2040_Main Component; sets with these values: 2
Name (HL_Geruchverschluss_HL2040:HL2040_Main Component:...)
4770614
4785075
4785099
4785204
4819023
4850313
4850324
4850335
4850344
5348014

# IfcFlowController: Handle_Valve_600700_RB_PA6_Blue-M3_000001:DN15_25 (4)
In: 0. Cokolinis Vandentiekis
Type - Material: Polyamide-RB-PA6-Domamid_6GB302
Type - Pset_ManufacturerTypeInformation - Manufacturer: Rubinetterie Bresciane Bonomi
Pset_DistributionFlowElementCommon - Reference: DN15_25; sets with these values: 2
Name (Handle_Valve_600700_RB_PA6_Blue-M3_000001:DN15_25:...)
5285360
5285621
5285813
5286021

# IfcFlowController: Hose-Tail_600700_RB_Brass-M3_000001:DN15 (4)
In: 0. Cokolinis Vandentiekis
Type - Material: Brass-RB-CW617N-UNI_EN_12165-Nickel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Rubinetterie Bresciane Bonomi
Pset_DistributionFlowElementCommon - Reference: DN15; sets with these values: 2
Name (Hose-Tail_600700_RB_Brass-M3_000001:DN15:...)
5285359
5285620
5285812
5286020

# IfcFlowController: P_VALVE BALL_WATER_2121R_MF_Manifold_Acc_Tiemmerfa:Ventilis DN15 (G1/2") MF d16 (5)
Type - Material: Tiemme_BRASS-CW617N_Nickel, Tiemme logo, Tiemme_Aluminium_Painted-RED
Type - Pset_DuctConnection - ConnectionType: ISO 228(Water)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TIEMME Original Italian Trademark
Type - Pset_PipeConnection - ConnectionType: ISO 228(Water)
Pset_DistributionFlowElementCommon - Reference: Ventilis DN15 (G1/2") MF d16; sets with these values: 2
Name (P_VALVE BALL_WATER_2121R_MF_Manifold_Acc_Tiemmerfa:Ventilis DN15 (G1/2") MF d16:...) | In | Group
5263617 | 0. Cokolinis Vandentiekis | T3 1
5264467 | 0. Cokolinis Vandentiekis | V1 3 (1)
5264503 | 0. Cokolinis Vandentiekis | T3 3
5328588 | 1. Pirmas | T3 3; T3 5
5328647 | 1. Pirmas | V1 3 (1)

# IfcFlowController: P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN15 (G1/2") MF (3)
In: 0. Cokolinis Vandentiekis
Type - Material: Tiemme_BRASS-CW617N_Nickel, Tiemme_Stainless-Steel_AISI302
Type - Pset_DuctConnection - ConnectionType: ISO 228(Water)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TIEMME Original Italian Trademark
Type - Pset_PipeConnection - ConnectionType: ISO 228(Water)
Material: Tiemme_Stainless-Steel_AISI302, Tiemme_Aluminium-Painted_BLACK, Tiemme_BRASS-CW617N_Nickel, Tiemme logo; Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: Ventilis DN15 (G1/2") MF; sets with these values: 2
Name (P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN15 (G1/2") MF:...)
5228639
5373478
5373496

# IfcFlowController: P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN20 (G3/4") MF (5)
In: 0. Cokolinis Vandentiekis
Type - Material: Tiemme_BRASS-CW617N_Nickel, Tiemme_Stainless-Steel_AISI302
Type - Pset_DuctConnection - ConnectionType: ISO 228(Water)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TIEMME Original Italian Trademark
Type - Pset_PipeConnection - ConnectionType: ISO 228(Water)
Material: Tiemme_Stainless-Steel_AISI302, Tiemme_Aluminium-Painted_BLACK, Tiemme_BRASS-CW617N_Nickel, Tiemme logo
Pset_DistributionFlowElementCommon - Reference: Ventilis DN20 (G3/4") MF; sets with these values: 2
Name (P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN20 (G3/4") MF:...) | Group
5230929 | V1 3 (1)
5231190 | V1 3 (1)
5254320 | T3 1
5254823 | V1 3 (1)
5335786 | V1 3 (1)

# IfcFlowController: P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN25 (G1") MF (6)
In: 0. Cokolinis Vandentiekis
Type - Material: Tiemme_BRASS-CW617N_Nickel, Tiemme_Stainless-Steel_AISI302
Type - Pset_DuctConnection - ConnectionType: ISO 228(Water)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TIEMME Original Italian Trademark
Type - Pset_PipeConnection - ConnectionType: ISO 228(Water)
Material: Tiemme_Stainless-Steel_AISI302, Tiemme_Aluminium-Painted_BLACK, Tiemme_BRASS-CW617N_Nickel, Tiemme logo
Pset_DistributionFlowElementCommon - Reference: Ventilis DN25 (G1") MF; sets with these values: 2
Name (P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN25 (G1") MF:...) | Group
5228258 | V1 3 (1)
5252904 | V1 3 (1)
5264072 | V1 3 (1)
5264131 | T3 1
5264250 | T3 1
5264292 | V1 3 (1)

# IfcFlowController: P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN32 (G1"1/4) MF (2)
In: 0. Cokolinis Vandentiekis
Type - Material: Tiemme_BRASS-CW617N_Nickel, Tiemme_Stainless-Steel_AISI302
Type - Pset_DuctConnection - ConnectionType: ISO 228(Water)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TIEMME Original Italian Trademark
Type - Pset_PipeConnection - ConnectionType: ISO 228(Water)
Material: Tiemme_Stainless-Steel_AISI302, Tiemme_Aluminium-Painted_BLACK, Tiemme_BRASS-CW617N_Nickel, Tiemme logo; Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: Ventilis DN32 (G1"1/4) MF; sets with these values: 2
Name (P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN32 (G1"1/4) MF:...)
5230831
5231179

# IfcFlowController: P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN50 (G2") MF (6)
In: 0. Cokolinis Vandentiekis
Type - Material: Tiemme_BRASS-CW617N_Nickel, Tiemme_Stainless-Steel_AISI302
Type - Pset_DuctConnection - ConnectionType: ISO 228(Water)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TIEMME Original Italian Trademark
Type - Pset_PipeConnection - ConnectionType: ISO 228(Water)
Material: Tiemme_Stainless-Steel_AISI302, Tiemme_Aluminium-Painted_BLACK, Tiemme_BRASS-CW617N_Nickel, Tiemme logo; Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: Ventilis DN50 (G2") MF; sets with these values: 2
Name (P_VALVE BALL_WATER_2361-2371_MF_MISTRAL_Acc_Tiemme:Ventilis DN50 (G2") MF:...)
5225499
5226527
5230394
5231171
5323584
5367481

# IfcFlowController: Safety_relief_valve-Caleffi-5321-5322_DN15:Techninis manometras, Safety_relief_valve-Caleffi-5321-5322_DN15:Techninis manometras:5104324
In: 0. Cokolinis Vandentiekis
Type - PredefinedType: PRESSURERELIEF; Material: Metal Brass, Glass, Technopolymer Black, Technopolymer Red
Type - Pset_DuctConnection - ConnectionType: Gas ISO 228-1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Caleffi Italy
Type - Pset_PipeConnection - ConnectionType: Gas ISO 228-1
Classification: D3020 Uniformat (Uniformat); Group: V1 8
Pset_DistributionFlowElementCommon - Reference: Techninis manometras; sets with these values: 2

# IfcFlowController: Water_meter-Caleffi-7942_DN15-DN50:1/2" (2)
In: 0. Cokolinis Vandentiekis
Type - Material: Metal Brass, Paint Grey
Type - Pset_ManufacturerTypeInformation - Manufacturer: Caleffi Italy
Classification: D20 Uniformat (Uniformat); Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: 1/2"; sets with these values: 2
Name (Water_meter-Caleffi-7942_DN15-DN50:1/2":...)
5227805
5373236

# IfcFlowController: Water_meter-Caleffi-7942_DN15-DN50:11/2", Water_meter-Caleffi-7942_DN15-DN50:11/2":5226336
In: 0. Cokolinis Vandentiekis
Type - Material: Paint Blue, Metal Brass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Caleffi Italy
Classification: D20 Uniformat (Uniformat); Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: 11/2"; sets with these values: 2

# IfcFlowController: Water_meter-Caleffi-7942_DN15-DN50:3/4" (2)
In: 0. Cokolinis Vandentiekis
Type - Material: Metal Brass, Paint Grey
Type - Pset_ManufacturerTypeInformation - Manufacturer: Caleffi Italy
Classification: D20 Uniformat (Uniformat); Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: 3/4"; sets with these values: 2
Name (Water_meter-Caleffi-7942_DN15-DN50:3/4":...)
5230637
5231174

# IfcFlowController: _Термометр для AHT:_Термометр для AHT, _Термометр для AHT:_Термометр для AHT:5303172
In: 0. Cokolinis Vandentiekis
Type - Material: Danfoss белый, Danfoss Латунь
Type - Pset_ManufacturerTypeInformation - Manufacturer: Danfoss
Pset_DistributionFlowElementCommon - Reference: _Термометр для AHT; sets with these values: 2

# IfcFlowController: Šalto vandens skaitiklis:Dn40, Šalto vandens skaitiklis:Dn40:5104341
In: 0. Cokolinis Vandentiekis
Type - Material: Color RGB 202-162-112
Type - Pset_ManufacturerTypeInformation - Manufacturer: Itron
Material: Color RGB 202-162-112, Color RGB 192-206-224, Color RGB 136-162-193; Group: V1 7; V1 8
Pset_DistributionFlowElementCommon - Reference: Dn40; sets with these values: 2

# IfcFlowFitting: 400_53_Geberit_Mapress_carbon_steel_T-branch_fitting_reduced:Trišakis (11)
In: 0. Cokolinis Vandentiekis
Type - Material: Rubber, Black, Aluminum, Anodized Red, 53_steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Trišakis; sets with these values: 2
Name (400_53_Geberit_Mapress_carbon_steel_T-branch_fitting_reduced:Trišakis:...) | Group
5131453 | V1 3 (1)
5174214 | V12 1
5187935 | V12 1
5220708 | V1 3 (1)
5226956 | V1 3 (1)
5228467 | V1 3 (1)
5230192 | V1 3 (1)
5230893 | V1 3 (1)
5231186 | V1 3 (1)
5231212 | V1 3 (1)
5233330 | V12 1

# IfcFlowFitting: Coupling - DI:Flanšinis adapteris, Coupling - DI:Flanšinis adapteris:5346321
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Pset_DistributionFlowElementCommon - Reference: Flanšinis adapteris; sets with these values: 2
Pset_PipeFittingTypeCommon - NominalDiameter: 100
Group: V1 14

# IfcFlowFitting: Elbow - Flanged - CS - PN 25:Standard (2)
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_PipeConnectionFlanged - FlangeThickness: 22 mm
Pset_PipeFittingTypeCommon - NominalDiameter: 65
Group: V1 1
Name (Elbow - Flanged - CS - PN 25:Standard:...)
5151690
5153674

# IfcFlowFitting: Geberit Mapress SS Cap:DN (2)
In: 0. Cokolinis Vandentiekis
Type - PredefinedType: USERDEFINED; Material: Rubber, Black, Steel, Paint Finish, Blue, 53_steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: DN; sets with these values: 2
Group: V1 3 (1)
Name (Geberit Mapress SS Cap:DN:...)
5131807
5330109

# IfcFlowFitting: Geberit Mapress SS Coupling:DN, Geberit Mapress SS Coupling:DN:5372649
In: 0. Cokolinis Vandentiekis
Type - Material: Rubber, Black, Steel, Paint Finish, Blue, 53_steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: DN; sets with these values: 2
Group: V1 3 (1)

# IfcFlowFitting: Geberit Mapress SS Reducer with plain end:Perėjimas (16)
In: 0. Cokolinis Vandentiekis
Type - Material: Rubber, Black, Steel, Paint Finish, Blue, 53_steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Perėjimas; sets with these values: 2
Name (Geberit Mapress SS Reducer with plain end:Perėjimas:...) | Group
5104333 | V1 8
5104346 | V1 8
5104348 | V1 8
5225984 | V1 3 (1)
5226598 | V1 3 (1)
5226612 | V1 3 (1)
5230873 | V1 3 (1)
5231182 | V1 3 (1)
5233156 | V1 3 (1)
5329844 | T3 3; T4 5
5366917 | V1 3 (1)
5366990 | V1 3 (1)
5367370 | V1 3 (1)
5367566 | V1 3 (1)
5372004 | V1 3 (1)
5374046 | V1 3 (1)

# IfcFlowFitting: Geberit_PipeFitting_Mapress_StSt_Bend:Alkūnė 90° (40)
In: 0. Cokolinis Vandentiekis
Type - Description: Mapress St-Steel Bend; PredefinedType: BEND; Material: Geberit_Paint Finish,Blue, Geberit_Mapress_St-Steel
Type - Pset_ElementShading - Color: St Steel
Type - Pset_FlowFittingDuctFitting - Color: St Steel
Type - Pset_FlowFittingPipeFitting - Color: St Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit; ProductionYear: 2018
Classification: D2090800 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Alkūnė 90°; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.
Pset_ManufacturerTypeInformation - ModelReference: Bend
Name (Geberit_PipeFitting_Mapress_StSt_Bend:Alkūnė 90°:...) | ArticleNumber | Group
5066483 | 31108 | V1 3 (1)
5066758 | 31106 | V1 3 (1)
5066886 | 31106 | T3 1
5066894 | 31106 | T3 1
5131794 | 31106 | V1 3 (1)
5173465 | 30104 | T4 5
5173502 | 30104 | T4 5
5173659 | 30104 | T4 5
5173863 | 30104 | T4 5
5174047 | 31106 | V1 3 (1)
5174178 | 30105 | V12 1
5174188 | 30105 | V12 1
5174253 | 30105 | V12 1
5174263 | 30105 | V12 1
5186839 | 30105 | V12 1
5186852 | 30105 | V12 1
5186921 | 30105 | V12 1
5186973 | 30105 | V12 1
5187071 | 30105 | V12 1
5187249 | 31108 | V1 3 (1)
5187324 | 30105 | V12 1
5187939 | 30105 | V12 1
5188107 | 30105 | V12 1
5188115 | 30105 | V12 1
5225980 | 31109 | V1 3 (1)
5231377 | 31108 | V1 3 (1)
5231949 | 31106 | V1 3 (1)
5232042 | 31106 | V1 3 (1)
5232044 | 31106 | V1 3 (1)
5232738 | 31106 | V1 3 (1)
5233020 | 31106 | V1 3 (1)
5233028 | 31106 | V1 3 (1)
5233194 | 30105 | V1 3 (1)
5233230 | 30105 | V1 3 (1)
5233307 | 30105 | V12 1
5233334 | 30105 | V1 3 (1)
5234358 | 31106 | V1 3 (1)
5234360 | 31106 | V1 3 (1)
5371541 | 31108 | V1 3 (1)
5371658 | 31106 | V1 3 (1)

# IfcFlowFitting: Jungtis:Standard, Jungtis:Standard:5220316
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_PipeFittingTypeCommon - NominalDiameter: 65
Group: V1 3 (1); V1 4

# IfcFlowFitting: Keturšakis 1:Standard, Keturšakis 1:Standard:5104329
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_PipeFittingTypeCommon - NominalDiameter: 40
Group: V1 8

# IfcFlowFitting: PIF_Tigris_Elbow_M-K_Wavin:Standard (158)
Type - Description: Elbow; PredefinedType: BEND; Material: Steel WVN-T, Brass WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (PIF_Tigris_Elbow_M-K_Wavin:Standard:...) | In | Group
5067468 | 0. Cokolinis Vandentiekis | V1 3 (1)
5067544 | 0. Cokolinis Vandentiekis | V1 3 (1)
5067572 | 0. Cokolinis Vandentiekis | V1 3 (1)
5067580 | 0. Cokolinis Vandentiekis | V1 3 (1)
5067977 | 0. Cokolinis Vandentiekis | T3 6
5068079 | 0. Cokolinis Vandentiekis | T3 6
5068091 | 0. Cokolinis Vandentiekis | T3 6
5068149 | 0. Cokolinis Vandentiekis | T3 6
5068352 | 0. Cokolinis Vandentiekis | V1 3 (1)
5068356 | 0. Cokolinis Vandentiekis | V1 3 (1)
5068391 | 0. Cokolinis Vandentiekis | T3 3
5068395 | 0. Cokolinis Vandentiekis | T3 3
5068399 | 0. Cokolinis Vandentiekis | T3 3
5068454 | 0. Cokolinis Vandentiekis | T3 3
5069729 | 0. Cokolinis Vandentiekis | V1 3 (1)
5069974 | 0. Cokolinis Vandentiekis | V1 3 (1)
5069976 | 0. Cokolinis Vandentiekis | V1 3 (1)
5071730 | 0. Cokolinis Vandentiekis | V1 3 (1)
5071734 | 0. Cokolinis Vandentiekis | V1 3 (1)
5071953 | 0. Cokolinis Vandentiekis | V1 3 (1)
5072031 | 0. Cokolinis Vandentiekis | V1 3 (1)
5072035 | 0. Cokolinis Vandentiekis | V1 3 (1)
5075437 | 0. Cokolinis Vandentiekis | T3 1
5076997 | 0. Cokolinis Vandentiekis | T3 1
5077025 | 0. Cokolinis Vandentiekis | V1 3 (1)
5085639 | 1. Pirmas | V1 3 (1)
5085647 | 1. Pirmas | V1 3 (1)
5085706 | 1. Pirmas | T3 1
5085714 | 1. Pirmas | T3 1
5085815 | 1. Pirmas | V1 3 (1)
5086016 | 1. Pirmas | T3 1
5086394 | 1. Pirmas | T3 1
5086550 | 1. Pirmas | V1 3 (1)
5087034 | 0. Cokolinis Vandentiekis | V1 3 (1)
5087053 | 0. Cokolinis Vandentiekis | T3 1
5087264 | 0. Cokolinis Vandentiekis | T3 1
5087457 | 0. Cokolinis Vandentiekis | V1 3 (1)
5088143 | 0. Cokolinis Vandentiekis | T3 1
5088420 | 1. Pirmas | V1 3 (1)
5088727 | 1. Pirmas | V1 3 (1)
5088769 | 1. Pirmas | T3 1
5088773 | 1. Pirmas | T3 1
5088897 | 0. Cokolinis Vandentiekis | V1 3 (1)
5088959 | 0. Cokolinis Vandentiekis | T3 1
5089570 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089596 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089622 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089664 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089694 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089725 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089801 | 0. Cokolinis Vandentiekis | T3 1
5089836 | 0. Cokolinis Vandentiekis | T3 1
5089865 | 0. Cokolinis Vandentiekis | T3 1
5089917 | 0. Cokolinis Vandentiekis | T3 1
5089955 | 0. Cokolinis Vandentiekis | T3 1
5089993 | 0. Cokolinis Vandentiekis | T3 1
5090469 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090471 | 0. Cokolinis Vandentiekis | T3 1
5090483 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090495 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090507 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090525 | 0. Cokolinis Vandentiekis | T3 1
5090537 | 0. Cokolinis Vandentiekis | T3 1
5090549 | 0. Cokolinis Vandentiekis | T3 1
5090610 | 0. Cokolinis Vandentiekis | T3 1
5090639 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090667 | 0. Cokolinis Vandentiekis | T3 1
5090697 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090727 | 0. Cokolinis Vandentiekis | T3 1
5090757 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090788 | 0. Cokolinis Vandentiekis | T3 1
5090819 | 0. Cokolinis Vandentiekis | V1 3 (1)
5091063 | 0. Cokolinis Vandentiekis | V1 3 (1)
5091117 | 0. Cokolinis Vandentiekis | T3 1
5091568 | 1. Pirmas | V1 3 (1)
5091708 | 0. Cokolinis Vandentiekis | T3 1
5091812 | 0. Cokolinis Vandentiekis | V1 3 (1)
5092090 | 0. Cokolinis Vandentiekis | T3 1
5092092 | 0. Cokolinis Vandentiekis | T3 1
5092444 | 0. Cokolinis Vandentiekis | T3 1
5092633 | 0. Cokolinis Vandentiekis | V1 3 (1)
5092891 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093063 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093215 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093242 | 1. Pirmas | V1 3 (1)
5093267 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093397 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093475 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093602 | 0. Cokolinis Vandentiekis | V1 3 (1)
5093658 | 0. Cokolinis Vandentiekis | T3 1
5098439 | 0. Cokolinis Vandentiekis | V1 3 (1)
5098571 | 0. Cokolinis Vandentiekis | V1 3 (1)
5098581 | 0. Cokolinis Vandentiekis | V1 3 (1)
5098610 | 0. Cokolinis Vandentiekis | V1 3 (1)
5099433 | 0. Cokolinis Vandentiekis | V1 3 (1)
5099439 | 0. Cokolinis Vandentiekis | V1 3 (1)
5099463 | 0. Cokolinis Vandentiekis | T3 2
5099485 | 0. Cokolinis Vandentiekis | T3 2
5099775 | 0. Cokolinis Vandentiekis | T3 2
5100035 | 0. Cokolinis Vandentiekis | T3 2
5100497 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100515 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100988 | 0. Cokolinis Vandentiekis | V1 3 (1)
5101148 | 0. Cokolinis Vandentiekis | V1 3 (1)
5101546 | 0. Cokolinis Vandentiekis | V1 3 (1)
5101986 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102487 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102491 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102548 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102566 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102633 | 0. Cokolinis Vandentiekis | T3 2
5102815 | 0. Cokolinis Vandentiekis | T3 2
5103008 | 0. Cokolinis Vandentiekis | V1 3 (1)
5103115 | 0. Cokolinis Vandentiekis | V1 3 (1)
5103117 | 0. Cokolinis Vandentiekis | V1 3 (1)
5103412 | 0. Cokolinis Vandentiekis | T3 2
5103525 | 0. Cokolinis Vandentiekis | T3 2
5103658 | 0. Cokolinis Vandentiekis | V1 3 (1)
5250193 | 0. Cokolinis Vandentiekis | V1 3 (1)
5250262 | 0. Cokolinis Vandentiekis | V1 3 (1)
5250386 | 0. Cokolinis Vandentiekis | T3 2
5250963 | 0. Cokolinis Vandentiekis | T3 2
5250965 | 0. Cokolinis Vandentiekis | T3 2
5326749 | 1. Pirmas | T3 7
5327204 | 1. Pirmas | V1 3 (1)
5327278 | 1. Pirmas | V1 3 (1)
5327373 | 1. Pirmas | V1 3 (1)
5327507 | 1. Pirmas | V1 3 (1)
5327540 | 1. Pirmas | T3 7
5327601 | 1. Pirmas | T3 7
5327659 | 1. Pirmas | T3 5
5327663 | 1. Pirmas | T3 7; T3 5
5327765 | 1. Pirmas | V1 3 (1)
5328223 | 1. Pirmas | V1 3 (1)
5329409 | 0. Cokolinis Vandentiekis | V1 3 (1)
5329905 | 0. Cokolinis Vandentiekis | V1 3 (1)
5329960 | 0. Cokolinis Vandentiekis | T3 6
5331256 | 0. Cokolinis Vandentiekis | T3 1
5331291 | 0. Cokolinis Vandentiekis | V1 3 (3)
5345456 | 0. Cokolinis Vandentiekis | V1 3 (1)
5346124 | 0. Cokolinis Vandentiekis | V1 3 (1)
5348507 | 0. Cokolinis Vandentiekis | V1 3 (1)
5348517 | 0. Cokolinis Vandentiekis | T3 1
5348731 | 0. Cokolinis Vandentiekis | V1 3 (1)
5348868 | 1. Pirmas | V1 3 (1)
5348926 | 0. Cokolinis Vandentiekis | V1 3 (1)
5348930 | 1. Pirmas | V1 3 (1)
5349053 | 0. Cokolinis Vandentiekis | T3 1
5349111 | 0. Cokolinis Vandentiekis | T3 1
5349165 | 0. Cokolinis Vandentiekis | T3 1
5374048 | 0. Cokolinis Vandentiekis | V1 3 (1)
5386155 | 0. Cokolinis Vandentiekis | T3 1
5386200 | 0. Cokolinis Vandentiekis | T3 1
5386544 | 0. Cokolinis Vandentiekis | T3 1
5386606 | 0. Cokolinis Vandentiekis | T3 2
5386772 | 0. Cokolinis Vandentiekis | T3 2
5386824 | 0. Cokolinis Vandentiekis | T3 2
5386967 | 0. Cokolinis Vandentiekis | T3 2

# IfcFlowFitting: PIF_Tigris_MultiReducer_Wavin:Standard Multireducer (6)
In: 0. Cokolinis Vandentiekis
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: <Unnamed>, T3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat); Material: T3
Pset_DistributionFlowElementCommon - Reference: Standard Multireducer; sets with these values: 2
Name (PIF_Tigris_MultiReducer_Wavin:Standard Multireducer:...) | Group
5087251 | T3 1
5090890 | T3 1
5090969 | V1 3 (1)
5092620 | V1 3 (1)
5099465 | T3 2
5335841 | T3 2

# IfcFlowFitting: PIF_Tigris_MultiReducer_Wavin:Standard Multireducer (3)
In: 0. Cokolinis Vandentiekis
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: <Unnamed>, V1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat); Material: V1; Group: V1 3 (1)
Pset_DistributionFlowElementCommon - Reference: Standard Multireducer; sets with these values: 2
Name (PIF_Tigris_MultiReducer_Wavin:Standard Multireducer:...)
5087197
5099435
5335876

# IfcFlowFitting: PIF_Tigris_Super_Tee_Wavin:Standard SuperTee (46)
Type - Description: Branch; PredefinedType: JUNCTION; Material: <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, T3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat); Material: T3, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T
Pset_DistributionFlowElementCommon - Reference: Standard SuperTee; sets with these values: 2
Name (PIF_Tigris_Super_Tee_Wavin:Standard SuperTee:...) | In | Group
5068458 | 0. Cokolinis Vandentiekis | T3 3; T3 4
5069919 | 0. Cokolinis Vandentiekis | V1 3 (1)
5072190 | 0. Cokolinis Vandentiekis | T3 1
5075334 | 0. Cokolinis Vandentiekis | V1 3 (1)
5076911 | 0. Cokolinis Vandentiekis | T3 1
5076993 | 0. Cokolinis Vandentiekis | T3 1
5077021 | 0. Cokolinis Vandentiekis | V1 3 (1)
5080763 | 0. Cokolinis Vandentiekis | V1 3 (1)
5080939 | 0. Cokolinis Vandentiekis | T3 1
5084980 | 0. Cokolinis Vandentiekis | T3 1
5088139 | 0. Cokolinis Vandentiekis | T3 1
5088398 | 1. Pirmas | V1 3 (1)
5089668 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089698 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089729 | 0. Cokolinis Vandentiekis | V1 3 (1)
5089923 | 0. Cokolinis Vandentiekis | T3 1
5089961 | 0. Cokolinis Vandentiekis | T3 1
5089999 | 0. Cokolinis Vandentiekis | T3 1
5090616 | 0. Cokolinis Vandentiekis | T3 1
5090645 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090673 | 0. Cokolinis Vandentiekis | T3 1
5090703 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090733 | 0. Cokolinis Vandentiekis | T3 1
5090763 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090794 | 0. Cokolinis Vandentiekis | T3 1
5090825 | 0. Cokolinis Vandentiekis | V1 3 (1)
5090872 | 1. Pirmas | T3 1
5092317 | 0. Cokolinis Vandentiekis | T3 1
5092879 | 0. Cokolinis Vandentiekis | V1 3 (1)
5092968 | 0. Cokolinis Vandentiekis | V1 3 (1)
5092988 | 0. Cokolinis Vandentiekis | V1 3 (1)
5096118 | 0. Cokolinis Vandentiekis | V1 3 (1)
5097661 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100209 | 0. Cokolinis Vandentiekis | T3 2
5100762 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100796 | 0. Cokolinis Vandentiekis | V1 3 (1)
5101825 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102105 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102197 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102819 | 0. Cokolinis Vandentiekis | T3 2
5103527 | 0. Cokolinis Vandentiekis | T3 2
5103662 | 0. Cokolinis Vandentiekis | V1 3 (1)
5327632 | 1. Pirmas | T3 3
5374038 | 0. Cokolinis Vandentiekis | V1 3 (1)
5386776 | 0. Cokolinis Vandentiekis | T3 2
5386973 | 0. Cokolinis Vandentiekis | T3 2

# IfcFlowFitting: PIF_Tigris_Super_Tee_Wavin:Standard SuperTee (29)
Type - Description: Branch; PredefinedType: JUNCTION; Material: <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, V1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat); Material: V1, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T
Pset_DistributionFlowElementCommon - Reference: Standard SuperTee; sets with these values: 2
Name (PIF_Tigris_Super_Tee_Wavin:Standard SuperTee:...) | In | Group
5069990 | 0. Cokolinis Vandentiekis | V1 3 (1)
5080794 | 0. Cokolinis Vandentiekis | V1 3 (1)
5085037 | 0. Cokolinis Vandentiekis | V1 3 (1)
5085805 | 1. Pirmas | V1 3 (1)
5086012 | 1. Pirmas | T3 1
5086398 | 1. Pirmas | T3 1
5086554 | 1. Pirmas | V1 3 (1)
5091583 | 1. Pirmas | V1 3 (1)
5092427 | 0. Cokolinis Vandentiekis | V1 3 (1)
5092702 | 0. Cokolinis Vandentiekis | V1 3 (1)
5094495 | 0. Cokolinis Vandentiekis | T3 1
5098616 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100031 | 0. Cokolinis Vandentiekis | T3 2
5100484 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100614 | 0. Cokolinis Vandentiekis | V1 3 (1)
5100813 | 0. Cokolinis Vandentiekis | V1 3 (1)
5103109 | 0. Cokolinis Vandentiekis | V1 3 (1)
5249330 | 0. Cokolinis Vandentiekis | T3 2
5249392 | 0. Cokolinis Vandentiekis | V1 3 (1)
5326779 | 1. Pirmas | T3 7
5327339 | 1. Pirmas | V1 3 (1)
5328227 | 1. Pirmas | V1 3 (1)
5329907 | 0. Cokolinis Vandentiekis | V1 3 (1)
5329962 | 0. Cokolinis Vandentiekis | T3 3; T3 6
5345412 | 0. Cokolinis Vandentiekis | V1 3 (1)
5348735 | 0. Cokolinis Vandentiekis | V1 3 (1)
5349113 | 0. Cokolinis Vandentiekis | T3 1
5386202 | 0. Cokolinis Vandentiekis | T3 1
5386550 | 0. Cokolinis Vandentiekis | T3 1

# IfcFlowFitting: Prietaisinė alkūnė:16-RP1/2" (45)
Type - PredefinedType: EXIT; Material: Metalas
Type - Pset_ManufacturerTypeInformation - Manufacturer: Uponor
Pset_DistributionFlowElementCommon - Reference: 16-RP1/2"; sets with these values: 2
Name (Prietaisinė alkūnė:16-RP1/2":...) | In | Group
5080972 | 1. Pirmas | T3 1
5083890 | 1. Pirmas | V1 3 (1)
5084021 | 1. Pirmas | T3 1
5084025 | 1. Pirmas | V1 3 (1)
5084686 | 1. Pirmas | T3 1
5084690 | 1. Pirmas | V1 3 (1)
5084743 | 1. Pirmas | T3 1
5084747 | 1. Pirmas | V1 3 (1)
5085090 | 1. Pirmas | T3 1
5085094 | 1. Pirmas | V1 3 (1)
5088788 | 1. Pirmas | T3 1
5088792 | 1. Pirmas | V1 3 (1)
5089566 | 1. Pirmas | V1 3 (1)
5089592 | 1. Pirmas | V1 3 (1)
5089618 | 1. Pirmas | V1 3 (1)
5089797 | 1. Pirmas | T3 1
5089832 | 1. Pirmas | T3 1
5089861 | 1. Pirmas | T3 1
5090461 | 1. Pirmas | T3 1
5090465 | 1. Pirmas | V1 3 (1)
5090479 | 1. Pirmas | V1 3 (1)
5090491 | 1. Pirmas | V1 3 (1)
5090503 | 1. Pirmas | V1 3 (1)
5090521 | 1. Pirmas | T3 1
5090533 | 1. Pirmas | T3 1
5090545 | 1. Pirmas | T3 1
5091059 | 1. Pirmas | V1 3 (1)
5091113 | 1. Pirmas | T3 1
5098093 | -1 Baseino dugnas | V1 3 (1)
5098097 | -1 Baseino dugnas | T3 2
5098477 | -1 Baseino dugnas | V1 3 (1)
5098481 | -1 Baseino dugnas | T3 2
5098625 | -1 Baseino dugnas | V1 3 (1)
5098629 | -1 Baseino dugnas | T3 2
5102006 | 0. Cokolinis Vandentiekis | V1 3 (1)
5102010 | 0. Cokolinis Vandentiekis | T3 2
5102119 | 1. Pirmas | V1 3 (1)
5102123 | 1. Pirmas | T3 2
5325250 | 1. Pirmas | V1 3 (1)
5325254 | 1. Pirmas | T3 7
5325361 | 1. Pirmas | V1 3 (1)
5325365 | 1. Pirmas | T3 7
5345939 | 0. Cokolinis Vandentiekis | V1 3 (1); T3 8
5348503 | 1. Pirmas | V1 3 (1)
5348513 | 1. Pirmas | T3 1

# IfcFlowFitting: Reducer - Flanged - CS - PN 25:Perėjimas (2)
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Pset_DistributionFlowElementCommon - Reference: Perėjimas; sets with these values: 2
Name (Reducer - Flanged - CS - PN 25:Perėjimas:...) | Group
5104344 | V1 7
5104360 | V1 8

# IfcFlowFitting: Uponor_Žiedas_QE_Baltas:Uponor_Žiedas_QE_Baltas (45)
Type - Material: Plastikas
Type - Pset_ManufacturerTypeInformation - Manufacturer: Uponor
Pset_DistributionFlowElementCommon - Reference: Uponor_Žiedas_QE_Baltas; sets with these values: 2
Name (Uponor_Žiedas_QE_Baltas:Uponor_Žiedas_QE_Baltas:...) | In
5080973 | 1. Pirmas
5083891 | 1. Pirmas
5084022 | 1. Pirmas
5084026 | 1. Pirmas
5084687 | 1. Pirmas
5084691 | 1. Pirmas
5084744 | 1. Pirmas
5084748 | 1. Pirmas
5085091 | 1. Pirmas
5085095 | 1. Pirmas
5088789 | 1. Pirmas
5088793 | 1. Pirmas
5089567 | 1. Pirmas
5089593 | 1. Pirmas
5089619 | 1. Pirmas
5089798 | 1. Pirmas
5089833 | 1. Pirmas
5089862 | 1. Pirmas
5090462 | 1. Pirmas
5090466 | 1. Pirmas
5090480 | 1. Pirmas
5090492 | 1. Pirmas
5090504 | 1. Pirmas
5090522 | 1. Pirmas
5090534 | 1. Pirmas
5090546 | 1. Pirmas
5091060 | 1. Pirmas
5091114 | 1. Pirmas
5098094 | 0. Cokolinis Vandentiekis
5098098 | 0. Cokolinis Vandentiekis
5098478 | 0. Cokolinis Vandentiekis
5098482 | 0. Cokolinis Vandentiekis
5098626 | 0. Cokolinis Vandentiekis
5098630 | 0. Cokolinis Vandentiekis
5102007 | 1. Pirmas
5102011 | 1. Pirmas
5102120 | 1. Pirmas
5102124 | 1. Pirmas
5325251 | 1. Pirmas
5325255 | 1. Pirmas
5325362 | 1. Pirmas
5325366 | 1. Pirmas
5345940 | 0. Cokolinis Vandentiekis
5348504 | 1. Pirmas
5348514 | 1. Pirmas

# IfcFlowFitting: Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):1 - M5 (9)
In: 0. Cokolinis Vandentiekis
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: Steel WVN-T, Brass WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 1 - M5; sets with these values: 2
Name (Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):1 - M5:...)
5087208
5087253
5090947
5090971
5092622
5099437
5099467
5335866
5335902

# IfcFlowSegment: Pipe Types:Kalaus ketaus intarpas (5)
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Pset_DistributionFlowElementCommon - Reference: Kalaus ketaus intarpas; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:Kalaus ketaus intarpas:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
5104322 | 7.38203 | -1128.51 | V1 7
5104342 | 111.188 | -1115.81 | V1 7
5143144 | 106.599 | -1128.52 | V1 1
5153184 | 297.61 | -1523 | V1 1
5219656 | 94.2884 | -1128.51 | V1 4

# IfcFlowSegment: Pipe Types:Nerūdijančio plieno vamzdis (114)
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Pset_DistributionFlowElementCommon - Reference: Nerūdijančio plieno vamzdis; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:Nerūdijančio plieno vamzdis:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
5066467 | 10674.2 | 1075.33 | V1 3 (1)
5066477 | 20270 | 1075.33 | V1 3 (1)
5066734 | 5154.6 | 1374 | V1 3 (1)
5066801 | 723.577 | 1428.97 | T3 3
5066871 | 4591.1 | 1428.97 | T3 1
5068459 | 3233.43 | 1428.97 | T3 1; T3 4
5069920 | 2856.35 | 1374 | V1 3 (1)
5072191 | 607.134 | 1428.97 | T3 1
5076950 | 747.569 | 1374 | V1 3 (1)
5092269 | 3313.96 | 1428.97 | T3 1
5092339 | 3289.61 | 1374 | V1 3 (1)
5094228 | 2012.91 | 1428.97 | T3 1
5094496 | 5136.77 | 1428.97 | T3 1
5096097 | 2005.5 | 1374 | V1 3 (1)
5100472 | 1888.01 | 1374 | V1 3 (1)
5100485 | 3247.38 | 1374 | V1 3 (1)
5104331 | 44.2419 | -980.392 | V1 8
5104337 | 62.1081 | -1278.5 | V1 8
5104350 | 23.1261 | -1117.89 | V1 8
5104352 | 100.507 | -1134.44 | V1 4
5104354 | 9.1649 | -1134.44 | V1 8
5104356 | 58.8351 | -1117.89 | V1 8
5131468 | 2709.34 | 1084.83 | V1 3 (1)
5131489 | 158 | 1084.83 | V1 3 (1)
5131533 | 3013.52 | 1084.83 | V1 3 (1)
5131786 | 2207.33 | -1148.5 | V1 3 (1)
5172499 | 829.931 | 1459 | V1 3 (1)
5173026 | 5700.24 | 1493.08 | V12 1
5173104 | 10625.5 | 1493.08 | V12 1
5173201 | 907.582 | 549 | V12 1
5173219 | 66.0411 | 487.5 | V12 1
5173329 | 493.169 | 1435.47 | T4 6
5173457 | 4615 | 1435.47 | T4 5
5173494 | 14754.2 | 1435.47 | T4 5
5173586 | 273.717 | 1428.97 | T3 3
5173651 | 6.46428 | 1435.47 | T4 5
5173731 | 3.559 | 1435.47 | T4 5
5174029 | 1811.97 | 1459 | V1 3 (1)
5174039 | 578 | 1459 | V1 3 (1)
5174162 | 24347.1 | 1493.08 | V12 1
5174180 | 562.857 | 1493.08 | V12 1
5174237 | 3394.47 | 1493.08 | V12 1
5174247 | 25568.6 | 1493.08 | V12 1
5174255 | 4602 | 1493.08 | V12 1
5174265 | 907.582 | 549 | V12 1
5186844 | 672.859 | 487.5 | V12 1
5186963 | 673.374 | 487.5 | V12 1
5187063 | 1124.25 | 332.329 | V12 1
5187241 | 306.968 | -1665 | V1 3 (1)
5187316 | 586 | 270.829 | V12 1
5187538 | 166.531 | 1493.08 | V12 1
5187586 | 27.4694 | 1493.08 | V12 1
5187933 | 57.4828 | 1420.1 | V12 1
5187936 | 8769.82 | 1493.08 | V12 1
5188093 | 8687 | 1358.6 | V12 1
5188099 | 773.099 | 549 | V12 1
5188109 | 567.75 | 487.5 | V12 1
5220303 | 74.4096 | -1134.32 | V1 3 (1)
5220606 | 736.655 | -379.823 | V1 3 (1)
5220749 | 71.3529 | -1134.22 | V1 3 (1)
5225735 | 111.883 | 435.331 | V1 3 (1)
5225940 | 41.0608 | 435.331 | V1 3 (1)
5226338 | 144.633 | 441.331 | V1 3 (1)
5226529 | 96.7195 | 441.331 | V1 3 (1)
5226933 | 40 | 251.576 | V1 3 (1)
5226957 | 277.769 | 441.331 | V1 3 (1)
5227068 | 65 | 361.576 | V1 3 (1)
5227367 | 40.9879 | -1123.7 | V1 3 (1)
5227807 | 142.119 | -1106.02 | V1 3 (1)
5228260 | 74.9531 | -1106.03 | V1 3 (1)
5228447 | 12.5386 | -1223.15 | V1 3 (1)
5228468 | 75.5974 | -1106.03 | V1 3 (1)
5228641 | 50.835 | -1167.06 | V1 3 (1)
5229964 | 78.1425 | 435.331 | V1 3 (1)
5230182 | 51.6006 | -457.806 | V1 3 (1)
5230193 | 204.196 | -708.035 | V1 3 (1)
5230639 | 113.516 | -451.297 | V1 3 (1)
5230833 | 64.6541 | -451.304 | V1 3 (1)
5230876 | 61.6353 | -525.438 | V1 3 (1)
5230894 | 86.1625 | -451.302 | V1 3 (1)
5231169 | 151.601 | -785.975 | V1 3 (1)
5231172 | 144.632 | -795.497 | V1 3 (1)
5231175 | 103.516 | -779.433 | V1 3 (1)
5231180 | 64.6541 | -779.473 | V1 3 (1)
5231184 | 8.46608 | -800.439 | V1 3 (1)
5231187 | 86.1618 | -779.471 | V1 3 (1)
5231213 | 190.182 | -1022.22 | V1 3 (1)
