Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcFlowSegment: Pipe Types:Nerūdijančio plieno vamzdis (114)
Name (Pipe Types:Nerūdijančio plieno vamzdis:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
5231369 | 510 | 525.831 | V1 3 (1)
5231643 | 86.0187 | -1110.73 | V1 3 (1)
5231924 | 153.879 | -457.806 | V1 3 (1)
5231936 | 1832.74 | -399.741 | V1 3 (1)
5232789 | 2075.97 | -727.975 | V1 3 (1)
5233018 | 154.022 | -785.975 | V1 3 (1)
5233066 | 2505.79 | -1049.21 | V1 3 (1)
5233181 | 74.9477 | -1110.73 | V1 3 (1)
5233218 | 137.469 | 1493.08 | V12 1
5233221 | 3643.34 | 1493.08 | V12 1
5249018 | 72.5 | 1493.08 | V12 1
5303500 | 4626.12 | 1435.47 | T4 5
5323586 | 2294.82 | -1258.99 | V1 3 (1)
5327633 | 4358.42 | 1428.97 | T3 3; T3 1
5328197 | 682.889 | 1374 | V1 3 (1)
5328228 | 2544.62 | 1374 | V1 3 (1)
5330050 | 186 | 1374 | V1 3 (1)
5361451 | 191.871 | 1493.08 | V1 3 (1)
5367089 | 149.843 | -467.357 | V1 3 (1)
5367483 | 62.9625 | -1123.68 | V1 3 (1)
5371588 | 4032.97 | 1075.33 | V1 3 (1)
5372647 | 709.223 | 1075.33 | V1 3 (1)
5373237 | 89.0833 | -229.694 | V1 3 (1)
5373239 | 22.7645 | -229.694 | V1 3 (1)
5373480 | 96.9006 | -229.694 | V1 3 (1)
5373498 | 17.2812 | -229.694 | V1 3 (1)
5374039 | 2184.93 | 1374 | V1 3 (1)

# IfcFlowSegment: Pipe Types:PE100 vamzdis (2)
In: 0. Cokolinis Vandentiekis
Type - Material: V1
Pset_DistributionFlowElementCommon - Reference: PE100 vamzdis; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentPipeSegment - InvertElevation: -1701.13 mm
Group: V1 14
Name (Pipe Types:PE100 vamzdis:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm)
5104238 | 611
5346318 | 911

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (316)
Type - Material: V1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Wavin Tigris Single Pipe (OD) - Standard; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
5067333 | 0. Cokolinis Vandentiekis | 202.576 | 1384 | V1 3 (1)
5067445 | 0. Cokolinis Vandentiekis | 459 | 1408 | V1 3 (1)
5067536 | 0. Cokolinis Vandentiekis | 19 | 1879 | V1 3 (1)
5067548 | 0. Cokolinis Vandentiekis | 609.003 | 1903 | V1 3 (1)
5067574 | 0. Cokolinis Vandentiekis | 42 | 2524 | V1 3 (1)
5067852 | 0. Cokolinis Vandentiekis | 285.643 | 1438.97 | T3 6
5068018 | 0. Cokolinis Vandentiekis | 404.023 | 1462.97 | T3 6
5068069 | 0. Cokolinis Vandentiekis | 19 | 1879 | T3 6
5068083 | 0. Cokolinis Vandentiekis | 609.003 | 1903 | T3 6
5068137 | 0. Cokolinis Vandentiekis | 42 | 2524 | T3 6
5068342 | 0. Cokolinis Vandentiekis | 459 | 1408 | V1 3 (1)
5068346 | 0. Cokolinis Vandentiekis | 58.8526 | 1879 | V1 3 (1)
5068350 | 0. Cokolinis Vandentiekis | 1209 | 1903 | V1 3 (1)
5068354 | 0. Cokolinis Vandentiekis | 485.629 | 3124 | V1 3 (1)
5068383 | 0. Cokolinis Vandentiekis | 42.0345 | 1438.97 | T3 3
5068387 | 0. Cokolinis Vandentiekis | 404.023 | 1462.97 | T3 3
5068389 | 0. Cokolinis Vandentiekis | 35.239 | 1879 | T3 3
5068393 | 0. Cokolinis Vandentiekis | 609.003 | 1903 | T3 3
5069721 | 0. Cokolinis Vandentiekis | 37 | 3075 | V1 3 (1)
5069966 | 0. Cokolinis Vandentiekis | 171.103 | 1384 | V1 3 (1)
5070014 | 0. Cokolinis Vandentiekis | 151 | 1384 | V1 3 (1)
5070043 | 0. Cokolinis Vandentiekis | 459 | 1408 | V1 3 (1)
5070233 | 0. Cokolinis Vandentiekis | 43.1469 | 2524 | V1 3 (1)
5070678 | 0. Cokolinis Vandentiekis | 45.6401 | 1384 | V1 3 (1)
5071583 | 0. Cokolinis Vandentiekis | 89.8643 | 2524 | T3 3
5071911 | 0. Cokolinis Vandentiekis | 609 | 1903 | V1 3 (1)
5071943 | 0. Cokolinis Vandentiekis | 35.239 | 1879 | V1 3 (1)
5075324 | 0. Cokolinis Vandentiekis | 83 | 1382.3 | V1 3 (1)
5075415 | 0. Cokolinis Vandentiekis | 270.519 | 1464.97 | T3 1
5075455 | 0. Cokolinis Vandentiekis | 325.496 | 1410 | V1 3 (1)
5076705 | 0. Cokolinis Vandentiekis | 1139.99 | 1747.79 | T3 1
5076777 | 1. Pirmas | 1110 | 1747.79 | V1 3 (1)
5076787 | 1. Pirmas | 669 | 1749.49 | V1 3 (1)
5076970 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5076991 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5076994 | 0. Cokolinis Vandentiekis | 678.905 | 1434.97 | T3 1
5077012 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5077019 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5077022 | 0. Cokolinis Vandentiekis | 756.752 | 1380 | V1 3 (1)
5077091 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5077128 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5080768 | 0. Cokolinis Vandentiekis | 747.58 | 1380 | V1 3 (1)
5080823 | 0. Cokolinis Vandentiekis | 607.14 | 1434.97 | T3 1
5080908 | 0. Cokolinis Vandentiekis | 81.7192 | 1437.27 | T3 1
5083924 | 1. Pirmas | 760.508 | 1773.49 | V1 3 (1)
5083974 | 1. Pirmas | 760.508 | 1773.49 | T3 1
5085019 | 0. Cokolinis Vandentiekis | 75.7487 | 1437.27 | T3 1
5085060 | 0. Cokolinis Vandentiekis | 73.0196 | 1382.3 | V1 3 (1)
5085116 | 0. Cokolinis Vandentiekis | 760.508 | 1773.49 | T3 1
5085547 | 1. Pirmas | 61.1663 | 1749.01 | V1 3 (1)
5085637 | 1. Pirmas | 6.80447 | 1749.49 | V1 3 (1)
5085704 | 1. Pirmas | 47.0286 | 1749.49 | T3 1
5085767 | 1. Pirmas | 760.508 | 1773.49 | V1 3 (1)
5085803 | 1. Pirmas | 6.80447 | 1749.49 | V1 3 (1)
5085995 | 1. Pirmas | 760.508 | 1773.49 | T3 1
5086010 | 1. Pirmas | 47.0286 | 1749.49 | T3 1
5086127 | 1. Pirmas | 760.508 | 1773.49 | T3 1
5086176 | 1. Pirmas | 760.508 | 1773.49 | V1 3 (1)
5086203 | 1. Pirmas | 53.5028 | 1749.49 | V1 3 (1)
5086243 | 1. Pirmas | 33.2786 | 1749.49 | T3 1
5086389 | 1. Pirmas | 505.154 | 1749.49 | T3 1
5086399 | 1. Pirmas | 127.846 | 1749.49 | T3 1
5086547 | 1. Pirmas | 40.1537 | 1749.49 | V1 3 (1)
5086959 | 0. Cokolinis Vandentiekis | 253.519 | 1483.97 | T3 1
5086961 | 0. Cokolinis Vandentiekis | 308.045 | 1429 | V1 3 (1)
5087270 | 0. Cokolinis Vandentiekis | 11.5405 | 1749.49 | T3 1
5088105 | 0. Cokolinis Vandentiekis | 508.62 | 1747.79 | T3 1
5088140 | 0. Cokolinis Vandentiekis | 387.241 | 1747.79 | T3 1
5088343 | 1. Pirmas | 760.986 | 1773.01 | V1 3 (1)
5088374 | 1. Pirmas | 465.435 | 1747.31 | V1 3 (1)
5088399 | 1. Pirmas | 437.034 | 1746.87 | V1 3 (1)
5088633 | 1. Pirmas | 1518.66 | 1749.49 | T3 1
5088675 | 1. Pirmas | 1225.07 | 1749.01 | V1 3 (1)
5088719 | 1. Pirmas | 760.986 | 1773.01 | V1 3 (1)
5088755 | 1. Pirmas | 42.8314 | 1749.49 | T3 1
5088767 | 1. Pirmas | 760.508 | 1773.49 | T3 1
5089558 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5089560 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5089564 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5089584 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5089586 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5089590 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5089610 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5089612 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5089616 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5089669 | 0. Cokolinis Vandentiekis | 892.164 | 1380 | V1 3 (1)
5089699 | 0. Cokolinis Vandentiekis | 892.164 | 1380 | V1 3 (1)
5089718 | 0. Cokolinis Vandentiekis | 246.867 | 1380 | V1 3 (1)
5089730 | 0. Cokolinis Vandentiekis | 892.164 | 1380 | V1 3 (1)
5089787 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5089789 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5089795 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5089822 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5089824 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5089830 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5089851 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5089853 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5089859 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5089914 | 0. Cokolinis Vandentiekis | 438.013 | 1434.97 | T3 1
5089952 | 0. Cokolinis Vandentiekis | 892.164 | 1434.97 | T3 1
5089990 | 0. Cokolinis Vandentiekis | 892.164 | 1434.97 | T3 1
5090000 | 0. Cokolinis Vandentiekis | 892.165 | 1434.97 | T3 1
5090445 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5090447 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5090451 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5090453 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5090457 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5090459 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5090473 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5090475 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5090477 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5090485 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5090487 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5090489 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5090497 | 0. Cokolinis Vandentiekis | 145.222 | 1858.74 | V1 3 (1)
5090499 | 0. Cokolinis Vandentiekis | 434.746 | 1412 | V1 3 (1)
5090501 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | V1 3 (1)
5090515 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5090517 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5090519 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5090527 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5090529 | 0. Cokolinis Vandentiekis | 379.769 | 1466.97 | T3 1
5090531 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5090539 | 0. Cokolinis Vandentiekis | 75 | 1858.74 | T3 1
5090541 | 0. Cokolinis Vandentiekis | 382.257 | 1464.48 | T3 1
5090543 | 0. Cokolinis Vandentiekis | 1256.26 | 1882.74 | T3 1
5090617 | 0. Cokolinis Vandentiekis | 689.411 | 1434.97 | T3 1
5090646 | 0. Cokolinis Vandentiekis | 757.321 | 1380 | V1 3 (1)
5090674 | 0. Cokolinis Vandentiekis | 892.165 | 1434.97 | T3 1
5090704 | 0. Cokolinis Vandentiekis | 892.164 | 1380 | V1 3 (1)
5090734 | 0. Cokolinis Vandentiekis | 892.164 | 1434.97 | T3 1
5090764 | 0. Cokolinis Vandentiekis | 892.164 | 1380 | V1 3 (1)
5090785 | 0. Cokolinis Vandentiekis | 438.013 | 1434.97 | T3 1
5090795 | 0. Cokolinis Vandentiekis | 892.164 | 1434.97 | T3 1
5090816 | 0. Cokolinis Vandentiekis | 246.867 | 1380 | V1 3 (1)
5090826 | 0. Cokolinis Vandentiekis | 892.164 | 1380 | V1 3 (1)
5091053 | 0. Cokolinis Vandentiekis | 93.4161 | 1749.01 | V1 3 (1)
5091055 | 0. Cokolinis Vandentiekis | 1256.35 | 1749.01 | V1 3 (1)
5091057 | 0. Cokolinis Vandentiekis | 1260.99 | 1773.01 | V1 3 (1)
5091107 | 0. Cokolinis Vandentiekis | 147.293 | 1749.49 | T3 1
5091109 | 0. Cokolinis Vandentiekis | 153.831 | 1749.49 | T3 1
5091111 | 0. Cokolinis Vandentiekis | 1260.51 | 1773.49 | T3 1
5091584 | 1. Pirmas | 186.467 | 1747.31 | V1 3 (1)
5092012 | 0. Cokolinis Vandentiekis | 1298.23 | 1749.49 | T3 1
5092080 | 1. Pirmas | 85.0604 | 1749.49 | T3 1
5092123 | 0. Cokolinis Vandentiekis | 419.845 | 1384 | V1 3 (1)
5092436 | 0. Cokolinis Vandentiekis | 304.909 | 1438.97 | T3 1
5092560 | 0. Cokolinis Vandentiekis | 131.425 | 1382.3 | V1 3 (1)
5092625 | 0. Cokolinis Vandentiekis | 255.826 | 1384 | V1 3 (1)
5092678 | 0. Cokolinis Vandentiekis | 164.399 | 1384 | V1 3 (1)
5092703 | 0. Cokolinis Vandentiekis | 866.655 | 1384 | V1 3 (1)
5092871 | 0. Cokolinis Vandentiekis | 548 | 1384 | V1 3 (1)
5092880 | 0. Cokolinis Vandentiekis | 1958.8 | 1382.3 | V1 3 (1)
5092883 | 0. Cokolinis Vandentiekis | 29.0001 | 1384 | V1 3 (1)
5092958 | 0. Cokolinis Vandentiekis | 158.668 | 1384 | V1 3 (1)
5092982 | 0. Cokolinis Vandentiekis | 173.668 | 1384 | V1 3 (1)
5092989 | 0. Cokolinis Vandentiekis | 570.741 | 1382.3 | V1 3 (1)
5093055 | 0. Cokolinis Vandentiekis | 2232 | -860.003 | V1 3 (1)
5093122 | 0. Cokolinis Vandentiekis | 578 | 1384 | V1 3 (1)
5093183 | 0. Cokolinis Vandentiekis | 1750.62 | 1408 | V1 3 (1)
5093207 | 1. Pirmas | 99 | 3170.62 | V1 3 (1)
5093234 | 1. Pirmas | 127 | 3031.62 | V1 3 (1)
5093259 | 0. Cokolinis Vandentiekis | 2177 | -805.003 | V1 3 (1)
5093389 | 0. Cokolinis Vandentiekis | 2147 | -775.003 | V1 3 (1)
5093467 | 0. Cokolinis Vandentiekis | 2232 | -860.003 | V1 3 (1)
5093594 | 0. Cokolinis Vandentiekis | 2547 | -1175 | V1 3 (3)
5093648 | 0. Cokolinis Vandentiekis | 2601.98 | -1175 | T3 1
5097594 | 0. Cokolinis Vandentiekis | 440.625 | 1384 | V1 3 (1)
5097673 | 0. Cokolinis Vandentiekis | 2656.88 | -1284.89 | V1 3 (1)
5097789 | 0. Cokolinis Vandentiekis | 2656.38 | -1284.39 | V1 3 (1)
5098252 | -1 Baseino dugnas | 42 | -1362.39 | V1 3 (1)
5098437 | 0. Cokolinis Vandentiekis | 31.0691 | -1308.39 | V1 3 (1)
5098486 | -1 Baseino dugnas | 41.5 | -1362.39 | V1 3 (1)
5098569 | 0. Cokolinis Vandentiekis | 21.5082 | -1308.89 | V1 3 (1)
5098603 | 0. Cokolinis Vandentiekis | 443.181 | 1384 | V1 3 (1)
5098617 | 0. Cokolinis Vandentiekis | 505.904 | 1384 | V1 3 (1)
5098634 | -1 Baseino dugnas | 2734.38 | -1362.39 | V1 3 (1)
5099308 | 0. Cokolinis Vandentiekis | 554.938 | 1383.99 | V1 3 (1)
5099453 | 0. Cokolinis Vandentiekis | 721.412 | 1436.48 | T3 2
5099469 | 0. Cokolinis Vandentiekis | 28.6875 | 1436.48 | T3 2
5099761 | 0. Cokolinis Vandentiekis | 2786.87 | -1362.39 | T3 2
5099910 | 0. Cokolinis Vandentiekis | 2786.87 | -1362.39 | T3 2
5100016 | 0. Cokolinis Vandentiekis | 2786.87 | -1362.39 | T3 2
5100029 | 0. Cokolinis Vandentiekis | 85.9809 | 1436.48 | T3 2
5100032 | 0. Cokolinis Vandentiekis | 203.188 | 1436.48 | T3 2
5100131 | 0. Cokolinis Vandentiekis | 670.865 | 1436.48 | T3 2
5100293 | 0. Cokolinis Vandentiekis | 1819 | -455.003 | V1 3 (1)
5100501 | 0. Cokolinis Vandentiekis | 220 | -715.003 | V1 3 (1)
5100529 | 0. Cokolinis Vandentiekis | 240 | -735.003 | V1 3 (1)
5100582 | 0. Cokolinis Vandentiekis | 890.852 | -482.704 | V1 3 (1)
5100615 | 0. Cokolinis Vandentiekis | 163.155 | -482.704 | V1 3 (1)
5100641 | 0. Cokolinis Vandentiekis | 1359.58 | 1380 | V1 3 (1)
5100726 | 0. Cokolinis Vandentiekis | 817.024 | 1764.11 | V1 3 (1)
5100763 | 0. Cokolinis Vandentiekis | 480.064 | 1380 | V1 3 (1)
5100780 | 0. Cokolinis Vandentiekis | 384.405 | 1380 | V1 3 (1)
5100797 | 0. Cokolinis Vandentiekis | 709.732 | 1380 | V1 3 (1)
5100830 | 0. Cokolinis Vandentiekis | 1838.39 | 1412 | V1 3 (1)
5100886 | 0. Cokolinis Vandentiekis | 1735 | 1412 | V1 3 (1)
5100894 | 0. Cokolinis Vandentiekis | 79.4958 | 3159 | V1 3 (1)
5100930 | 0. Cokolinis Vandentiekis | 1715 | 1412 | V1 3 (1)
5100938 | 0. Cokolinis Vandentiekis | 59 | 3139 | V1 3 (1)
5101538 | 0. Cokolinis Vandentiekis | 117 | 3010 | V1 3 (1)
5101891 | 0. Cokolinis Vandentiekis | 64.8859 | 2593.14 | V1 3 (1)
5102040 | 0. Cokolinis Vandentiekis | 1008 | 1412 | V1 3 (1)
5102063 | 0. Cokolinis Vandentiekis | 46.1756 | 1380 | V1 3 (1)
5102106 | 0. Cokolinis Vandentiekis | 771.984 | 1380 | V1 3 (1)
5102198 | 0. Cokolinis Vandentiekis | 1454.86 | 1380 | V1 3 (1)
5102269 | 0. Cokolinis Vandentiekis | 70.2832 | 3262.39 | V1 3 (1)
5102306 | 0. Cokolinis Vandentiekis | 242 | 3008.39 | V1 3 (1)
5102521 | 0. Cokolinis Vandentiekis | 91 | 2427.16 | V1 3 (1)
5102530 | 0. Cokolinis Vandentiekis | 3.20448 | 2403.16 | V1 3 (1)
5102552 | 0. Cokolinis Vandentiekis | 979.164 | 1412 | V1 3 (1)
5102619 | 0. Cokolinis Vandentiekis | 82 | 2436.16 | T3 2
5102627 | 0. Cokolinis Vandentiekis | 45.1533 | 2412.16 | T3 2
5102637 | 0. Cokolinis Vandentiekis | 937.674 | 1462.49 | T3 2
5103000 | 0. Cokolinis Vandentiekis | 122 | 3025 | V1 3 (1)
5103038 | 0. Cokolinis Vandentiekis | 723.5 | 1764.11 | V1 3 (1)
5103096 | 0. Cokolinis Vandentiekis | 3.20448 | 1740.11 | V1 3 (1)
5103107 | 0. Cokolinis Vandentiekis | 46.1745 | 1740.11 | V1 3 (1)
5103110 | 0. Cokolinis Vandentiekis | 316.116 | 1412 | V1 3 (1)
5103398 | 0. Cokolinis Vandentiekis | 482 | 2005.61 | T3 2
5103406 | 0. Cokolinis Vandentiekis | 43.903 | 1981.61 | T3 2
5103416 | 0. Cokolinis Vandentiekis | 508.127 | 1461.48 | T3 2
5103522 | 0. Cokolinis Vandentiekis | 404.762 | 1434.78 | T3 2
5103528 | 0. Cokolinis Vandentiekis | 1498.37 | 1434.78 | T3 2
5103655 | 0. Cokolinis Vandentiekis | 726.979 | 1382.3 | V1 3 (1)
5103663 | 0. Cokolinis Vandentiekis | 303.665 | 1382.3 | V1 3 (1)
5249341 | 0. Cokolinis Vandentiekis | 1682.02 | 1436.48 | T3 2
5249802 | 0. Cokolinis Vandentiekis | 2042.98 | 1384 | V1 3 (1)
5250128 | 0. Cokolinis Vandentiekis | 166.497 | 1384 | V1 3 (1)
5250250 | 0. Cokolinis Vandentiekis | 1751.76 | 1384 | V1 3 (1)
5250339 | 0. Cokolinis Vandentiekis | 165.863 | 1436.48 | T3 2
5250354 | 0. Cokolinis Vandentiekis | 2112.85 | 1436.48 | T3 2
5250957 | 0. Cokolinis Vandentiekis | 2786.87 | -1362.39 | T3 2
5251185 | 0. Cokolinis Vandentiekis | 21.4149 | 1384 | V1 3 (1)
5252748 | 0. Cokolinis Vandentiekis | 65.9366 | 1380 | V1 3 (1)
5252906 | 0. Cokolinis Vandentiekis | 87.8494 | 1380 | V1 3 (1)
5254322 | 0. Cokolinis Vandentiekis | 72.5612 | 1434.78 | T3 1
5254825 | 0. Cokolinis Vandentiekis | 67.2564 | 1382.29 | V1 3 (1)
5255607 | 0. Cokolinis Vandentiekis | 108.435 | 1434.78 | T3 1
5263619 | 0. Cokolinis Vandentiekis | 71.6618 | 1438.97 | T3 1
5263737 | 0. Cokolinis Vandentiekis | 58.491 | 1382.29 | V1 3 (1)
5263986 | 0. Cokolinis Vandentiekis | 56.1338 | 1438.97 | T3 1
5264079 | 0. Cokolinis Vandentiekis | 67.1832 | 1379.99 | V1 3 (1)
5264175 | 0. Cokolinis Vandentiekis | 81.1384 | 1434.97 | T3 1
5264259 | 0. Cokolinis Vandentiekis | 77.4114 | 1434.97 | T3 1
5264343 | 0. Cokolinis Vandentiekis | 59.4082 | 1379.99 | V1 3 (1)
5264469 | 0. Cokolinis Vandentiekis | 48.6351 | 1383.99 | V1 3 (1)
5264906 | 0. Cokolinis Vandentiekis | 44.5898 | 1379.99 | V1 3 (1)
5264952 | 0. Cokolinis Vandentiekis | 43.6793 | 1434.97 | T3 1
5265050 | 0. Cokolinis Vandentiekis | 57.9124 | 1434.97 | T3 1
5265114 | 0. Cokolinis Vandentiekis | 52.9338 | 1379.99 | V1 3 (1)
5325369 | 1. Pirmas | 4.26181 | 1889.61 | V1 3 (1)
5325371 | 1. Pirmas | 574 | 1913.61 | T3 7
5326735 | 1. Pirmas | 574 | 1913.61 | T3 7
5326780 | 1. Pirmas | 469 | 1889.61 | T3 7
5327231 | 1. Pirmas | 4.26181 | 1889.61 | V1 3 (1)
5327239 | 1. Pirmas | 574 | 1913.61 | V1 3 (1)
5327340 | 1. Pirmas | 469 | 1889.61 | V1 3 (1)
5327344 | 1. Pirmas | 574 | 1913.61 | V1 3 (1)
5327446 | 1. Pirmas | 2721.03 | 1889.61 | V1 3 (1)
5327477 | 1. Pirmas | 2649.99 | 1889.61 | T3 7
5327499 | 1. Pirmas | 297.391 | 1580.22 | V1 3 (1)
5327532 | 1. Pirmas | 304 | 1573.61 | T3 7
5327589 | 1. Pirmas | 2489.48 | 1549.61 | T3 7
5327605 | 1. Pirmas | 74.6391 | 1462.97 | T3 5
5327630 | 1. Pirmas | 72.9483 | 1438.97 | T3 5
5327759 | 1. Pirmas | 102.571 | 1556.22 | V1 3 (1)
5327918 | 1. Pirmas | 129.226 | 1414.99 | V1 3 (1)
5328590 | 1. Pirmas | 243.852 | 1438.97 | T3 3
5328649 | 1. Pirmas | 1866.63 | 1556.22 | V1 3 (1)
5329311 | 0. Cokolinis Vandentiekis | 2734.38 | -1362.39 | V1 3 (1)
5329867 | 0. Cokolinis Vandentiekis | 1739.92 | 1383.99 | V1 3 (1)
5329902 | 0. Cokolinis Vandentiekis | 299.308 | 1384 | V1 3 (1)
5329908 | 0. Cokolinis Vandentiekis | 37.4773 | 1384 | V1 3 (1)
5329922 | 0. Cokolinis Vandentiekis | 1553.05 | 1438.97 | T3 6
5329957 | 0. Cokolinis Vandentiekis | 19.4692 | 1438.97 | T3 3
5329963 | 0. Cokolinis Vandentiekis | 300.735 | 1438.97 | T3 3
5330451 | 0. Cokolinis Vandentiekis | 29.0122 | 1383.99 | V1 3 (1)
5330470 | 0. Cokolinis Vandentiekis | 60.6882 | 1438.97 | T3 3
5331248 | 0. Cokolinis Vandentiekis | 27 | -1199 | T3 1
5331285 | 0. Cokolinis Vandentiekis | 62 | -1199 | V1 3 (3)
5335788 | 0. Cokolinis Vandentiekis | 91.3475 | -482.704 | V1 3 (1)
5345436 | 0. Cokolinis Vandentiekis | 1742 | 1384 | V1 3 (1)
5345448 | 0. Cokolinis Vandentiekis | 824 | 1384 | V1 3 (1)
5345458 | 0. Cokolinis Vandentiekis | 2648 | -1276 | V1 3 (1)
5348499 | 0. Cokolinis Vandentiekis | 93.4277 | 1749.01 | V1 3 (1)
5348501 | 0. Cokolinis Vandentiekis | 987.499 | 1749.02 | V1 3 (1)
5348509 | 0. Cokolinis Vandentiekis | 147.304 | 1749.49 | T3 1
5348525 | 0. Cokolinis Vandentiekis | 1178.61 | 1749.49 | T3 1
5348726 | 1. Pirmas | 618.441 | 1749.49 | V1 3 (1)
5348736 | 1. Pirmas | 176.772 | 1747.79 | V1 3 (1)
5349108 | 1. Pirmas | 629.112 | 1749.49 | T3 1
5349114 | 1. Pirmas | 77.3888 | 1747.79 | T3 1
5349180 | 1. Pirmas | 1260.51 | 1773.49 | T3 1
5349204 | 1. Pirmas | 1260.99 | 1773.01 | V1 3 (1)
5373598 | 0. Cokolinis Vandentiekis | 2793.66 | -227.895 | V1 3 (1)
5374036 | 0. Cokolinis Vandentiekis | 1568.89 | -203.894 | V1 3 (1)
5386147 | 0. Cokolinis Vandentiekis | 696.081 | 1390.24 | T3 1
5386149 | 0. Cokolinis Vandentiekis | 64.0001 | 1389 | T3 1
5386153 | 0. Cokolinis Vandentiekis | 2152 | -775.003 | T3 1
5386195 | 0. Cokolinis Vandentiekis | 1508.19 | 1438.97 | T3 1
5386378 | 0. Cokolinis Vandentiekis | 207.709 | 1436.48 | T3 1
5386380 | 0. Cokolinis Vandentiekis | 2229.49 | -805.003 | T3 1
5386537 | 0. Cokolinis Vandentiekis | 1851.74 | 1438.97 | T3 1
5386551 | 0. Cokolinis Vandentiekis | 1889.87 | 1438.97 | T3 1
5386598 | 0. Cokolinis Vandentiekis | 1789.9 | 1460.49 | T3 2
5386600 | 0. Cokolinis Vandentiekis | 110.283 | 3262.39 | T3 2
5386602 | 0. Cokolinis Vandentiekis | 242 | 3008.39 | T3 2
5386756 | 0. Cokolinis Vandentiekis | 378.612 | 1436.48 | T3 2
5386777 | 0. Cokolinis Vandentiekis | 1367.68 | 1436.48 | T3 2
5386816 | 0. Cokolinis Vandentiekis | 1685.51 | 1461.49 | T3 2
5386818 | 0. Cokolinis Vandentiekis | 123.955 | 3159 | T3 2
5386822 | 0. Cokolinis Vandentiekis | 122 | 3025 | T3 2
5386964 | 0. Cokolinis Vandentiekis | 1374.88 | 1434.78 | T3 2
5386974 | 0. Cokolinis Vandentiekis | 851.549 | 1434.78 | T3 2

# IfcFlowTerminal: 9320008 350 0:Tece Pisuaro remas (2)
Type - Material: RGBA(175,175,175,255), RGBA(174,49,30,255)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tece
Pset_DistributionFlowElementCommon - Reference: Tece Pisuaro remas; sets with these values: 2
Name (9320008 350 0:Tece Pisuaro remas:...) | In | Group
4747280 | 0. Cokolinis Vandentiekis | Other 2
4754139 | -1 Baseino dugnas | Other 3

# IfcFlowTerminal: Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm_PRO_100825:111.300.00.5 Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm (10)
Type - Description: Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm; PredefinedType: CISTERN; Material: Geberit, PE-HD, Black, Geberit, Plastic, Opaque white, Geberit, Laminate, Ivory, Matte, Geberit, Steel, galvanized, Geberit, Steel, Paint Finish, Blue, Laminate, Navy
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm
Pset_DistributionFlowElementCommon - Reference: 111.300.00.5 Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm; sets with these values: 2
Name (Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm_PRO_100825:111.300.00.5 Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm:...) | In
4714504 | 0. Cokolinis Vandentiekis
4718681 | 0. Cokolinis Vandentiekis
4718716 | 0. Cokolinis Vandentiekis
4778424 | 0. Cokolinis Vandentiekis
4785265 | 1. Pirmas
4786506 | 1. Pirmas
4793497 | 1. Pirmas
4794379 | 1. Pirmas
4845147 | 1. Pirmas
4872543 | 1. Pirmas

# IfcFlowTerminal: HL_Floor drain_HL510NG-B_V21_240612:HL510NG (2)
In: 1. Pirmas
Type - Material: Stainless Steel, Plactic - Gray, Plactic - White, Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Pset_DistributionFlowElementCommon - Reference: HL510NG; sets with these values: 2
Name (HL_Floor drain_HL510NG-B_V21_240612:HL510NG:...)
5383912
5384472

# IfcFlowTerminal: PRD_AR_Shlvs_MaximaShelfForCommercialSinks_MAXT:MAXT120-70, PRD_AR_Shlvs_MaximaShelfForCommercialSinks_MAXT:MAXT120-70:5053528
In: 1. Pirmas
Type - Material: PRD_AR_StainlessSteel_SatinFinished
Type - Pset_ElementShading - Color: stainless steel
Type - Pset_ManufacturerTypeInformation - ModelReference: MAXT120-70; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Maxima shelve for sinks width 1200 mm / depth 700 mm
Pset_DistributionFlowElementCommon - Reference: MAXT120-70; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a

# IfcFlowTerminal: PRD_AR_SnksSuprts_MaximaUnderframeToCommercialSinks_MAXF:MAXF120-70, PRD_AR_SnksSuprts_MaximaUnderframeToCommercialSinks_MAXF:MAXF120-70:5053527
In: 1. Pirmas
Type - Material: PRD_AR_StainlessSteel_SatinFinished
Type - Pset_ElementShading - Color: stainless steel
Type - Pset_ManufacturerTypeInformation - ModelReference: MAXF120-70; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Underframe to Maxima sinks width 1200 mm / depth 700 mm
Type - Pset_QuantityTakeOff - Reference: n/a
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a

# IfcFlowTerminal: PRD_AR_Snks_MaximaCommercialSink_MAXL200-120:MAXL200-120, PRD_AR_Snks_MaximaCommercialSink_MAXL200-120:MAXL200-120:5053526
In: 1. Pirmas
Type - PredefinedType: SINK; Material: PRD_AR_StainlessSteel_SatinFinished
Type - Pset_ElementShading - Color: stainless steel
Type - Pset_ManufacturerTypeInformation - ModelReference: MAXL200-120; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Maxima catering sink MAXL200-120
Type - Pset_SanitaryTerminalTypeSink - SinkType: Rinsing; NominalWidth: 1200 mm; NominalDepth: 700 mm; Color: stainless steel
Pset_DistributionFlowElementCommon - Reference: MAXL200-120; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Group: F1 3

# IfcFlowTerminal: Plumbing-Urinals-Sloan-Valve-HYB-4000:Pisuaras (2)
In: -1 Baseino dugnas
Type - Material: Sloan Valve - Finish - Stainless Steel, Sloan Valve - Plastic - White, Sloan Valve - Vitreous China - White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Sloan Valve
Classification: D2010 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pisuaras; sets with these values: 2
Name (Plumbing-Urinals-Sloan-Valve-HYB-4000:Pisuaras:...)
4722353
4722514 | Group: Other 1

# IfcFlowTerminal: Plumbing_Fixture-Oatey-Closet_Flange-Cast_Iron:Cast Iron Flange, Plumbing_Fixture-Oatey-Closet_Flange-Cast_Iron:Cast Iron Flange:5144751
In: -1 Baseino dugnas
Type - Material: Plastic-Oatey-ABS, Metal-Oatey-Cast Iron-Red, Metal-Oatey-Brass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Oatey Company
Type - Pset_PipeConnectionFlanged - FlangeThickness: 11.1125 mm
Classification: D2030 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Cast Iron Flange; sets with these values: 2

# IfcFlowTerminal: Sanitary_Basins_Ceramica-Globo_T-EDGE-Basin-B6R62:Default (9)
Type - Material: Glossy White BI 32FE5085
Pset_DistributionFlowElementCommon - Reference: Default; sets with these values: 2
Name (Sanitary_Basins_Ceramica-Globo_T-EDGE-Basin-B6R62:Default:...) | In
4746727 | 0. Cokolinis Vandentiekis
4787486 | 1. Pirmas
4791721 | 1. Pirmas
4791756 | 1. Pirmas
4793789 | 1. Pirmas
4794384 | 1. Pirmas
4846506 | 1. Pirmas
4888284 | 1. Pirmas
5102846 | 1. Pirmas

# IfcFlowTerminal: Sanitary_Basins_Sanindusa_Look-Semi-Recessed-Washbasin:SanindusaLavatório134360004 (3)
Type - Material: <Unnamed>
Type - Pset_ElementShading - Color: white
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: Look; Manufacturer: Sanindusa; ProductionYear: 2017
Type - Pset_ProductRequirements - Name: Look 83x47 semi-recessed
Pset_DistributionFlowElementCommon - Reference: SanindusaLavatório134360004; sets with these values: 2
Name (Sanitary_Basins_Sanindusa_Look-Semi-Recessed-Washbasin:SanindusaLavatório134360004:...) | In
4741252 | 0. Cokolinis Vandentiekis
4741440 | -1 Baseino dugnas
5388167 | 0. Cokolinis Vandentiekis

# IfcFlowTerminal: Sanitary_Toilets_Roca_347687xx0-ONA-Back-to-wall-vitreous-china close-coupled-WC-with-dual-outlet:Įleidžiamas unitazas (10)
Type - Material: F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Roca
Pset_DistributionFlowElementCommon - Reference: Įleidžiamas unitazas; sets with these values: 2
Name (Sanitary_Toilets_Roca_347687xx0-ONA-Back-to-wall-vitreous-china close-coupled-WC-with-dual-outlet:Įleidžiamas unitazas:...) | In
4714503 | 0. Cokolinis Vandentiekis
4718680 | 0. Cokolinis Vandentiekis
4718715 | 0. Cokolinis Vandentiekis
4845243 | 1. Pirmas
4845329 | 1. Pirmas
4845352 | 1. Pirmas
4845409 | 1. Pirmas
4845434 | 1. Pirmas
4890924 | 1. Pirmas
5343848 | 0. Cokolinis Vandentiekis | Group: Other 4

# IfcFlowTerminal: ŽN unitazas1:ŽN unitazas su porankiais - B C tipas, ŽN unitazas1:ŽN unitazas su porankiais - B C tipas:4734389
In: 0. Cokolinis Vandentiekis
Type - Material: Default - Bathroom Fixture
Type - Pset_ManufacturerTypeInformation - Manufacturer: DP metu
Pset_DistributionFlowElementCommon - Reference: ŽN unitazas su porankiais - B C tipas; sets with these values: 2
