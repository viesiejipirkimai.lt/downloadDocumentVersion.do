Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 27240251-8f0e-4fe5-b183-7d9275e0107d, NumberOfSaves: 150], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Project Number
Time: 2025-05-20T15:28:31+02:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.0.63 (ENG) - IFC 24.2.0.63

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 6

# IfcBuildingStorey: Level:8mm Head (6)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
-1 Baseino dugnas | -1 Baseino dugnas | -4000
0. Cokolinis Vandentiekis | 0. Cokolinis Vandentiekis | 5.41434e-13
1. Pirmas | 1. Pirmas | 3900
Pirmo aukšto antresolė | Pirmo aukšto antresolė | 7800
Stogas | Stogas | 10800
Stogo ilaju aukštas | Stogo ilaju aukštas | 11288

# IfcBuildingElementProxy: HVAC-Indoor_AC-LG-Cassette_4_Way_2x2:By Type, HVAC-Indoor_AC-LG-Cassette_4_Way_2x2:By Type:1096918
In: 1. Pirmas
Classification: D3060300 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: HVAC-Indoor_AC-LG-Cassette_4_Way_2x2-By Type; sets with these values: 2

# IfcBuildingElementProxy: HVAC_Air-Conditioning_Skystar_600_Sabiana_SK 600 2P 02-12-22-32-Ovale:SK02 (17)
Type - Material: lamiera, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: SABIANA
Material: <Unnamed>, lamiera
Pset_BuildingElementProxyCommon - Reference: SK02; sets with these values: 2
Name (HVAC_Air-Conditioning_Skystar_600_Sabiana_SK 600 2P 02-12-22-32-Ovale:SK02:...) | In | Group
5191658 | 1. Pirmas | K1 9
5193082 | 1. Pirmas | K1 10
5193214 | 1. Pirmas | K1 9
5193318 | 1. Pirmas | K1 10
5193412 | 1. Pirmas | K1 6
5193529 | 1. Pirmas | K1 5
5193617 | 1. Pirmas | K1 2
5193730 | 1. Pirmas | K1 2
5193827 | 1. Pirmas | K1 7
5193881 | 1. Pirmas | K1 7
5194317 | Pirmo aukšto antresolė | K1 11
5195031 | 0. Cokolinis Vandentiekis | Hydronic Supply 1; K1 1
5195328 | 1. Pirmas | K1 3
5195643 | 0. Cokolinis Vandentiekis | K1 2
5197811 | 0. Cokolinis Vandentiekis | K1 2
5199093 | 0. Cokolinis Vandentiekis | K1 1
5201226 | 0. Cokolinis Vandentiekis | K1 4

# IfcBuildingElementProxy: ŽN pakeliama atrama:ŽN pakeliama atrama su kojele, ŽN pakeliama atrama:ŽN pakeliama atrama su kojele:4734390
In: 0. Cokolinis Vandentiekis
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: DP metu
Pset_BuildingElementProxyCommon - Reference: ŽN pakeliama atrama su kojele; sets with these values: 2

# IfcDistributionPort (2718)
Description: Flow
Name | FlowDirection | Group
InPort_5364555_1 | SINK | L1 2
OutPort_4647952_1 | SOURCE | L1 2
InPort_4661860_0 | SINK | L1 2
OutPort_4651617_1 | SOURCE | L1 2
InPort_4662021_0 | SINK | L1 2
OutPort_4652182_1 | SOURCE | L1 2
InPort_4662046_0 | SINK | L1 2
OutPort_4652455_1 | SOURCE | L1 2
InPort_4662069_0 | SINK | L1 2
OutPort_4652520_1 | SOURCE | L1 2
InPort_4662090_1 | SINK | L1 2
OutPort_4652616_1 | SOURCE | L1 2
InPort_4654390_0 | SINK | L1 1
OutPort_4652938_1 | SOURCE | L1 1
InPort_4661555_1 | SINK | L1 1
OutPort_4653022_1 | SOURCE | L1 1
InPort_4659875_0 | SINK | L1 1
OutPort_4653123_1 | SOURCE | L1 1
InPort_4659975_0 | SINK | L1 1
OutPort_4653200_1 | SOURCE | L1 1
InPort_4659719_0 | SINK | L1 1
OutPort_4653279_1 | SOURCE | L1 1
InPort_4659557_0 | SINK | L1 1
OutPort_4653329_1 | SOURCE | L1 1
InPort_4659411_0 | SINK | L1 1
OutPort_4653369_1 | SOURCE | L1 1
Port_4654344_0 | SOURCEANDSINK | L1 1
Port_4659821_2 | SOURCEANDSINK | L1 1
Port_4654344_1 | SOURCEANDSINK | L1 1
Port_4659543_2 | SOURCEANDSINK | L1 1
Port_4654390_1 | SOURCEANDSINK | L1 1
Port_5040865_2 | SOURCEANDSINK | L1 1
Port_4659411_1 | SOURCEANDSINK | L1 1
Port_4659543_1 | SOURCEANDSINK | L1 1
Port_4659557_1 | SOURCEANDSINK | L1 1
Port_4659821_3 | SOURCEANDSINK | L1 1
Port_4659719_1 | SOURCEANDSINK | L1 1
Port_4659775_3 | SOURCEANDSINK | L1 1
Port_4659775_1 | SOURCEANDSINK | L1 1
Port_4660753_0 | SOURCEANDSINK | L1 1
Port_4659775_2 | SOURCEANDSINK | L1 1
Port_4659822_0 | SOURCEANDSINK | L1 1
Port_4659821_1 | SOURCEANDSINK | L1 1
Port_4659822_1 | SOURCEANDSINK | L1 1
Port_4659875_1 | SOURCEANDSINK | L1 1
Port_4660818_3 | SOURCEANDSINK | L1 1
Port_4659975_1 | SOURCEANDSINK | L1 1
Port_4660752_3 | SOURCEANDSINK | L1 1
Port_4660588_0 | SOURCEANDSINK | L1 1
Port_5040833_2 | SOURCEANDSINK | L1 1
Port_4660588_1 | SOURCEANDSINK | L1 1
Port_5040861_2 | SOURCEANDSINK | L1 1
Port_4660752_1 | SOURCEANDSINK | L1 1
Port_4660819_0 | SOURCEANDSINK | L1 1
Port_4660752_2 | SOURCEANDSINK | L1 1
Port_4660753_1 | SOURCEANDSINK | L1 1
Port_4660818_1 | SOURCEANDSINK | L1 1
Port_4661579_0 | SOURCEANDSINK | L1 1
Port_4660818_2 | SOURCEANDSINK | L1 1
Port_5347197_1 | SOURCEANDSINK | L1 1
Port_4660819_1 | SOURCEANDSINK | L1 1
Port_5347197_2 | SOURCEANDSINK | L1 1
Port_4661555_0 | SOURCEANDSINK | L1 1
Port_4661578_3 | SOURCEANDSINK | L1 1
Port_4661578_1 | SOURCEANDSINK | L1 1
Port_5040534_0 | SOURCEANDSINK | L1 1
Port_4661578_2 | SOURCEANDSINK | L1 1
Port_4661579_1 | SOURCEANDSINK | L1 1
Port_4661860_1 | SOURCEANDSINK | L1 2
Port_4663492_3 | SOURCEANDSINK | L1 2
Port_4662021_1 | SOURCEANDSINK | L1 2
Port_4663528_3 | SOURCEANDSINK | L1 2
Port_4662046_1 | SOURCEANDSINK | L1 2
Port_4663390_3 | SOURCEANDSINK | L1 2
Port_4662069_1 | SOURCEANDSINK | L1 2
Port_4663413_3 | SOURCEANDSINK | L1 2
Port_4662090_0 | SOURCEANDSINK | L1 2
Port_5363270_3 | SOURCEANDSINK | L1 2
Port_4662172_0 | SOURCEANDSINK | L1 1
Port_5303550_1 | SOURCEANDSINK | L1 1
Port_4662172_1 | SOURCEANDSINK | L1 1
Port_5175933_1 | SOURCEANDSINK | L1 1
Port_4663390_1 | SOURCEANDSINK | L1 2
Port_4663529_0 | SOURCEANDSINK | L1 2
Port_4663390_2 | SOURCEANDSINK | L1 2
Port_4663408_1 | SOURCEANDSINK | L1 2
Port_4663408_0 | SOURCEANDSINK | L1 2
Port_4663413_1 | SOURCEANDSINK | L1 2
Port_4663413_2 | SOURCEANDSINK | L1 2
Port_4663414_1 | SOURCEANDSINK | L1 2
Port_4663414_0 | SOURCEANDSINK | L1 2
Port_5363270_1 | SOURCEANDSINK | L1 2
Port_4663487_0 | SOURCEANDSINK | L1 2
Port_4663492_1 | SOURCEANDSINK | L1 2
Port_4663487_1 | SOURCEANDSINK | L1 2
Port_4663600_3 | SOURCEANDSINK | L1 2
Port_4663492_2 | SOURCEANDSINK | L1 2
Port_4663523_1 | SOURCEANDSINK | L1 2
Port_4663523_0 | SOURCEANDSINK | L1 2
Port_4663528_1 | SOURCEANDSINK | L1 2
Port_4663528_2 | SOURCEANDSINK | L1 2
Port_5347180_1 | SOURCEANDSINK | L1 2
Port_4663529_1 | SOURCEANDSINK | L1 2
Port_5347180_2 | SOURCEANDSINK | L1 2
Port_4663600_1 | SOURCEANDSINK | L1 2
Port_4665046_0 | SOURCEANDSINK | L1 2
Port_4663600_2 | SOURCEANDSINK | L1 2
Port_5307941_0 | SOURCEANDSINK | L1 2
OutPort_4663987_1 | SOURCE
Port_4665046_1 | SOURCEANDSINK | L1 2
Port_5058121_1 | SOURCEANDSINK | L1 2
OutPort_4666271_1 | SOURCE
InPort_4684044_0 | SINK | L1 2
OutPort_4666278_1 | SOURCE | L1 2
Port_4684044_1 | SOURCEANDSINK | L1 2
Port_4684065_1 | SOURCEANDSINK | L1 2
Port_4684059_0 | SOURCEANDSINK | L1 2
Port_4684065_2 | SOURCEANDSINK | L1 2
Port_4684059_1 | SOURCEANDSINK | L1 2
Port_5063266_1 | SOURCEANDSINK | L1 2
InPort_4684703_0 | SINK | L1 2
OutPort_4684699_1 | SOURCE | L1 2
Port_4684703_1 | SOURCEANDSINK | L1 2
Port_5064246_1 | SOURCEANDSINK | L1 2
Port_4684705_0 | SOURCEANDSINK | L1 2
Port_5064246_2 | SOURCEANDSINK | L1 2
Port_4684705_1 | SOURCEANDSINK | L1 2
Port_5064250_3 | SOURCEANDSINK | L1 2
InPort_4684729_0 | SINK | L1 1
OutPort_4684725_1 | SOURCE | L1 1
InPort_5061898_1 | SINK | L1 1
OutPort_4684729_1 | SOURCE | L1 1
InPort_5362819_0 | SINK | L1 1
OutPort_4684783_1 | SOURCE | L1 1
InPort_5363024_2 | SINK | L1 1
OutPort_4684789_0 | SOURCE | L1 1
InPort_4684789_1 | SINK | L1 1
OutPort_5363028_2 | SOURCE | L1 1
InPort_4685651_0 | SINK | L1 1
OutPort_4685650_1 | SOURCE | L1 1
InPort_4686380_1 | SINK | L1 1
OutPort_4685651_1 | SOURCE | L1 1
InPort_4685653_0 | SINK | L1 1
OutPort_5062019_1 | SOURCE | L1 1
InPort_5042398_1 | SINK | L1 1
OutPort_4685653_1 | SOURCE | L1 1
InPort_5062020_0 | SINK | L1 1
OutPort_4686380_2 | SOURCE | L1 1
InPort_4686407_0 | SINK | L1 1
OutPort_5042398_2 | SOURCE | L1 1
InPort_5042442_3 | SINK | L1 1
OutPort_4686407_1 | SOURCE | L1 1
InPort_4703151_0 | SINK | L1 1
OutPort_4702333_1 | SOURCE | L1 1
InPort_4703541_0 | SINK | L1 1
OutPort_4702904_1 | SOURCE | L1 1
InPort_4703169_1 | SINK | L1 1
OutPort_4703151_1 | SOURCE | L1 1
InPort_4703159_0 | SINK | L1 1
OutPort_4703169_2 | SOURCE | L1 1
InPort_5046255_1 | SINK | L1 1
OutPort_4703159_1 | SOURCE | L1 1
InPort_5044237_1 | SINK | L1 1
OutPort_4703541_1 | SOURCE | L1 1
InPort_4705532_0 | SINK | L1 1
OutPort_4703785_1 | SOURCE | L1 1
InPort_4704807_0 | SINK | L1 1
OutPort_4704193_1 | SOURCE | L1 1
InPort_4704835_0 | SINK | L1 1
OutPort_4704460_1 | SOURCE | L1 1
InPort_4707639_1 | SINK | L1 1
OutPort_4704807_1 | SOURCE | L1 1
InPort_4707125_1 | SINK | L1 1
OutPort_4704835_1 | SOURCE | L1 1
InPort_4705194_0 | SINK | L1 1
OutPort_4707125_2 | SOURCE | L1 1
InPort_4707840_1 | SINK | L1 1
OutPort_4705194_1 | SOURCE | L1 1
InPort_4705909_1 | SINK | L1 1
OutPort_4705532_1 | SOURCE | L1 1
InPort_4705683_0 | SINK | L1 1
OutPort_4705909_2 | SOURCE | L1 1
InPort_4705913_2 | SINK | L1 1
OutPort_4705683_1 | SOURCE | L1 1
InPort_5211054_0 | SINK | L1 1
OutPort_4705913_1 | SOURCE | L1 1
InPort_4707697_2 | SINK | L1 1
OutPort_4707293_0 | SOURCE | L1 1
InPort_4707293_1 | SINK | L1 1
OutPort_4707639_2 | SOURCE | L1 1
InPort_4707697_3 | SINK | L1 1
OutPort_4707666_0 | SOURCE | L1 1
InPort_4707666_1 | SINK | L1 1
OutPort_4707840_2 | SOURCE | L1 1
InPort_4707698_1 | SINK | L1 1
OutPort_4707697_1 | SOURCE | L1 1
InPort_5181211_1 | SINK | L1 1
OutPort_4707698_0 | SOURCE | L1 1
Port_4710643_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4712329_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4710643_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5421398_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4712329_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5034829_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_4712329_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712503_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712329_4 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712587_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712503_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712558_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712558_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4778496_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712587_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712623_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712623_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712615_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712615_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712837_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712837_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4712829_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4712829_1 | SINK | F1 2 (1) (1) (1) (1) (1)
Port_4713935_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4778495_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4713935_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714038_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714204_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714038_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714047_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4778495_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714047_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714204_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714246_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714254_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714246_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714307_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714254_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5034829_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714254_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5287189_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714280_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714307_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4714280_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4714503_1 | SOURCE
OutPort_4714503_2 | SOURCE
InPort_4714504_1 | SINK
OutPort_4714504_2 | SOURCE
OutPort_4718680_1 | SOURCE
OutPort_4718680_2 | SOURCE
InPort_4718681_1 | SINK
OutPort_4718681_2 | SOURCE
OutPort_4718715_1 | SOURCE
OutPort_4718715_2 | SOURCE
InPort_4718716_1 | SINK
OutPort_4718716_2 | SOURCE
OutPort_4722353_1 | SOURCE
InPort_4722353_3 | SINK
InPort_4747086_1 | SINK | F1 1
OutPort_4722514_1 | SOURCE | F1 1
InPort_4722514_3 | SINK | Other 1
OutPort_4741252_2 | SOURCE
OutPort_4741440_2 | SOURCE
Port_4747086_2 | SOURCEANDSINK | F1 1
InPort_4747280_1 | SINK | Other 2
InPort_4747280_2 | SINK | F1 3 (6)
OutPort_4749779_0 | SOURCE | F1 3 (6)
InPort_4749783_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4749779_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4781046_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4749783_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_4753681_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782506_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4753681_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5024585_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_4754139_1 | SINK | Other 3
InPort_4754139_2 | SINK | F1 3 (5)
OutPort_4754143_0 | SOURCE | F1 3 (5)
InPort_4754141_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4780829_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5179701_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4754141_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4754145_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4754143_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4780762_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4754145_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4849633_2 | SINK | F1 9
OutPort_4755116_0 | SOURCE | F1 9
InPort_4755116_1 | SINK | F1 9
OutPort_5357908_1 | SOURCE | F1 9
Port_4755556_0 | SOURCEANDSINK | F1 9
Port_4872341_3 | SOURCEANDSINK | F1 9
Port_4755556_1 | SOURCEANDSINK | F1 9
Port_4755663_0 | SOURCEANDSINK | F1 9
Port_5390500_1 | SOURCEANDSINK | F1 9
Port_4755663_1 | SOURCEANDSINK | F1 9
Port_4755775_0 | SOURCEANDSINK | F1 9
Port_5351568_2 | SOURCEANDSINK | F1 9
Port_4755775_1 | SOURCEANDSINK | F1 9
Port_5351576_1 | SOURCEANDSINK | F1 9
Port_4756346_0 | SOURCEANDSINK | F1 9
Port_4789731_3 | SOURCEANDSINK | F1 9
Port_4756346_1 | SOURCEANDSINK | F1 9
Port_4789797_1 | SOURCEANDSINK | F1 9
Port_4770913_1 | SOURCEANDSINK | F1 4 (1)
Port_4811831_3 | SOURCEANDSINK | F1 4 (1)
InPort_4778424_1 | SINK
OutPort_4778424_2 | SOURCE
InPort_4778496_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4778495_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_4779701_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5243728_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4779701_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5243734_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_4780829_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4780762_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5180267_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4781046_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_4782293_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782295_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782293_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782301_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782295_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782299_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782301_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782299_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782315_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782303_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782319_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782303_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5412968_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782313_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782315_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782313_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782319_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4782506_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5345344_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_4782960_2 | SINK | F1 3 (9)
OutPort_4782958_0 | SOURCE | F1 3 (9)
InPort_4782966_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782958_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
OutPort_4782960_1 | SOURCE | F1 3 (9)
InPort_4782964_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782966_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4782974_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782964_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784906_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782968_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4782968_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782978_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4782972_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784497_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4782978_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782972_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784498_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4782974_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784134_2 | SINK | F1 3 (10)
OutPort_4784132_0 | SOURCE | F1 3 (10)
InPort_4784140_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784132_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
OutPort_4784134_1 | SOURCE | F1 3 (10)
InPort_4784138_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784140_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784144_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784138_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784142_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784144_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784513_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784142_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784497_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784424_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784424_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784513_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784497_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784498_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784724_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784906_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4784914_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4784724_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_4784914_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038382_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4784914_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5095913_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4785079_1 | SOURCEANDSINK | F1 4 (1)
Port_4809922_3 | SOURCEANDSINK | F1 4 (1)
Port_4785208_1 | SOURCEANDSINK | F1 4 (1)
Port_4797984_1 | SOURCEANDSINK | F1 4 (1)
InPort_4785265_1 | SINK
OutPort_4785265_2 | SOURCE
Port_4785359_0 | SOURCEANDSINK | F1 9
Port_5408789_3 | SOURCEANDSINK | F1 9
Port_4785359_1 | SOURCEANDSINK | F1 9
Port_4785480_0 | SOURCEANDSINK | F1 9
Port_4818917_2 | SOURCEANDSINK | F1 9
Port_4785480_1 | SOURCEANDSINK | F1 9
Port_4818925_1 | SOURCEANDSINK | F1 9
Port_4785721_0 | SOURCEANDSINK | F1 9
Port_4818917_1 | SOURCEANDSINK | F1 9
Port_4785721_1 | SOURCEANDSINK | F1 9
Port_4794096_2 | SOURCEANDSINK | F1 9
InPort_4786506_1 | SINK
OutPort_4786506_2 | SOURCE
Port_4786576_0 | SOURCEANDSINK | F1 9
Port_4838003_2 | SOURCEANDSINK | F1 9
Port_4786576_1 | SOURCEANDSINK | F1 9
Port_4788623_1 | SOURCEANDSINK | F1 9
Port_4787367_0 | SOURCEANDSINK | F1 9
Port_4787746_2 | SOURCEANDSINK | F1 9
Port_4787367_1 | SOURCEANDSINK | F1 9
Port_4788358_1 | SOURCEANDSINK | F1 9
Port_4787726_0 | SOURCEANDSINK | F1 9
Port_4788623_2 | SOURCEANDSINK | F1 9
Port_4787726_1 | SOURCEANDSINK | F1 9
Port_4787746_1 | SOURCEANDSINK | F1 9
Port_4788131_0 | SOURCEANDSINK | F1 9
Port_4788295_1 | SOURCEANDSINK | F1 9
Port_4788131_1 | SOURCEANDSINK | F1 9
Port_4788283_0 | SOURCEANDSINK | F1 9
Port_4788295_2 | SOURCEANDSINK | F1 9
Port_4788283_1 | SOURCEANDSINK | F1 9
Port_4788358_2 | SOURCEANDSINK | F1 9
Port_4789350_1 | SOURCEANDSINK | F1 9
Port_4838004_0 | SOURCEANDSINK | F1 9
Port_4789350_2 | SOURCEANDSINK | F1 9
Port_4789732_0 | SOURCEANDSINK | F1 9
InPort_4797643_0 | SINK | F1 9
OutPort_4789731_1 | SOURCE | F1 9
Port_4789731_2 | SOURCEANDSINK | F1 9
Port_4789732_1 | SOURCEANDSINK | F1 9
Port_4789789_0 | SOURCEANDSINK | F1 9
Port_4789797_2 | SOURCEANDSINK | F1 9
Port_4789789_1 | SOURCEANDSINK | F1 9
Port_4791064_0 | SOURCEANDSINK | F1 9
Port_4791066_2 | SOURCEANDSINK | F1 9
Port_4791064_1 | SOURCEANDSINK | F1 9
Port_4791072_1 | SOURCEANDSINK | F1 9
Port_4791066_1 | SOURCEANDSINK | F1 9
Port_4791070_0 | SOURCEANDSINK | F1 9
Port_4791072_2 | SOURCEANDSINK | F1 9
Port_4791070_1 | SOURCEANDSINK | F1 9
Port_4791078_1 | SOURCEANDSINK | F1 9
Port_4791076_0 | SOURCEANDSINK | F1 9
Port_5204872_1 | SOURCEANDSINK | F1 9
Port_4791076_1 | SOURCEANDSINK | F1 9
Port_5351568_1 | SOURCEANDSINK | F1 9
Port_4791078_2 | SOURCEANDSINK | F1 9
Port_5204873_0 | SOURCEANDSINK | F1 9
Port_4791117_0 | SOURCEANDSINK | F1 9
Port_4791119_2 | SOURCEANDSINK | F1 9
Port_4791117_1 | SOURCEANDSINK | F1 9
Port_4791125_1 | SOURCEANDSINK | F1 9
Port_4791119_1 | SOURCEANDSINK | F1 9
Port_4791123_0 | SOURCEANDSINK | F1 9
Port_4791125_2 | SOURCEANDSINK | F1 9
Port_4791123_1 | SOURCEANDSINK | F1 9
Port_4791503_2 | SOURCEANDSINK | F1 9
Port_4791406_0 | SOURCEANDSINK | F1 9
Port_4791503_1 | SOURCEANDSINK | F1 9
Port_4791406_1 | SOURCEANDSINK | F1 9
Port_5351252_3 | SOURCEANDSINK | F1 9
Port_4791797_0 | SOURCEANDSINK | F1 9
Port_4791799_2 | SOURCEANDSINK | F1 9
Port_4791797_1 | SOURCEANDSINK | F1 9
Port_4791805_1 | SOURCEANDSINK | F1 9
Port_4791799_1 | SOURCEANDSINK | F1 9
Port_4791805_2 | SOURCEANDSINK | F1 9
Port_4792610_0 | SOURCEANDSINK | F1 9
Port_4792610_1 | SOURCEANDSINK | F1 9
Port_4793187_1 | SOURCEANDSINK | F1 9
Port_4793091_0 | SOURCEANDSINK | F1 9
Port_4793187_2 | SOURCEANDSINK | F1 9
Port_4793091_1 | SOURCEANDSINK | F1 9
Port_5351315_1 | SOURCEANDSINK | F1 9
Port_4793373_0 | SOURCEANDSINK | F1 9
Port_5351315_2 | SOURCEANDSINK | F1 9
Port_4793373_1 | SOURCEANDSINK | F1 9
Port_5351448_3 | SOURCEANDSINK | F1 9
InPort_4793497_1 | SINK
OutPort_4793497_2 | SOURCE
Port_4793675_0 | SOURCEANDSINK | F1 4 (2)
Port_4793675_1 | SOURCEANDSINK | F1 4 (2)
Port_4793819_0 | SOURCEANDSINK | F1 9
Port_4793821_2 | SOURCEANDSINK | F1 9
Port_4793819_1 | SOURCEANDSINK | F1 9
Port_4793827_1 | SOURCEANDSINK | F1 9
Port_4793821_1 | SOURCEANDSINK | F1 9
Port_4793825_0 | SOURCEANDSINK | F1 9
Port_4793827_2 | SOURCEANDSINK | F1 9
Port_4793825_1 | SOURCEANDSINK | F1 9
Port_4794098_1 | SOURCEANDSINK | F1 9
Port_4793981_0 | SOURCEANDSINK | F1 9
Port_4794098_2 | SOURCEANDSINK | F1 9
Port_4793981_1 | SOURCEANDSINK | F1 9
Port_4794096_3 | SOURCEANDSINK | F1 9
InPort_4794377_0 | SINK | F1 9
OutPort_4841653_2 | SOURCE | F1 9
InPort_4841695_1 | SINK | F1 9
OutPort_4794377_1 | SOURCE | F1 9
InPort_4794379_1 | SINK
OutPort_4794379_2 | SOURCE
Port_4794382_0 | SOURCEANDSINK | F1 9
Port_4794387_2 | SOURCEANDSINK | F1 9
Port_4794382_1 | SOURCEANDSINK | F1 9
Port_4794397_1 | SOURCEANDSINK | F1 9
Port_4794385_0 | SOURCEANDSINK | F1 9
Port_4794387_1 | SOURCEANDSINK | F1 9
Port_4794385_1 | SOURCEANDSINK | F1 9
Port_4842151_2 | SOURCEANDSINK | F1 9
Port_4794391_0 | SOURCEANDSINK | F1 9
Port_4794395_1 | SOURCEANDSINK | F1 9
Port_4794391_1 | SOURCEANDSINK | F1 9
Port_4794393_0 | SOURCEANDSINK | F1 9
Port_4794395_2 | SOURCEANDSINK | F1 9
Port_4794393_1 | SOURCEANDSINK | F1 9
Port_4794397_2 | SOURCEANDSINK | F1 9
InPort_4794872_4 | SINK | F1 9
OutPort_4794411_0 | SOURCE | F1 9
InPort_4794411_1 | SINK | F1 9
OutPort_4797132_1 | SOURCE | F1 9
InPort_4841653_1 | SINK | F1 9
OutPort_4794417_0 | SOURCE | F1 9
InPort_4794417_1 | SINK | F1 9
InPort_5287801_0 | SINK | F1 9
OutPort_4794872_1 | SOURCE | F1 9
InPort_4794872_2 | SINK | F1 9
OutPort_5287959_0 | SOURCE | F1 9
InPort_4794872_3 | SINK | F1 9
OutPort_4795109_0 | SOURCE | F1 9
InPort_4795109_1 | SINK | F1 9
OutPort_4797751_1 | SOURCE | F1 9
InPort_4797132_2 | SINK | F1 9
OutPort_4796919_0 | SOURCE | F1 9
InPort_4796919_1 | SINK | F1 9
OutPort_4797909_1 | SOURCE | F1 9
InPort_4797751_2 | SINK | F1 9
OutPort_4797643_1 | SOURCE | F1 9
InPort_4797909_2 | SINK | F1 9
OutPort_4838578_0 | SOURCE | F1 9
Port_4797944_0 | SOURCEANDSINK | F1 4 (1)
Port_4797984_2 | SOURCEANDSINK | F1 4 (1)
Port_4797944_1 | SOURCEANDSINK | F1 4 (1)
Port_4806653_1 | SOURCEANDSINK | F1 4 (1)
Port_4798561_1 | SOURCEANDSINK | F1 4 (1)
Port_4806897_3 | SOURCEANDSINK | F1 4 (1)
InPort_5287956_1 | SINK | F1 9
OutPort_4800158_0 | SOURCE | F1 9
InPort_4800158_1 | SINK | F1 9
OutPort_5357945_1 | SOURCE | F1 9
InPort_4800964_0 | SINK | F1 palubėje 12
OutPort_4801194_2 | SOURCE | F1 palubėje 12
InPort_4801277_1 | SINK | F1 palubėje 12
OutPort_4800964_1 | SOURCE | F1 palubėje 12
InPort_4801194_1 | SINK | F1 palubėje 12
OutPort_5455917_0 | SOURCE | F1 palubėje 12
InPort_4801225_0 | SINK | F1 palubėje 12
OutPort_4801277_2 | SOURCE | F1 palubėje 12
InPort_4801305_1 | SINK | F1 palubėje 12
OutPort_4801225_1 | SOURCE | F1 palubėje 12
InPort_4801297_0 | SINK | F1 palubėje 12
OutPort_5215481_2 | SOURCE | F1 palubėje 12
InPort_5095065_1 | SINK | F1 palubėje 12
OutPort_4801297_1 | SOURCE | F1 palubėje 12
InPort_5215482_0 | SINK | F1 palubėje 12
OutPort_4801305_2 | SOURCE | F1 palubėje 12
Port_4804490_0 | SOURCEANDSINK | F1 9
Port_4814897_3 | SOURCEANDSINK | F1 9
Port_4804490_1 | SOURCEANDSINK | F1 9
Port_4815032_1 | SOURCEANDSINK | F1 9
Port_4805892_0 | SOURCEANDSINK | F1 4 (1)
Port_4806653_2 | SOURCEANDSINK | F1 4 (1)
Port_4805892_1 | SOURCEANDSINK | F1 4 (1)
Port_4806736_1 | SOURCEANDSINK | F1 4 (1)
Port_4806736_2 | SOURCEANDSINK | F1 4 (1)
Port_4806898_0 | SOURCEANDSINK | F1 4 (1)
Port_4806897_1 | SOURCEANDSINK | F1 4 (1)
Port_5384535_0 | SOURCEANDSINK | F1 4 (1)
Port_4806897_2 | SOURCEANDSINK | F1 4 (1)
Port_4806898_1 | SOURCEANDSINK | F1 4 (1)
Port_4809922_1 | SOURCEANDSINK | F1 4 (1)
Port_4811832_0 | SOURCEANDSINK | F1 4 (1)
Port_4809922_2 | SOURCEANDSINK | F1 4 (1)
Port_5384495_1 | SOURCEANDSINK | F1 4 (1)
Port_4811824_0 | SOURCEANDSINK | F1 4 (1)
Port_4811831_1 | SOURCEANDSINK | F1 4 (1)
Port_4811824_1 | SOURCEANDSINK | F1 4 (1)
Port_4847730_2 | SOURCEANDSINK | F1 4 (1)
Port_4811831_2 | SOURCEANDSINK | F1 4 (1)
Port_4811832_1 | SOURCEANDSINK | F1 4 (1)
Port_4814683_0 | SOURCEANDSINK | F1 9
Port_4880161_3 | SOURCEANDSINK | F1 9
Port_4814683_1 | SOURCEANDSINK | F1 9
Port_5408789_1 | SOURCEANDSINK | F1 9
Port_4814897_1 | SOURCEANDSINK | F1 9
Port_4814898_1 | SOURCEANDSINK | F1 9
Port_4814897_2 | SOURCEANDSINK | F1 9
Port_5422942_0 | SOURCEANDSINK | F1 9
Port_4814898_0 | SOURCEANDSINK | F1 9
Port_4891349_1 | SOURCEANDSINK | F1 9
Port_4815032_2 | SOURCEANDSINK | F1 9
Port_4817258_0 | SOURCEANDSINK | F1 9
Port_4815032_3 | SOURCEANDSINK | F1 9
Port_4880162_0 | SOURCEANDSINK | F1 9
InPort_4817257_2 | SINK | F1 9
OutPort_4817248_0 | SOURCE | F1 9
InPort_4817248_1 | SINK | F1 9
OutPort_4837508_2 | SOURCE | F1 9
Port_4817257_1 | SOURCEANDSINK | F1 9
Port_4817258_1 | SOURCEANDSINK | F1 9
Port_4817257_3 | SOURCEANDSINK | F1 9
Port_5356942_0 | SOURCEANDSINK | F1 9
Port_4818757_0 | SOURCEANDSINK | F1 9
Port_4880161_2 | SOURCEANDSINK | F1 9
Port_4818757_1 | SOURCEANDSINK | F1 9
Port_4818925_2 | SOURCEANDSINK | F1 9
InPort_4837438_0 | SINK | F1 9
OutPort_4837101_1 | SOURCE | F1 9
InPort_4837508_1 | SINK | F1 9
OutPort_4837438_1 | SOURCE | F1 9
InPort_4837645_0 | SINK | F1 9
OutPort_4837611_1 | SOURCE | F1 9
InPort_4838003_3 | SINK | F1 9
OutPort_4837645_1 | SOURCE | F1 9
Port_4838003_1 | SOURCEANDSINK | F1 9
Port_4838004_1 | SOURCEANDSINK | F1 9
InPort_4838578_1 | SINK | F1 9
OutPort_4841695_2 | SOURCE | F1 9
InPort_4839044_0 | SINK | F1 3 (4)
OutPort_4838888_1 | SOURCE | F1 3 (4)
InPort_4838888_1 | SINK | F1 3 (4)
OutPort_4839044_0 | SOURCE | F1 3 (4)
InPort_4839044_1 | SINK | F1 3 (4)
OutPort_5104036_2 | SOURCE | F1 3 (4)
Port_4842142_0 | SOURCEANDSINK | F1 9
Port_4842151_3 | SOURCEANDSINK | F1 9
Port_4842142_1 | SOURCEANDSINK | F1 9
Port_5407519_1 | SOURCEANDSINK | F1 9
Port_4844626_0 | SOURCEANDSINK | F1 4 (3)
Port_4876073_2 | SOURCEANDSINK | F1 4 (3)
Port_4844626_1 | SOURCEANDSINK | F1 4 (3)
Port_4872267_1 | SOURCEANDSINK | F1 4 (3)
InPort_4845147_1 | SINK
OutPort_4845147_2 | SOURCE
OutPort_4845243_1 | SOURCE
OutPort_4845243_2 | SOURCE
OutPort_4845329_1 | SOURCE
OutPort_4845329_2 | SOURCE
OutPort_4845352_1 | SOURCE
OutPort_4845352_2 | SOURCE
OutPort_4845409_1 | SOURCE
OutPort_4845409_2 | SOURCE
OutPort_4845434_1 | SOURCE
OutPort_4845434_2 | SOURCE
Port_4847297_0 | SOURCEANDSINK | F1 4 (1)
Port_4847730_1 | SOURCEANDSINK | F1 4 (1)
Port_4847297_1 | SOURCEANDSINK | F1 4 (1)
Port_4848876_2 | SOURCEANDSINK | F1 4 (1)
InPort_4847430_0 | SINK | F1 9
OutPort_5287798_1 | SOURCE | F1 9
InPort_4892475_1 | SINK | F1 9
OutPort_4847430_1 | SOURCE | F1 9
Port_4848868_0 | SOURCEANDSINK | F1 4 (1)
Port_4848876_1 | SOURCEANDSINK | F1 4 (1)
Port_4848868_1 | SOURCEANDSINK | F1 4 (1)
Port_4849277_3 | SOURCEANDSINK | F1 4 (1)
Port_4849277_1 | SOURCEANDSINK | F1 4 (1)
Port_4849277_2 | SOURCEANDSINK | F1 4 (1)
Port_4849292_0 | SOURCEANDSINK | F1 4 (1)
Port_4849292_1 | SOURCEANDSINK | F1 4 (1)
Port_4849589_0 | SOURCEANDSINK | F1 9
Port_4849633_3 | SOURCEANDSINK | F1 9
Port_4849589_1 | SOURCEANDSINK | F1 9
Port_4849653_2 | SOURCEANDSINK | F1 9
Port_4849633_1 | SOURCEANDSINK | F1 9
Port_4849634_1 | SOURCEANDSINK | F1 9
Port_4849634_0 | SOURCEANDSINK | F1 9
Port_5422939_1 | SOURCEANDSINK | F1 9
Port_4849653_1 | SOURCEANDSINK | F1 9
Port_5423012_0 | SOURCEANDSINK | F1 9
InPort_4850380_3 | SINK | F1 9
OutPort_4850317_1 | SOURCE | F1 9
InPort_4850374_3 | SINK | F1 9
OutPort_4850328_1 | SOURCE | F1 9
InPort_4850352_1 | SINK | F1 9
OutPort_4850348_1 | SOURCE | F1 9
InPort_4850350_0 | SINK | F1 9
OutPort_4850352_2 | SOURCE | F1 9
InPort_4850360_1 | SINK | F1 9
OutPort_4850350_1 | SOURCE | F1 9
InPort_4850368_3 | SINK | F1 9
OutPort_4850356_1 | SOURCE | F1 9
InPort_4850358_0 | SINK | F1 9
OutPort_4850360_2 | SOURCE | F1 9
InPort_4850364_1 | SINK | F1 9
OutPort_4850358_1 | SOURCE | F1 9
InPort_4850369_0 | SINK | F1 9
OutPort_4850364_2 | SOURCE | F1 9
InPort_5384232_0 | SINK | F1 9
OutPort_4850368_1 | SOURCE | F1 9
InPort_4850368_2 | SINK | F1 9
OutPort_4850369_1 | SOURCE | F1 9
InPort_4850381_0 | SINK | F1 9
OutPort_4850374_1 | SOURCE | F1 9
InPort_4850374_2 | SINK | F1 9
OutPort_5384193_1 | SOURCE | F1 9
InPort_4850378_0 | SINK | F1 9
OutPort_4850380_1 | SOURCE | F1 9
InPort_4850390_2 | SINK | F1 9
OutPort_4850378_1 | SOURCE | F1 9
InPort_4850380_2 | SINK | F1 9
OutPort_4850381_1 | SOURCE | F1 9
InPort_4850388_0 | SINK | F1 9
OutPort_4850390_1 | SOURCE | F1 9
InPort_4850396_2 | SINK | F1 9
OutPort_4850388_1 | SOURCE | F1 9
InPort_4850394_0 | SINK | F1 9
OutPort_4850396_1 | SOURCE | F1 9
InPort_4850400_3 | SINK | F1 9
OutPort_4850394_1 | SOURCE | F1 9
Port_4850400_1 | SOURCEANDSINK | F1 9
Port_4888357_1 | SOURCEANDSINK | F1 9
Port_4850400_2 | SOURCEANDSINK | F1 9
Port_4891325_0 | SOURCEANDSINK | F1 9
Port_4851261_0 | SOURCEANDSINK | F1 9
Port_4851462_3 | SOURCEANDSINK | F1 9
Port_4851261_1 | SOURCEANDSINK | F1 9
Port_4851462_1 | SOURCEANDSINK | F1 9
Port_4851463_0 | SOURCEANDSINK | F1 9
Port_4851462_2 | SOURCEANDSINK | F1 9
Port_4853766_0 | SOURCEANDSINK | F1 9
Port_4851463_1 | SOURCEANDSINK | F1 9
Port_4870979_3 | SOURCEANDSINK | F1 9
Port_4852724_0 | SOURCEANDSINK | F1 9
Port_4852726_2 | SOURCEANDSINK | F1 9
Port_4852724_1 | SOURCEANDSINK | F1 9
Port_4852732_1 | SOURCEANDSINK | F1 9
Port_4852726_1 | SOURCEANDSINK | F1 9
Port_4852732_2 | SOURCEANDSINK | F1 9
Port_4852824_0 | SOURCEANDSINK | F1 9
Port_4852824_1 | SOURCEANDSINK | F1 9
Port_4852883_1 | SOURCEANDSINK | F1 9
Port_4852875_0 | SOURCEANDSINK | F1 9
Port_4852883_2 | SOURCEANDSINK | F1 9
Port_4852875_1 | SOURCEANDSINK | F1 9
Port_4871549_1 | SOURCEANDSINK | F1 9
Port_4853766_1 | SOURCEANDSINK | F1 9
Port_4871531_1 | SOURCEANDSINK | F1 9
InPort_4890022_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4853992_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_4870438_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4899322_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870438_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870543_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870592_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870647_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870592_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870655_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870647_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444057_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870647_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5442425_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4870952_0 | SOURCEANDSINK | F1 9
Port_5296583_1 | SOURCEANDSINK | F1 9
Port_4870952_1 | SOURCEANDSINK | F1 9
Port_5418201_1 | SOURCEANDSINK | F1 9
Port_4870979_1 | SOURCEANDSINK | F1 9
Port_5296586_0 | SOURCEANDSINK | F1 9
InPort_4870979_2 | SINK | F1 9
OutPort_5457336_0 | SOURCE | F1 9
InPort_5457333_1 | SINK | F1 9
OutPort_4870990_0 | SOURCE | F1 9
InPort_4870990_1 | SINK | F1 9
OutPort_4889244_1 | SOURCE | F1 9
Port_4871344_0 | SOURCEANDSINK | F1 9
Port_4894019_2 | SOURCEANDSINK | F1 9
Port_4871344_1 | SOURCEANDSINK | F1 9
Port_4871549_2 | SOURCEANDSINK | F1 9
Port_4871531_2 | SOURCEANDSINK | F1 9
Port_4894020_0 | SOURCEANDSINK | F1 9
Port_4872267_2 | SOURCEANDSINK | F1 4 (3)
Port_4872341_1 | SOURCEANDSINK | F1 9
Port_4872341_2 | SOURCEANDSINK | F1 9
Port_4896631_1 | SOURCEANDSINK | F1 9
InPort_4872543_1 | SINK
OutPort_4872543_2 | SOURCE
Port_4873654_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038227_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4873654_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038259_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4874158_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5412968_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4874158_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4890132_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4875220_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4890132_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4875220_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038227_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4875860_0 | SOURCEANDSINK | F1 4 (3)
Port_4875862_2 | SOURCEANDSINK | F1 4 (3)
Port_4875860_1 | SOURCEANDSINK | F1 4 (3)
Port_4875866_1 | SOURCEANDSINK | F1 4 (3)
Port_4875862_1 | SOURCEANDSINK | F1 4 (3)
Port_4875866_2 | SOURCEANDSINK | F1 4 (3)
Port_4875868_0 | SOURCEANDSINK | F1 4 (3)
Port_4875868_1 | SOURCEANDSINK | F1 4 (3)
Port_4875872_1 | SOURCEANDSINK | F1 4 (3)
Port_4875870_0 | SOURCEANDSINK | F1 9
Port_4875870_1 | SOURCEANDSINK | F1 9
Port_4876022_1 | SOURCEANDSINK | F1 9
Port_4875872_2 | SOURCEANDSINK | F1 4 (3)
Port_4875943_0 | SOURCEANDSINK | F1 9
Port_4875979_2 | SOURCEANDSINK | F1 9
Port_4875943_1 | SOURCEANDSINK | F1 9
Port_4876028_2 | SOURCEANDSINK | F1 9
Port_4875963_1 | SOURCEANDSINK | F1 9
Port_5391780_0 | SOURCEANDSINK | F1 9
Port_4875963_2 | SOURCEANDSINK | F1 9
Port_4875964_1 | SOURCEANDSINK | F1 9
Port_4875963_3 | SOURCEANDSINK | F1 9
Port_4875979_1 | SOURCEANDSINK | F1 9
Port_4875964_0 | SOURCEANDSINK | F1 9
Port_4876022_2 | SOURCEANDSINK | F1 9
Port_4876028_1 | SOURCEANDSINK | F1 9
InPort_4876131_0 | SINK | F1 9
OutPort_5421956_1 | SOURCE | F1 9
InPort_5095960_2 | SINK | F1 9
OutPort_4876131_1 | SOURCE | F1 9
InPort_5412437_2 | SINK | F1 9
OutPort_4876253_0 | SOURCE | F1 9
InPort_5412445_2 | SINK | F1 9
OutPort_4876253_1 | SOURCE | F1 9
InPort_5392839_2 | SINK | F1 9
OutPort_4879007_0 | SOURCE | F1 9
InPort_4879007_1 | SINK | F1 9
OutPort_5287692_1 | SOURCE | F1 9
InPort_4893967_1 | SINK | F1 9
OutPort_4879710_1 | SOURCE | F1 9
InPort_4896521_1 | SINK | F1 9
OutPort_4880024_1 | SOURCE | F1 9
Port_4880161_1 | SOURCEANDSINK | F1 9
Port_4880162_1 | SOURCEANDSINK | F1 9
InPort_4883590_0 | SINK | F1 palubėje 12
OutPort_5357967_2 | SOURCE | F1 palubėje 12
InPort_4883628_2 | SINK | F1 palubėje 12
OutPort_4883590_1 | SOURCE | F1 palubėje 12
InPort_4883620_0 | SINK | F1 palubėje 12
OutPort_4883628_1 | SOURCE | F1 palubėje 12
InPort_4884434_2 | SINK | F1 palubėje 12
OutPort_4883620_1 | SOURCE | F1 palubėje 12
InPort_4883634_0 | SINK | F1 palubėje 12
OutPort_4884434_1 | SOURCE | F1 palubėje 12
InPort_4885754_1 | SINK | F1 palubėje 12
OutPort_4883634_1 | SOURCE | F1 palubėje 12
InPort_4885221_0 | SINK | F1 palubėje 12
OutPort_4885235_3 | SOURCE | F1 palubėje 12
InPort_5422903_1 | SINK | F1 palubėje 12
OutPort_4885221_1 | SOURCE | F1 palubėje 12
InPort_4885235_1 | SINK | F1 palubėje 12
OutPort_4885724_0 | SOURCE | F1 palubėje 12
InPort_4885235_2 | SINK | F1 palubėje 12
OutPort_5357725_1 | SOURCE | F1 palubėje 12
InPort_4885724_1 | SINK | F1 palubėje 12
OutPort_4885754_2 | SOURCE | F1 palubėje 12
Port_4888357_0 | SOURCEANDSINK | F1 9
Port_5423009_1 | SOURCEANDSINK | F1 9
InPort_5042181_2 | SINK | F1 palubėje 5
OutPort_4888628_0 | SOURCE | F1 palubėje 5
InPort_4888849_2 | SINK | F1 4 (1) (2)
OutPort_4888628_1 | SOURCE | F1 4 (1) (2)
InPort_5287695_0 | SINK | F1 9
OutPort_4888841_1 | SOURCE | F1 9
InPort_4888841_2 | SINK | F1 9
OutPort_5042182_0 | SOURCE | F1 9
InPort_5211644_0 | SINK | F1 4 (1) (2)
OutPort_4888849_1 | SOURCE | F1 4 (1) (2)
InPort_5041494_0 | SINK | F1 palubėje 5
OutPort_4889244_2 | SOURCE | F1 palubėje 5
InPort_4889890_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4889586_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5392839_1 | SINK | F1 9
OutPort_4889586_1 | SOURCE | F1 9
Port_4889890_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4889891_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4889890_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4889891_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5288150_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_4890161_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890022_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890132_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890130_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890130_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890161_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890676_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890632_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890693_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890676_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890685_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890683_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890683_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890693_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_4890685_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5095913_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4890685_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292106_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5180214_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_4890686_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_4890686_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5179701_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
OutPort_4890924_1 | SOURCE
OutPort_4890924_2 | SOURCE
Port_4891279_0 | SOURCEANDSINK | F1 9
Port_4891324_3 | SOURCEANDSINK | F1 9
Port_4891279_1 | SOURCEANDSINK | F1 9
Port_4891349_2 | SOURCEANDSINK | F1 9
Port_4891324_1 | SOURCEANDSINK | F1 9
Port_5446282_0 | SOURCEANDSINK | F1 9
Port_4891324_2 | SOURCEANDSINK | F1 9
Port_4891325_1 | SOURCEANDSINK | F1 9
Port_4891833_1 | SOURCEANDSINK | F1 palubėje 3
Port_4891833_2 | SOURCEANDSINK | F1 palubėje 3
Port_4891862_1 | SOURCEANDSINK | F1 palubėje 6
Port_4891862_2 | SOURCEANDSINK | F1 palubėje 6
InPort_4892314_0 | SINK | F1 9
OutPort_4892475_2 | SOURCE | F1 9
InPort_4893761_2 | SINK | F1 9
OutPort_4892314_1 | SOURCE | F1 9
InPort_4892502_0 | SINK | F1 9
OutPort_4893761_1 | SOURCE | F1 9
InPort_4893767_3 | SINK | F1 9
OutPort_4892502_1 | SOURCE | F1 9
Port_4893436_0 | SOURCEANDSINK | F1 9
Port_5455535_2 | SOURCEANDSINK | F1 9
Port_4893436_1 | SOURCEANDSINK | F1 9
Port_5446191_2 | SOURCEANDSINK | F1 9
Port_4893767_1 | SOURCEANDSINK | F1 9
Port_5418210_0 | SOURCEANDSINK | F1 9
Port_4893767_2 | SOURCEANDSINK | F1 9
Port_5455536_0 | SOURCEANDSINK | F1 9
InPort_4894019_3 | SINK | F1 9
OutPort_4893967_0 | SOURCE | F1 9
Port_4894019_1 | SOURCEANDSINK | F1 9
Port_4894020_1 | SOURCEANDSINK | F1 9
Port_4894398_0 | SOURCEANDSINK | F1 2 1
Port_5293466_1 | SOURCEANDSINK | F1 2 1
Port_4894398_1 | SOURCEANDSINK | F1 2 1
Port_4894406_0 | SOURCEANDSINK | F1 2 1
Port_5293468_2 | SOURCEANDSINK | F1 2 1
Port_4894406_1 | SOURCEANDSINK | F1 2 1
Port_4896521_0 | SOURCEANDSINK | F1 9
Port_4896810_3 | SOURCEANDSINK | F1 9
Port_4896631_0 | SOURCEANDSINK | F1 9
Port_4896810_1 | SOURCEANDSINK | F1 9
Port_4896810_2 | SOURCEANDSINK | F1 9
Port_5392585_1 | SOURCEANDSINK | F1 9
Port_4897252_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897358_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897252_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897907_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897481_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897729_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897481_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897907_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897729_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897730_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897729_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057608_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897730_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4898899_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897945_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897947_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897945_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4898891_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897951_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4898891_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4897951_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4898899_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4898899_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461293_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4899322_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057706_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_4899322_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5291174_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_4960425_0 | SINK | F1 palubėje 15
OutPort_4900782_1 | SOURCE | F1 palubėje 15
InPort_5011124_0 | SINK | F1 palubėje 15
OutPort_4901107_1 | SOURCE | F1 palubėje 15
InPort_5011554_3 | SINK | F1 palubėje 15
OutPort_4960425_1 | SOURCE | F1 palubėje 15
InPort_4968293_1 | SINK | F1 palubėje 15
OutPort_4968174_1 | SOURCE | F1 palubėje 15
InPort_5015387_3 | SINK | F1 palubėje 15
OutPort_4968293_0 | SOURCE | F1 palubėje 15
InPort_5010743_1 | SINK | F1 9
OutPort_4968554_1 | SOURCE | F1 9
InPort_5013512_0 | SINK | F1 palubėje 11
OutPort_4982705_1 | SOURCE | F1 palubėje 11
InPort_5010794_0 | SINK | F1 palubėje 20
OutPort_4982761_1 | SOURCE | F1 palubėje 20
InPort_4982766_0 | SINK | F1 palubėje 20
OutPort_4982765_1 | SOURCE | F1 palubėje 20
InPort_5011818_3 | SINK | F1 palubėje 20
OutPort_4982766_1 | SOURCE | F1 palubėje 20
InPort_5014074_0 | SINK | F1 palubėje 11
OutPort_4982768_1 | SOURCE | F1 palubėje 11
InPort_5014043_0 | SINK | F1 palubėje 11
OutPort_4992426_1 | SOURCE | F1 palubėje 11
InPort_5010824_0 | SINK | F1 palubėje 20
OutPort_5009865_1 | SOURCE | F1 palubėje 20
InPort_5011161_1 | SINK | F1 palubėje 15
OutPort_5010360_1 | SOURCE | F1 palubėje 15
InPort_5017830_1 | SINK | F1 9
OutPort_5010743_0 | SOURCE | F1 9
InPort_5011797_3 | SINK | F1 palubėje 20
OutPort_5010794_1 | SOURCE | F1 palubėje 20
InPort_5010985_1 | SINK | F1 palubėje 20
OutPort_5010824_1 | SOURCE | F1 palubėje 20
InPort_5010835_0 | SINK | F1 palubėje 20
OutPort_5010985_2 | SOURCE | F1 palubėje 20
InPort_5011726_2 | SINK | F1 palubėje 20
OutPort_5010835_1 | SOURCE | F1 palubėje 20
InPort_5011141_1 | SINK | F1 palubėje 15
OutPort_5011124_1 | SOURCE | F1 palubėje 15
InPort_5011135_0 | SINK | F1 palubėje 15
OutPort_5011172_1 | SOURCE | F1 palubėje 15
InPort_5011450_1 | SINK | F1 palubėje 15
OutPort_5011135_1 | SOURCE | F1 palubėje 15
InPort_5286940_0 | SINK | F1 palubėje 15
OutPort_5011141_2 | SOURCE | F1 palubėje 15
InPort_5011172_3 | SINK | F1 palubėje 15
OutPort_5011161_0 | SOURCE | F1 palubėje 15
InPort_5011172_2 | SINK | F1 palubėje 15
OutPort_5011173_1 | SOURCE | F1 palubėje 15
InPort_5011173_0 | SINK | F1 palubėje 15
OutPort_5286927_1 | SOURCE | F1 palubėje 15
InPort_5011408_0 | SINK | F1 palubėje 15
OutPort_5011450_2 | SOURCE | F1 palubėje 15
InPort_5011525_1 | SINK | F1 palubėje 15
OutPort_5011408_1 | SOURCE | F1 palubėje 15
InPort_5011555_0 | SINK | F1 palubėje 15
OutPort_5011525_2 | SOURCE | F1 palubėje 15
InPort_5287014_0 | SINK | F1 palubėje 15
OutPort_5011554_1 | SOURCE | F1 palubėje 15
InPort_5011554_2 | SINK | F1 palubėje 15
OutPort_5017636_2 | SOURCE | F1 palubėje 15
InPort_5017636_1 | SINK | F1 palubėje 15
OutPort_5011555_1 | SOURCE | F1 palubėje 15
InPort_5011718_0 | SINK | F1 palubėje 20
OutPort_5011726_1 | SOURCE | F1 palubėje 20
InPort_5011740_2 | SINK | F1 palubėje 20
OutPort_5011718_1 | SOURCE | F1 palubėje 20
InPort_5011798_0 | SINK | F1 palubėje 20
OutPort_5011740_1 | SOURCE | F1 palubėje 20
InPort_5287112_0 | SINK | F1 palubėje 20
OutPort_5011797_1 | SOURCE | F1 palubėje 20
InPort_5011797_2 | SINK | F1 palubėje 20
OutPort_5011798_1 | SOURCE | F1 palubėje 20
OutPort_5011818_1 | SOURCE | F1 palubėje 20
InPort_5011818_2 | SINK | F1 palubėje 20
OutPort_5011819_1 | SOURCE | F1 palubėje 20
InPort_5011819_0 | SINK | F1 palubėje 20
OutPort_5287135_1 | SOURCE | F1 palubėje 20
Port_5012322_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5012373_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5012322_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057861_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5012377_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057705_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5012377_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057861_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5430281_1 | SINK | F1 palubėje 11
OutPort_5013512_1 | SOURCE | F1 palubėje 11
InPort_5013537_0 | SINK | F1 palubėje 11
OutPort_5430281_2 | SOURCE | F1 palubėje 11
InPort_5430289_2 | SINK | F1 palubėje 11
OutPort_5013537_1 | SOURCE | F1 palubėje 11
InPort_5430931_1 | SINK | F1 palubėje 11
OutPort_5014043_1 | SOURCE | F1 palubėje 11
InPort_5014054_0 | SINK | F1 palubėje 11
OutPort_5430931_2 | SOURCE | F1 palubėje 11
InPort_5431848_1 | SINK | F1 palubėje 11
OutPort_5014054_1 | SOURCE | F1 palubėje 11
InPort_5428574_3 | SINK | F1 palubėje 11
OutPort_5014074_1 | SOURCE | F1 palubėje 11
InPort_5015385_0 | SINK | F1 palubėje 15
OutPort_5015387_2 | SOURCE | F1 palubėje 15
InPort_5015481_3 | SINK | F1 palubėje 15
OutPort_5015385_1 | SOURCE | F1 palubėje 15
InPort_5435179_0 | SINK | F1 palubėje 15
OutPort_5015481_1 | SOURCE | F1 palubėje 15
InPort_5015481_2 | SINK | F1 palubėje 15
OutPort_5015482_1 | SOURCE | F1 palubėje 15
InPort_5015482_0 | SINK | F1 palubėje 15
OutPort_5287051_1 | SOURCE | F1 palubėje 15
InPort_5016325_0 | SINK | F1 9
OutPort_5017830_2 | SOURCE | F1 9
InPort_5017862_3 | SINK | F1 9
OutPort_5016325_1 | SOURCE | F1 9
Port_5017862_1 | SOURCEANDSINK | F1 9
Port_5019246_0 | SOURCEANDSINK | F1 9
InPort_5017863_0 | SINK | F1 palubėje 10
OutPort_5017862_2 | SOURCE | F1 palubėje 10
InPort_5287071_1 | SINK | F1 palubėje 10
OutPort_5017863_1 | SOURCE | F1 palubėje 10
Port_5019246_1 | SOURCEANDSINK | F1 9
Port_5433731_2 | SOURCEANDSINK | F1 9
Port_5020663_0 | SOURCEANDSINK | F1 9
Port_5031705_2 | SOURCEANDSINK | F1 9
Port_5020663_1 | SOURCEANDSINK | F1 9
Port_5435868_1 | SOURCEANDSINK | F1 9
Port_5023807_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5023828_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5023807_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5023822_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5023828_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5023822_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5024589_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5024571_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5024585_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5024571_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5024589_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5025153_0 | SOURCEANDSINK | F1 9
Port_5433731_1 | SOURCEANDSINK | F1 9
Port_5025153_1 | SOURCEANDSINK | F1 9
Port_5433737_2 | SOURCEANDSINK | F1 9
Port_5031622_0 | SOURCEANDSINK | F1 9
Port_5286701_1 | SOURCEANDSINK | F1 9
Port_5031622_1 | SOURCEANDSINK | F1 9
Port_5031705_1 | SOURCEANDSINK | F1 9
Port_5033966_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5438895_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5033966_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444160_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5036041_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5104004_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5036041_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5421398_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038259_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415720_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038259_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5413133_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5038382_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416086_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5040145_0 | SOURCEANDSINK | L1 2
Port_5059939_2 | SOURCEANDSINK | L1 2
Port_5040145_1 | SOURCEANDSINK | L1 2
Port_5304519_1 | SOURCEANDSINK | L1 2
Port_5040351_0 | SOURCEANDSINK | L1 1
Port_5040861_1 | SOURCEANDSINK | L1 1
Port_5040351_1 | SOURCEANDSINK | L1 1
Port_5040865_1 | SOURCEANDSINK | L1 1
Port_5040534_1 | SOURCEANDSINK | L1 1
Port_5041040_1 | SOURCEANDSINK | L1 1
Port_5040615_0 | SOURCEANDSINK | L1 1
Port_5041040_2 | SOURCEANDSINK | L1 1
Port_5040615_1 | SOURCEANDSINK | L1 1
Port_5041130_2 | SOURCEANDSINK | L1 1
Port_5040833_1 | SOURCEANDSINK | L1 1
Port_5041135_0 | SOURCEANDSINK | L1 1
Port_5041075_0 | SOURCEANDSINK | L1 1
Port_5041130_1 | SOURCEANDSINK | L1 1
Port_5041075_1 | SOURCEANDSINK | L1 1
Port_5041134_3 | SOURCEANDSINK | L1 1
Port_5041134_1 | SOURCEANDSINK | L1 1
Port_5456256_0 | SOURCEANDSINK | L1 1
Port_5041134_2 | SOURCEANDSINK | L1 1
Port_5303552_1 | SOURCEANDSINK | L1 1
Port_5041135_1 | SOURCEANDSINK | L1 1
Port_5303552_2 | SOURCEANDSINK | L1 1
Port_5041176_0 | SOURCEANDSINK | L1 1
Port_5175933_2 | SOURCEANDSINK | L1 1
Port_5041176_1 | SOURCEANDSINK | L1 1
Port_5453205_2 | SOURCEANDSINK | L1 1
Port_5041218_0 | SOURCEANDSINK | L1 1
Port_5452781_3 | SOURCEANDSINK | L1 1
Port_5041218_1 | SOURCEANDSINK | L1 1
Port_5453205_1 | SOURCEANDSINK | L1 1
InPort_5042173_1 | SINK | F1 palubėje 5
OutPort_5041494_1 | SOURCE | F1 palubėje 5
InPort_5041550_0 | SINK | F1 palubėje 5
OutPort_5042173_2 | SOURCE | F1 palubėje 5
InPort_5042181_3 | SINK | F1 palubėje 5
OutPort_5041550_1 | SOURCE | F1 palubėje 5
InPort_5042181_1 | SINK | F1 palubėje 5
OutPort_5042182_1 | SOURCE | F1 palubėje 5
InPort_5205497_0 | SINK | L1 1
OutPort_5042442_1 | SOURCE | L1 1
InPort_5042442_2 | SINK | L1 1
OutPort_5042473_0 | SOURCE | L1 1
InPort_5042473_1 | SINK | L1 1
OutPort_5363024_1 | SOURCE | L1 1
Port_5042510_0 | SOURCEANDSINK | L1 1
Port_5042519_2 | SOURCEANDSINK | L1 1
Port_5042510_1 | SOURCEANDSINK | L1 1
Port_5042527_1 | SOURCEANDSINK | L1 1
Port_5042519_1 | SOURCEANDSINK | L1 1
Port_5205492_1 | SOURCEANDSINK | L1 1
Port_5042521_0 | SOURCEANDSINK | L1 1
Port_5042527_2 | SOURCEANDSINK | L1 1
Port_5042521_1 | SOURCEANDSINK | L1 1
Port_5446671_3 | SOURCEANDSINK | L1 1
Port_5043236_0 | SOURCEANDSINK | L1 1
Port_5180364_1 | SOURCEANDSINK | L1 1
Port_5043236_1 | SOURCEANDSINK | L1 1
Port_5184699_3 | SOURCEANDSINK | L1 1
InPort_5043918_0 | SINK | L1 1
OutPort_5447855_2 | SOURCE | L1 1
InPort_5448056_3 | SINK | L1 1
OutPort_5043918_1 | SOURCE | L1 1
InPort_5044221_0 | SINK | L1 1
OutPort_5044237_2 | SOURCE | L1 1
InPort_5044425_1 | SINK | L1 1
OutPort_5044221_1 | SOURCE | L1 1
InPort_5279773_0 | SINK | L1 1
OutPort_5044425_2 | SOURCE | L1 1
InPort_5044813_0 | SINK | L1 1
OutPort_5279768_3 | SOURCE | L1 1
InPort_5045219_1 | SINK | L1 1
OutPort_5044813_1 | SOURCE | L1 1
InPort_5182676_0 | SINK | L1 1
OutPort_5045219_2 | SOURCE | L1 1
InPort_5045368_0 | SINK | L1 1
OutPort_5045367_1 | SOURCE | L1 1
InPort_5045405_1 | SINK | L1 1
OutPort_5045368_1 | SOURCE | L1 1
InPort_5045397_0 | SINK | L1 1
OutPort_5045405_2 | SOURCE | L1 1
InPort_5045474_1 | SINK | L1 1
OutPort_5045397_1 | SOURCE | L1 1
InPort_5045472_1 | SINK | L1 1
OutPort_5045449_0 | SOURCE | L1 1
InPort_5045449_1 | SINK | L1 1
OutPort_5045474_2 | SOURCE | L1 1
InPort_5045498_2 | SINK | L1 1
OutPort_5045466_0 | SOURCE | L1 1
InPort_5045466_1 | SINK | L1 1
OutPort_5045472_2 | SOURCE | L1 1
InPort_5457471_0 | SINK | L1 1
OutPort_5045498_1 | SOURCE | L1 1
InPort_5045661_0 | SINK | L1 1
OutPort_5185061_1 | SOURCE | L1 1
InPort_5185166_1 | SINK | L1 1
OutPort_5045661_1 | SOURCE | L1 1
InPort_5045669_0 | SINK | L1 1
OutPort_5185166_2 | SOURCE | L1 1
InPort_5185174_2 | SINK | L1 1
OutPort_5045669_1 | SOURCE | L1 1
InPort_5046247_0 | SINK | L1 1
OutPort_5046255_2 | SOURCE | L1 1
InPort_5046271_1 | SINK | L1 1
OutPort_5046247_1 | SOURCE | L1 1
InPort_5281029_0 | SINK | L1 1
OutPort_5046271_2 | SOURCE | L1 1
InPort_5046366_0 | SINK | L1 1
OutPort_5281026_3 | SOURCE | L1 1
InPort_5046424_1 | SINK | L1 1
OutPort_5046366_1 | SOURCE | L1 1
InPort_5046416_0 | SINK | L1 1
OutPort_5046424_2 | SOURCE | L1 1
InPort_5047188_2 | SINK | L1 1
OutPort_5046416_1 | SOURCE | L1 1
InPort_5280795_3 | SINK | L1 1
OutPort_5046428_0 | SOURCE | L1 1
InPort_5046428_1 | SINK | L1 1
OutPort_5047268_2 | SOURCE | L1 1
InPort_5046815_0 | SINK | L1 1
OutPort_5047231_1 | SOURCE | L1 1
InPort_5185965_1 | SINK | L1 1
OutPort_5046815_1 | SOURCE | L1 1
InPort_5047007_0 | SINK | L1 1
OutPort_5047188_1 | SOURCE | L1 1
InPort_5047268_1 | SINK | L1 1
OutPort_5047007_1 | SOURCE | L1 1
InPort_5047231_2 | SINK | L1 1
OutPort_5280798_0 | SOURCE | L1 1
InPort_5047292_0 | SINK | L1 1
OutPort_5185965_2 | SOURCE | L1 1
InPort_5185971_3 | SINK | L1 1
OutPort_5047292_1 | SOURCE | L1 1
Port_5047415_0 | SOURCEANDSINK | L1 2
Port_5058121_2 | SOURCEANDSINK | L1 2
Port_5047415_1 | SOURCEANDSINK | L1 2
Port_5058140_1 | SOURCEANDSINK | L1 2
Port_5047513_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5047532_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5047513_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5054002_1 | SINK | F1 3
OutPort_5053526_1 | SOURCE | F1 3
OutPort_5053526_2 | SOURCE | F1 3
InPort_5053886_0 | SINK | F1 3
OutPort_5054002_2 | SOURCE | F1 3
InPort_5054305_3 | SINK | F1 3
OutPort_5053886_1 | SOURCE | F1 3
InPort_5054305_1 | SINK | F1 3
OutPort_5054006_0 | SOURCE | F1 3
InPort_5054006_1 | SINK | F1 3
OutPort_5325489_1 | SOURCE | F1 3
OutPort_5054101_0 | SOURCE | F1 3
InPort_5054101_1 | SINK | F1 3
OutPort_5054525_1 | SOURCE | F1 3
InPort_5054525_2 | SINK | F1 3
OutPort_5054187_0 | SOURCE | F1 3
InPort_5054187_1 | SINK | F1 3
OutPort_5325453_1 | SOURCE | F1 3
InPort_5325453_2 | SINK | F1 3
OutPort_5054305_2 | SOURCE | F1 3
InPort_5056147_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5461954_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
OutPort_5056147_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_5056491_1 | SOURCEANDSINK | F1 palubėje 7
Port_5056491_2 | SOURCEANDSINK | F1 palubėje 7
Port_5057608_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057705_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057705_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5057706_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5058140_2 | SOURCEANDSINK | L1 2
Port_5304443_0 | SOURCEANDSINK | L1 2
Port_5059937_0 | SOURCEANDSINK | L1 2
Port_5281634_3 | SOURCEANDSINK | L1 2
Port_5059937_1 | SOURCEANDSINK | L1 2
Port_5059939_1 | SOURCEANDSINK | L1 2
Port_5060814_0 | SOURCEANDSINK | L1 2
Port_5063266_2 | SOURCEANDSINK | L1 2
Port_5060814_1 | SOURCEANDSINK | L1 2
Port_5063790_2 | SOURCEANDSINK | L1 2
InPort_5061526_0 | SINK | L1 1
OutPort_5061898_2 | SOURCE | L1 1
InPort_5061921_1 | SINK | L1 1
OutPort_5061526_1 | SOURCE | L1 1
InPort_5061909_0 | SINK | L1 1
OutPort_5061921_2 | SOURCE | L1 1
InPort_5062031_2 | SINK | L1 1
OutPort_5061909_1 | SOURCE | L1 1
InPort_5062024_2 | SINK | L1 1
OutPort_5062003_0 | SOURCE | L1 1
InPort_5062003_1 | SINK | L1 1
OutPort_5062031_1 | SOURCE | L1 1
InPort_5062019_2 | SINK | L1 1
OutPort_5062020_1 | SOURCE | L1 1
InPort_5062019_3 | SINK | L1 1
OutPort_5062024_1 | SOURCE | L1 1
Port_5063790_1 | SOURCEANDSINK | L1 2
Port_5064251_0 | SOURCEANDSINK | L1 2
Port_5064236_0 | SOURCEANDSINK | L1 2
Port_5064250_1 | SOURCEANDSINK | L1 2
Port_5064236_1 | SOURCEANDSINK | L1 2
Port_5064524_1 | SOURCEANDSINK | L1 2
Port_5064250_2 | SOURCEANDSINK | L1 2
Port_5064251_1 | SOURCEANDSINK | L1 2
Port_5064516_0 | SOURCEANDSINK | L1 2
Port_5065193_2 | SOURCEANDSINK | L1 2
Port_5064516_1 | SOURCEANDSINK | L1 2
Port_5064613_1 | SOURCEANDSINK | L1 2
Port_5064524_2 | SOURCEANDSINK | L1 2
Port_5282060_0 | SOURCEANDSINK | L1 2
Port_5064613_2 | SOURCEANDSINK | L1 2
Port_5064699_0 | SOURCEANDSINK | L1 2
Port_5064699_1 | SOURCEANDSINK | L1 2
Port_5439309_3 | SOURCEANDSINK | L1 2
Port_5064720_0 | SOURCEANDSINK | L1 2
Port_5439309_1 | SOURCEANDSINK | L1 2
Port_5064720_1 | SOURCEANDSINK | L1 2
Port_5426505_3 | SOURCEANDSINK | L1 2
Port_5065191_0 | SOURCEANDSINK | L1 2
Port_5282057_3 | SOURCEANDSINK | L1 2
Port_5065191_1 | SOURCEANDSINK | L1 2
Port_5065193_1 | SOURCEANDSINK | L1 2
Port_5072740_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360248_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5072740_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5073361_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5242842_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5073361_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415291_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5073361_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5074069_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360170_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5074069_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5095051_0 | SINK | F1 palubėje 12
OutPort_5095065_2 | SOURCE | F1 palubėje 12
InPort_5095177_1 | SINK | F1 palubėje 12
OutPort_5095051_1 | SOURCE | F1 palubėje 12
InPort_5095101_0 | SINK | F1 palubėje 12
OutPort_5095177_2 | SOURCE | F1 palubėje 12
InPort_5095327_0 | SINK | F1 9
OutPort_5095960_1 | SOURCE | F1 9
InPort_5427102_3 | SINK | F1 9
OutPort_5095327_1 | SOURCE | F1 9
InPort_5104002_0 | SINK | F1 palubėje 17
OutPort_5104004_3 | SOURCE | F1 palubėje 17
InPort_5104002_1 | SINK | F1 palubėje 17
OutPort_5104054_2 | SOURCE | F1 palubėje 17
Port_5104004_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5104005_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5104005_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5414130_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5104036_1 | SINK | F1 3 (4)
OutPort_5104054_1 | SOURCE | F1 3 (4)
Port_5174602_0 | SOURCEANDSINK | L1 2
Port_5424666_1 | SOURCEANDSINK | L1 2
Port_5174602_1 | SOURCEANDSINK | L1 2
Port_5385812_1 | SOURCEANDSINK | L1 2
Port_5175195_0 | SOURCEANDSINK | L1 2
Port_5385819_1 | SOURCEANDSINK | L1 2
Port_5175195_1 | SOURCEANDSINK | L1 2
Port_5424698_1 | SOURCEANDSINK | L1 2
Port_5177928_0 | SOURCEANDSINK | L1 1
Port_5446671_1 | SOURCEANDSINK | L1 1
Port_5177928_1 | SOURCEANDSINK | L1 1
Port_5180464_1 | SOURCEANDSINK | L1 1
Port_5179162_1 | SOURCEANDSINK | F1 palubėje 8
Port_5179162_2 | SOURCEANDSINK | F1 palubėje 8
InPort_5180214_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5180206_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5180206_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5180267_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5292098_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5180214_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_5180364_2 | SOURCEANDSINK | L1 1
