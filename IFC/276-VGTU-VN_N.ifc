Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcFlowSegment: Pipe Types:BERSnl_52_PI_UN_Wavin_PVCGravitySystem, Brown, RAL8023 - SN4 Socket End - OD 110-500, Standard gasket (163)
Pset_DistributionFlowElementCommon - Reference: BERSnl_52_PI_UN_Wavin_PVCGravitySystem, Brown, RAL8023 - SN4 Socket End - OD 110-500, Standard gasket; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:BERSnl_52_PI_UN_Wavin_PVCGravitySystem, Brown, RAL8023 - SN4 Socket End - OD 110-500, Standard gasket:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4662172 | Stogo ilaju aukštas | 890.85 | -2803.72 | L1 1
4710643 | 0. Cokolinis Vandentiekis | 60.4973 | -2560.85 | F1 2 (1) (1) (1) (1) (1)
4712615 | 0. Cokolinis Vandentiekis | 804.967 | -2331.18 | F1 2 (1) (1) (1) (1) (1)
4712829 | 0. Cokolinis Vandentiekis | 224.855 | -2169.23 | F1 2 (1) (1) (1) (1) (1)
4713935 | 0. Cokolinis Vandentiekis | 123.062 | -2075.57 | F1 2 (1) (1) (1) (1) (1)
4714038 | 0. Cokolinis Vandentiekis | 142.753 | -2095.27 | F1 2 (1) (1) (1) (1) (1)
4714047 | 0. Cokolinis Vandentiekis | 865.509 | -2314.31 | F1 2 (1) (1) (1) (1) (1)
4753681 | 0. Cokolinis Vandentiekis | 111.456 | -2136.5 | F1 2 (1) (1) (1) (1) (1)
4754141 | 0. Cokolinis Vandentiekis | 103.834 | -2125.7 | F1 2 (1) (1) (1) (1) (1)
4778496 | 0. Cokolinis Vandentiekis | 1250.55 | -2314.31 | F1 2 (1) (1) (1) (1) (1)
4779701 | 0. Cokolinis Vandentiekis | 106.797 | -2545.39 | F1 2 (1) (1) (1) (1) (1)
4782303 | 0. Cokolinis Vandentiekis | 109.354 | -2075.24 | F1 2 (1) (1) (1) (1) (1)
4782968 | 0. Cokolinis Vandentiekis | 189.992 | -2155.89 | F1 2 (1) (1) (1) (1) (1)
4784724 | 0. Cokolinis Vandentiekis | 724.119 | -2404.23 | F1 2 (1) (1) (1) (1) (1)
4870438 | 0. Cokolinis Vandentiekis | 256.243 | -2379.75 | F1 2 (1) (1) (1) (1) (1)
4870592 | 0. Cokolinis Vandentiekis | 413.374 | -2543.42 | F1 2 (1) (1) (1) (1) (1)
4873654 | 1. Pirmas | 173.046 | -2578.62 | F1 2 (1) (1) (1) (1) (1)
4874158 | 0. Cokolinis Vandentiekis | 1228.33 | -2321.82 | F1 2 (1) (1) (1) (1) (1)
4890686 | 0. Cokolinis Vandentiekis | 621.101 | -2358.61 | F1 2 (1) (1) (1) (1) (1)
4892314 | 1. Pirmas | 1207.61 | -2473.76 | F1 9
4892502 | 0. Cokolinis Vandentiekis | 2641.53 | -2533.04 | F1 9
4893436 | 0. Cokolinis Vandentiekis | 192.039 | -2530.86 | F1 9
4897252 | 0. Cokolinis Vandentiekis | 390.179 | -2513.66 | F1 2 (1) (1) (1) (1) (1)
4897481 | 0. Cokolinis Vandentiekis | 889.084 | -2695.9 | F1 2 (1) (1) (1) (1) (1)
4897730 | 0. Cokolinis Vandentiekis | 1038.19 | -2726.41 | F1 2 (1) (1) (1) (1) (1)
4897945 | 0. Cokolinis Vandentiekis | 335.393 | -2458.88 | F1 2 (1) (1) (1) (1) (1)
4897951 | 0. Cokolinis Vandentiekis | 1742.75 | -2721.5 | F1 2 (1) (1) (1) (1) (1)
5012322 | 0. Cokolinis Vandentiekis | 247.29 | -2370.77 | F1 2 (1) (1) (1) (1) (1)
5012377 | 0. Cokolinis Vandentiekis | 6328.8 | -2661.36 | F1 2 (1) (1) (1) (1) (1)
5013512 | 1. Pirmas | 139.377 | 1643.94 | F1 palubėje 11
5020663 | 0. Cokolinis Vandentiekis | 336.57 | -2327.16 | F1 9
5033966 | 0. Cokolinis Vandentiekis | 1048.05 | -2822.21 | F1 2 (1) (1) (1) (1) (1)
5036041 | 0. Cokolinis Vandentiekis | 1128.45 | -2803.63 | F1 2 (1) (1) (1) (1) (1)
5038382 | 0. Cokolinis Vandentiekis | 1169.1 | -2439.51 | F1 2 (1) (1) (1) (1) (1)
5041176 | Stogo ilaju aukštas | 218.426 | -3115.46 | L1 1
5041218 | 0. Cokolinis Vandentiekis | 100.635 | -3119.7 | L1 1
5042510 | 1. Pirmas | 910.889 | -2815.21 | L1 1
5042521 | 1. Pirmas | 1710.45 | -3069.83 | L1 1
5043236 | 0. Cokolinis Vandentiekis | 3562.11 | -3212.02 | L1 1
5043918 | 1. Pirmas | 197.683 | -2679.14 | L1 1
5045661 | Pirmo aukšto antresolė | 151.504 | -2148.45 | L1 1
5045669 | Pirmo aukšto antresolė | 462.875 | -2378.13 | L1 1
5046815 | Pirmo aukšto antresolė | 482.446 | -2472.94 | L1 1
5047292 | Pirmo aukšto antresolė | 587.965 | -2896.16 | L1 1
5047513 | 0. Cokolinis Vandentiekis | 262.96 | -2386.44 | F1 2 (1) (1) (1) (1) (1)
5056147 | 1. Pirmas | 1193.83 | -2624.63 | F1 2 (1) (1) (1) (1) (1)
5057608 | 0. Cokolinis Vandentiekis | 1586.04 | -2701.89 | F1 2 (1) (1) (1) (1) (1)
5057706 | 0. Cokolinis Vandentiekis | 2127.4 | -2665.76 | F1 2 (1) (1) (1) (1) (1)
5064516 | Pirmo aukšto antresolė | 574.738 | -2515.7 | L1 2
5064699 | 0. Cokolinis Vandentiekis | 2968.28 | -2795.48 | L1 2
5064720 | 0. Cokolinis Vandentiekis | 1014.79 | -2816.19 | L1 2
5072740 | 0. Cokolinis Vandentiekis | 682.076 | -2523.54 | F1 2 (1) (1) (1) (1) (1)
5074069 | 0. Cokolinis Vandentiekis | 3891.68 | -2894.04 | F1 2 (1) (1) (1) (1) (1)
5095327 | 0. Cokolinis Vandentiekis | 2125.45 | -2620.18 | F1 9
5095913 | 0. Cokolinis Vandentiekis | 1104.06 | -2411.72 | F1 2 (1) (1) (1) (1) (1)
5104005 | 0. Cokolinis Vandentiekis | 117.597 | -2814.6 | F1 2 (1) (1) (1) (1) (1)
5174602 | 0. Cokolinis Vandentiekis | 205.653 | -1373.41 | L1 2
5175195 | 0. Cokolinis Vandentiekis | 168.412 | -1373.41 | L1 2
5177928 | 0. Cokolinis Vandentiekis | 1703.14 | -3107.59 | L1 1
5180206 | 0. Cokolinis Vandentiekis | 101.782 | -2124.79 | F1 2 (1) (1) (1) (1) (1)
5180424 | 0. Cokolinis Vandentiekis | 178.935 | -3162.35 | L1 1
5181216 | 1. Pirmas | 619.686 | -2560.34 | L1 1
5181866 | 1. Pirmas | 166.07 | -2790.39 | L1 1
5182264 | 0. Cokolinis Vandentiekis | 5612.52 | -2922.88 | L1 1
5182676 | Pirmo aukšto antresolė | 153.988 | -2091.69 | L1 1
5182773 | Pirmo aukšto antresolė | 100.395 | -2305.75 | L1 1
5182803 | Pirmo aukšto antresolė | 266.433 | -2625.27 | L1 1
5182838 | 0. Cokolinis Vandentiekis | 498.265 | -2864.19 | L1 1
5183029 | 0. Cokolinis Vandentiekis | 164.264 | -2868.32 | F1 2 (1) (1) (1) (1) (1)
5183781 | 0. Cokolinis Vandentiekis | 5621.99 | -2799.54 | L1 1
5184562 | 0. Cokolinis Vandentiekis | 2630.76 | -3250.23 | L1 1
5185061 | Pirmo aukšto antresolė | 15.0999 | -1996.97 | L1 1
5185101 | Pirmo aukšto antresolė | 64.2653 | -2559.26 | L1 1
5185104 | 0. Cokolinis Vandentiekis | 3838.33 | -3032.09 | L1 1
5185972 | 0. Cokolinis Vandentiekis | 8903.36 | -3154.41 | L1 1
5211049 | 1. Pirmas | 519.644 | -2454.77 | L1 1
5242842 | 0. Cokolinis Vandentiekis | 1292.45 | -2935.07 | F1 2 (1) (1) (1) (1) (1)
5290717 | 0. Cokolinis Vandentiekis | 606.455 | -2947.77 | F1 2 (1) (1) (1) (1) (1)
5290754 | 0. Cokolinis Vandentiekis | 2309.38 | -3043.66 | F1 9
5291160 | 0. Cokolinis Vandentiekis | 398.989 | -2440.99 | F1 2 (1) (1) (1) (1) (1)
5291174 | 0. Cokolinis Vandentiekis | 667.902 | -2618.8 | F1 2 (1) (1) (1) (1) (1)
5292052 | 0. Cokolinis Vandentiekis | 110.002 | -2143.89 | F1 2 (1) (1) (1) (1) (1)
5292098 | 0. Cokolinis Vandentiekis | 929.682 | -2381.73 | F1 2 (1) (1) (1) (1) (1)
5292106 | 0. Cokolinis Vandentiekis | 50.7195 | -2387.19 | F1 2 (1) (1) (1) (1) (1)
5292238 | 0. Cokolinis Vandentiekis | 580.731 | -2622.73 | F1 2 (1) (1) (1) (1) (1)
5292412 | 0. Cokolinis Vandentiekis | 2535.98 | -2628.02 | F1 9
5304694 | 0. Cokolinis Vandentiekis | 453.133 | -2502.66 | L1 2
5305826 | 0. Cokolinis Vandentiekis | 2738.3 | -2830.3 | L1 1
5305897 | 0. Cokolinis Vandentiekis | 515.726 | -3220.78 | L1 1
5306265 | 0. Cokolinis Vandentiekis | 831.207 | -2873.21 | L1 1
5306279 | 0. Cokolinis Vandentiekis | 730.953 | -3164.29 | L1 1
5307108 | 0. Cokolinis Vandentiekis | 8651.71 | -3212.48 | L1 1
5334331 | 0. Cokolinis Vandentiekis | 181.511 | -2336.52 | L1 3
5334344 | 0. Cokolinis Vandentiekis | 407.774 | -2609.53 | L1 3
5334447 | 0. Cokolinis Vandentiekis | 73.5538 | -2232.44 | L1 4
5335055 | 0. Cokolinis Vandentiekis | 1560.16 | -2484.06 | L1 4
5335281 | 0. Cokolinis Vandentiekis | 1867.77 | -2601.38 | L1 3
5343871 | 0. Cokolinis Vandentiekis | 171.073 | -2121.07 | F1 2 (1) (1) (1) (1) (1)
5343902 | 0. Cokolinis Vandentiekis | 1265.35 | -2367.62 | F1 2 (1) (1) (1) (1) (1)
5345254 | 0. Cokolinis Vandentiekis | 68.3897 | -2377.71 | F1 2 (1) (1) (1) (1) (1)
5345344 | 0. Cokolinis Vandentiekis | 750.602 | -2371.93 | F1 2 (1) (1) (1) (1) (1)
5360080 | 0. Cokolinis Vandentiekis | 2177.93 | -2851.78 | F1 2 (1) (1) (1) (1) (1)
5360171 | 0. Cokolinis Vandentiekis | 214.796 | -2851.51 | F1 2 (1) (1) (1) (1) (1)
5384965 | 0. Cokolinis Vandentiekis | 153.554 | -2308.55 | L1 3
5385055 | 0. Cokolinis Vandentiekis | 1664.65 | -2562.26 | L1 3
5385576 | 0. Cokolinis Vandentiekis | 371.803 | -2563.9 | L1 3
5385621 | 0. Cokolinis Vandentiekis | 133.954 | -2559.61 | L1 3
5388651 | 0. Cokolinis Vandentiekis | 26.9765 | -2181.98 | L1 6
5409991 | 1. Pirmas | 1382.97 | -2631.46 | F1 9
5412527 | 0. Cokolinis Vandentiekis | 2180 | -2701.97 | F1 9
5413133 | 0. Cokolinis Vandentiekis | 649.199 | -2817.69 | F1 2 (1) (1) (1) (1) (1)
5413542 | 0. Cokolinis Vandentiekis | 63.6696 | -2814.71 | F1 2 (1) (1) (1) (1) (1)
5415720 | 0. Cokolinis Vandentiekis | 1108.28 | -2844.07 | F1 2 (1) (1) (1) (1) (1)
5416060 | 0. Cokolinis Vandentiekis | 48.6291 | -2604.99 | F1 2 (1) (1) (1) (1) (1)
5416063 | 0. Cokolinis Vandentiekis | 667.713 | -2861.84 | F1 2 (1) (1) (1) (1) (1)
5418210 | 0. Cokolinis Vandentiekis | 4688.01 | -2635.61 | F1 9
5419129 | 0. Cokolinis Vandentiekis | 4783.43 | -2809.86 | F1 9
5419250 | 0. Cokolinis Vandentiekis | 2065.55 | -2681.33 | F1 9
5423746 | 0. Cokolinis Vandentiekis | 6490.87 | -2799.72 | L1 2
5424457 | 0. Cokolinis Vandentiekis | 1116.44 | -1592.46 | L1 2
5424711 | 0. Cokolinis Vandentiekis | 234.92 | -1592.46 | L1 2
5424720 | 0. Cokolinis Vandentiekis | 1175.54 | -1592.46 | L1 2
5424932 | 0. Cokolinis Vandentiekis | 433.554 | -638.554 | L1 7
5424952 | 0. Cokolinis Vandentiekis | 787.408 | -874.721 | L1 7
5426422 | 0. Cokolinis Vandentiekis | 5567.97 | -2899.97 | L1 2
5426506 | 0. Cokolinis Vandentiekis | 3855.5 | -2841.89 | L1 2
5427164 | 0. Cokolinis Vandentiekis | 753.369 | -2651.11 | F1 9
5432946 | 0. Cokolinis Vandentiekis | 918.882 | -2909.85 | F1 9
5433476 | 0. Cokolinis Vandentiekis | 5282.75 | -2982.6 | F1 9
5433564 | 0. Cokolinis Vandentiekis | 2044.82 | -2926.63 | F1 9
5435860 | 0. Cokolinis Vandentiekis | 204.348 | -2635.61 | F1 9
5439795 | 0. Cokolinis Vandentiekis | 405.124 | -2447.12 | L1 2; F1 4
5439835 | 0. Cokolinis Vandentiekis | 121.051 | -2800.19 | L1 2
5441673 | 0. Cokolinis Vandentiekis | 169.018 | -2795.68 | L1 2
5442044 | 0. Cokolinis Vandentiekis | 586.409 | -2629.2 | L1 2; F1 6
5442425 | 0. Cokolinis Vandentiekis | 467.027 | -2782.5 | F1 2 (1) (1) (1) (1) (1)
5444057 | 0. Cokolinis Vandentiekis | 1125.75 | -2809.42 | F1 2 (1) (1) (1) (1) (1)
5444186 | 0. Cokolinis Vandentiekis | 469.522 | -2846.28 | F1 2 (1) (1) (1) (1) (1)
5444587 | 0. Cokolinis Vandentiekis | 445.948 | -2488.77 | F1 2 (1) (1) (1) (1) (1)
5446017 | 1. Pirmas | 353.796 | -2299.17 | F1 9
5446041 | 1. Pirmas | 426.993 | -2525.23 | F1 9
5448107 | 0. Cokolinis Vandentiekis | 237.159 | -2679.06 | L1 1
5448268 | 0. Cokolinis Vandentiekis | 412.787 | -2454.79 | L1 1; F1 5
5448692 | 0. Cokolinis Vandentiekis | 576.025 | -2618.03 | L1 1
5448706 | 0. Cokolinis Vandentiekis | 5484.2 | -2856.95 | L1 1
5448873 | 0. Cokolinis Vandentiekis | 387.57 | -3069.89 | L1 1
5449304 | 0. Cokolinis Vandentiekis | 799.713 | -2841.71 | L1 1; F1 7
5452267 | 0. Cokolinis Vandentiekis | 322.828 | -2795.34 | F1 9
5452438 | 0. Cokolinis Vandentiekis | 357.61 | -2399.61 | F1 9
5453226 | 0. Cokolinis Vandentiekis | 250.683 | -3122.79 | L1 1
5453437 | 0. Cokolinis Vandentiekis | 674.639 | -2716.64 | L1 1; F1 8
5453752 | 0. Cokolinis Vandentiekis | 535.898 | -2577.9 | F1 2 (1) (1) (1) (1) (1)
5453787 | 0. Cokolinis Vandentiekis | 85.7755 | -2800.02 | F1 2 (1) (1) (1) (1) (1)
5453973 | 0. Cokolinis Vandentiekis | 599.882 | -2641.88 | L1 1
5454168 | 0. Cokolinis Vandentiekis | 1197.87 | -3062.19 | L1 1
5454397 | 0. Cokolinis Vandentiekis | 160 | -2202 | F1 9
5454404 | 0. Cokolinis Vandentiekis | 322.794 | -2640.43 | F1 9
5455520 | 0. Cokolinis Vandentiekis | 249.782 | -2291.79 | F1 9
5455536 | 0. Cokolinis Vandentiekis | 108.713 | -2537.45 | F1 9
5460163 | 0. Cokolinis Vandentiekis | 864.788 | -2625.06 | F1 2 (1) (1) (1) (1) (1)
5460886 | 1. Pirmas | 374.445 | -2380.68 | F1 2 (1) (1) (1) (1) (1)
5461293 | 0. Cokolinis Vandentiekis | 1863.23 | -2768.74 | F1 2 (1) (1) (1) (1) (1)
5461811 | 0. Cokolinis Vandentiekis | 6427.02 | -2764.41 | F1 2 (1) (1) (1) (1) (1)

# IfcFlowSegment: Pipe Types:Geberit PE vamzdis_PRO_101538 - OD (100)
Type - Material: L1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Geberit PE vamzdis_PRO_101538 - OD; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:Geberit PE vamzdis_PRO_101538 - OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4654344 | Stogo ilaju aukštas | 4969.49 | 10469.2 | L1 1
4654390 | Stogo ilaju aukštas | 346.991 | 10646 | L1 1
4659411 | Stogo ilaju aukštas | 281.991 | 10711 | L1 1
4659557 | Stogo ilaju aukštas | 389.86 | 10603.2 | L1 1
4659719 | Stogo ilaju aukštas | 497.86 | 10495.2 | L1 1
4659822 | Stogo ilaju aukštas | 5186.08 | 10361.2 | L1 1
4659875 | Stogo ilaju aukštas | 688.683 | 10304.3 | L1 1
4659975 | Stogo ilaju aukštas | 629.86 | 10363.2 | L1 1
4660588 | Stogo ilaju aukštas | 849.842 | 10458.9 | L1 1
4660753 | Stogo ilaju aukštas | 6386.32 | 10229.2 | L1 1
4660819 | Stogo ilaju aukštas | 5067.31 | 10123.5 | L1 1
4661555 | Stogo ilaju aukštas | 820.243 | 10172.8 | L1 1
4661579 | Stogo ilaju aukštas | 6266.33 | 9967.07 | L1 1
4661860 | Stogo ilaju aukštas | 835.101 | 10157.9 | L1 2
4662021 | Stogo ilaju aukštas | 703.105 | 10289.9 | L1 2
4662046 | Stogo ilaju aukštas | 645.145 | 10347.9 | L1 2
4662069 | Stogo ilaju aukštas | 513.145 | 10479.9 | L1 2
4662090 | Stogo ilaju aukštas | 407.576 | 10585.4 | L1 2
4663408 | Stogo ilaju aukštas | 6386.32 | 10213.9 | L1 2
4663414 | Stogo ilaju aukštas | 5186.08 | 10345.9 | L1 2
4663487 | Stogo ilaju aukštas | 5013.69 | 9844.83 | L1 2
4663523 | Stogo ilaju aukštas | 6265.1 | 9951.8 | L1 2
4663529 | Stogo ilaju aukštas | 5068.11 | 10108.2 | L1 2
4665046 | Stogo ilaju aukštas | 56.6638 | 9656.29 | L1 2
4684044 | 1. Pirmas | 60.1069 | 7278.16 | L1 2
4684059 | 1. Pirmas | 2105.8 | 7093.57 | L1 2
4684703 | 1. Pirmas | 39.3864 | 7298.88 | L1 2
4684705 | 1. Pirmas | 4590.5 | 7065 | L1 2
4684729 | 1. Pirmas | 165.838 | 7172.43 | L1 1
4684789 | 1. Pirmas | 958.746 | 7118.63 | L1 1
4685651 | 1. Pirmas | 204.767 | 7133.5 | L1 1
4685653 | 1. Pirmas | 744.84 | 6930.96 | L1 1
4686407 | Pirmo aukšto antresolė | 690.589 | 6914.96 | L1 1
4703151 | Pirmo aukšto antresolė | 226.517 | 5726.45 | L1 1
4703159 | Pirmo aukšto antresolė | 276.004 | 5411.5 | L1 1
4703541 | Pirmo aukšto antresolė | 337.499 | 5714.8 | L1 1
4704807 | 1. Pirmas | 282.129 | 7056.14 | L1 1
4704835 | 1. Pirmas | 195.148 | 7143.12 | L1 1
4705532 | 1. Pirmas | 210.265 | 7128 | L1 1
4705683 | 1. Pirmas | 2762.89 | 6930.27 | L1 1
5040145 | Stogo ilaju aukštas | 259.423 | 6840.46 | L1 2
5040351 | Stogo ilaju aukštas | 1265.02 | 10478.1 | L1 1
5040534 | Stogo ilaju aukštas | 21.5539 | 9959.92 | L1 1
5040615 | Pirmo aukšto antresolė | 1286.15 | 9931.61 | L1 1
5041075 | Pirmo aukšto antresolė | 1875.82 | 9891.62 | L1 1
5041135 | Stogo ilaju aukštas | 254.073 | 10163.7 | L1 1
5042473 | Pirmo aukšto antresolė | 28.5689 | 7048.95 | L1 1
5044221 | Pirmo aukšto antresolė | 1002.56 | 5692.88 | L1 1
5044813 | Pirmo aukšto antresolė | 775.404 | -1935.4 | L1 1
5045368 | Pirmo aukšto antresolė | 48 | 5731 | L1 1
5045397 | Pirmo aukšto antresolė | 456 | 5237.5 | L1 1
5045449 | Pirmo aukšto antresolė | 161.582 | 5131 | L1 1
5045466 | Pirmo aukšto antresolė | 38.1798 | 5131 | L1 1
5046247 | Pirmo aukšto antresolė | 45.9968 | 5274.35 | L1 1
5046366 | Pirmo aukšto antresolė | 1342.1 | 1537.5 | L1 1
5046416 | Pirmo aukšto antresolė | 70.8859 | 1428.18 | L1 1
5046428 | Pirmo aukšto antresolė | 2197.5 | -840.005 | L1 1
5047007 | Pirmo aukšto antresolė | 1443.09 | 1396.45 | L1 1
5047415 | Stogo ilaju aukštas | 540.461 | 9469.49 | L1 2
5059937 | Stogo ilaju aukštas | 7591.49 | -754.025 | L1 2
5060814 | Pirmo aukšto antresolė | 958.422 | 7072.05 | L1 2
5061526 | 1. Pirmas | 2509.71 | 6979.76 | L1 1
5061909 | Pirmo aukšto antresolė | 1409.79 | 6949.37 | L1 1
5062003 | Pirmo aukšto antresolė | 383.726 | 6948.14 | L1 1
5062020 | 1. Pirmas | 2200.34 | 6947.01 | L1 1
5064236 | Pirmo aukšto antresolė | 206.087 | 7059.98 | L1 2
5064251 | Pirmo aukšto antresolė | 242.511 | 7065 | L1 2
5065191 | Pirmo aukšto antresolė | 733.966 | -1937.97 | L1 2
5203187 | Pirmo aukšto antresolė | 747.85 | -1907.85 | L1 1
5203191 | Pirmo aukšto antresolė | 1321.83 | 1481.82 | L1 1
5205492 | 1. Pirmas | 806.084 | -1901.32 | L1 1
5205497 | 1. Pirmas | 4.83504 | 6829.11 | L1 1
5209973 | 1. Pirmas | 733.652 | -1937.65 | L1 1
5210328 | 1. Pirmas | 79.8435 | 6763.21 | L1 1
5211054 | 1. Pirmas | 13.3632 | 6875.8 | L1 1
5279383 | 1. Pirmas | 7617.91 | -904 | L1 1
5279595 | 1. Pirmas | 7501.48 | -904 | L1 1
5279773 | Pirmo aukšto antresolė | 6578.93 | -925 | L1 1
5279970 | Pirmo aukšto antresolė | 2279.09 | -925 | L1 1
5280223 | 1. Pirmas | 7462.46 | -795.233 | L1 1
5280798 | Pirmo aukšto antresolė | 913.192 | -1988.19 | L1 1
5280895 | Stogo ilaju aukštas | 674.738 | -1912.87 | L1 1
5281029 | Pirmo aukšto antresolė | 2103.87 | 3114.62 | L1 1
5282060 | Pirmo aukšto antresolė | 7922.87 | -904.001 | L1 2
5304443 | Stogo ilaju aukštas | 1701.7 | 7728.61 | L1 2
5304469 | Stogo ilaju aukštas | 589.783 | 7153.54 | L1 2
5304658 | 0. Cokolinis Vandentiekis | 934.5 | -2046.52 | L1 2
5307941 | Stogo ilaju aukštas | 87.2244 | 10048.9 | L1 2
5358787 | 1. Pirmas | 728.125 | -1932.13 | L1 1
5362819 | 1. Pirmas | 57.9585 | 7280.31 | L1 1
5363217 | Stogo ilaju aukštas | 239.178 | 10753.8 | L1 2
5363279 | Stogo ilaju aukštas | 2351.34 | 10564.3 | L1 2
5363314 | Stogo ilaju aukštas | 745.091 | 10451.5 | L1 2
5363344 | Stogas | 1492.66 | 10468.6 | L1 2
5363360 | Stogas | 2110.17 | 10500.6 | L1 2
5363555 | Stogas | 857.307 | 10545 | L1 2
5364555 | Stogo ilaju aukštas | 788.85 | 10204.1 | L1 2
5445229 | Stogo ilaju aukštas | 4320.63 | -880.13 | L1 1
5456256 | Stogo ilaju aukštas | 5913.25 | 3846.5 | L1 1
5457471 | Pirmo aukšto antresolė | 2054.85 | 3038.65 | L1 1

# IfcFlowSegment: Pipe Types:NLRS_52_PI_Wavin SiTech+ Pipe (OD) (135)
Type - Material: L1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_52_PI_Wavin SiTech+ Pipe (OD); sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:NLRS_52_PI_Wavin SiTech+ Pipe (OD):...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4705194 | 1. Pirmas | 379.747 | 6992.34 | L1 1
4707293 | 1. Pirmas | 337.59 | 6906.2 | L1 1
4707666 | Pirmo aukšto antresolė | 4667.8 | 6910.71 | L1 1
4707698 | 1. Pirmas | 891.196 | 6883.46 | L1 1
4712503 | 0. Cokolinis Vandentiekis | 139.608 | -2416.5 | F1 2 (1) (1) (1) (1) (1)
4712587 | 0. Cokolinis Vandentiekis | 88.3867 | -2415.71 | F1 2 (1) (1) (1) (1) (1)
4714246 | 0. Cokolinis Vandentiekis | 209.412 | -2013.81 | F1 2 (1) (1) (1) (1) (1)
4714280 | 0. Cokolinis Vandentiekis | 453.589 | -1831.19 | F1 2 (1) (1) (1) (1) (1)
4755116 | 0. Cokolinis Vandentiekis | 679.871 | 4483.48 | F1 9
4755556 | 0. Cokolinis Vandentiekis | 315.574 | 1911.06 | F1 9
4756346 | 1. Pirmas | 139.511 | 1790.74 | F1 9
4770913 | 1. Pirmas | 78.0807 | 1844.58 | F1 4 (1)
4785079 | 1. Pirmas | 76.4106 | 1848.38 | F1 4 (1)
4785208 | 1. Pirmas | 54.6559 | 1872.51 | F1 4 (1)
4785359 | 1. Pirmas | 112.653 | 2021.31 | F1 9
4785721 | 1. Pirmas | 448.695 | 1990.81 | F1 9
4786576 | 1. Pirmas | 436.645 | 1865.69 | F1 9
4787367 | 1. Pirmas | 136.15 | 2424.83 | F1 9
4787726 | 1. Pirmas | 380.82 | 1979.4 | F1 9
4788131 | 1. Pirmas | 150 | 2587.58 | F1 9
4788283 | 1. Pirmas | 4.63906 | 2610.98 | F1 9
4789732 | 1. Pirmas | 481.215 | 1790.89 | F1 9
4789789 | 1. Pirmas | 286.831 | 1973.56 | F1 9
4793675 | 1. Pirmas | 76.8342 | 2132.11 | F1 4 (2)
4794382 | 1. Pirmas | 136.15 | 2424.83 | F1 9
4794385 | 1. Pirmas | 90 | 2270.23 | F1 9
4794391 | 1. Pirmas | 180 | 2587.58 | F1 9
4794393 | 1. Pirmas | 31.1247 | 2610.98 | F1 9
4794417 | 1. Pirmas | 210.589 | 2049.8 | F1 9
4798561 | 1. Pirmas | 76.8425 | 1845.09 | F1 4 (1)
4800158 | 1. Pirmas | 2052.25 | 3098.2 | F1 9
4800964 | 0. Cokolinis Vandentiekis | 25.1672 | 8208.9 | F1 palubėje 12
4801225 | Pirmo aukšto antresolė | 742.897 | 8311.79 | F1 palubėje 12
4801297 | Pirmo aukšto antresolė | 6.78746 | 10364.7 | F1 palubėje 12
4814898 | 0. Cokolinis Vandentiekis | 62.4428 | 1621.79 | F1 9
4838004 | 1. Pirmas | 966.109 | 1833.24 | F1 9
4847430 | 1. Pirmas | 1053.54 | -2209.04 | F1 9
4849634 | 0. Cokolinis Vandentiekis | 1177.48 | 3085 | F1 9
4850317 | 1. Pirmas | 64.0977 | 1853.32 | F1 9
4850328 | 1. Pirmas | 65.0641 | 1853.64 | F1 9
4850348 | 1. Pirmas | 44.7628 | 1877.83 | F1 9
4850356 | 1. Pirmas | 65.5049 | 1850.38 | F1 9
4870952 | 1. Pirmas | 1497.62 | -2383.31 | F1 9
4870990 | 1. Pirmas | 1699.13 | 3160.16 | F1 9
4876131 | 0. Cokolinis Vandentiekis | 1318.04 | -2413.04 | F1 9
4876253 | 0. Cokolinis Vandentiekis | 868.813 | 1278.94 | F1 9
4879007 | 0. Cokolinis Vandentiekis | 1321.65 | 1493.35 | F1 9
4883590 | 1. Pirmas | 191.686 | 5299.17 | F1 palubėje 12
4883620 | 1. Pirmas | 341.945 | 5299.17 | F1 palubėje 12
4883634 | 1. Pirmas | 71.3911 | 5299.17 | F1 palubėje 12
4885221 | 0. Cokolinis Vandentiekis | 246.043 | 5411.8 | F1 palubėje 12
4885724 | 1. Pirmas | 77.6367 | 5299.17 | F1 palubėje 12
4888357 | 1. Pirmas | 821.422 | 1990.95 | F1 9
4888628 | 0. Cokolinis Vandentiekis | 628.418 | 5011.88 | F1 palubėje 5; F1 4 (1) (2)
4889586 | 0. Cokolinis Vandentiekis | 1538.54 | 1284.15 | F1 2 (1) (1) (1) (1) (1); F1 9
4889891 | 0. Cokolinis Vandentiekis | 1813.69 | -752.243 | F1 2 (1) (1) (1) (1) (1)
4890022 | 0. Cokolinis Vandentiekis | 119.823 | -2077.65 | F1 2 (1) (1) (1) (1) (1)
4890130 | 0. Cokolinis Vandentiekis | 28.6678 | -2207.78 | F1 2 (1) (1) (1) (1) (1)
4890676 | 0. Cokolinis Vandentiekis | 834.772 | -2103.84 | F1 2 (1) (1) (1) (1) (1)
4890683 | 0. Cokolinis Vandentiekis | 67.846 | -2273.14 | F1 2 (1) (1) (1) (1) (1)
4891279 | 0. Cokolinis Vandentiekis | 61.6494 | 1422.52 | F1 9
4893967 | 1. Pirmas | 280.752 | 1834.52 | F1 9
4896521 | 1. Pirmas | 486.953 | 1819.97 | F1 9
4960425 | 1. Pirmas | 395.662 | 1387.65 | F1 palubėje 15
4968293 | 1. Pirmas | 60.5205 | 1722.79 | F1 palubėje 15
5010743 | 1. Pirmas | 316.077 | 1467.24 | F1 9
5010794 | 1. Pirmas | 329.745 | 1453.57 | F1 palubėje 20
5011124 | 1. Pirmas | 81.5453 | 1701.76 | F1 palubėje 15
5011135 | 1. Pirmas | 155.569 | 1375.33 | F1 palubėje 15
5011173 | 1. Pirmas | 3240.83 | 1383.36 | F1 palubėje 15
5011408 | 0. Cokolinis Vandentiekis | 3450.37 | 1303.75 | F1 palubėje 15
5011555 | 0. Cokolinis Vandentiekis | 1574.8 | 1269.69 | F1 palubėje 15
5011718 | 0. Cokolinis Vandentiekis | 864.479 | 1358.3 | F1 palubėje 20
5011798 | 0. Cokolinis Vandentiekis | 605.564 | 1342.4 | F1 palubėje 20
5013537 | 1. Pirmas | 746.886 | 1405.32 | F1 palubėje 11
5014054 | 1. Pirmas | 689.544 | 1421.08 | F1 palubėje 11
5014074 | 1. Pirmas | 680.42 | 1102.89 | F1 palubėje 11
5015385 | 1. Pirmas | 476.188 | 1245.6 | F1 palubėje 15
5015482 | 0. Cokolinis Vandentiekis | 626.361 | 1110.52 | F1 palubėje 15
5016325 | 1. Pirmas | 248.811 | 1116.82 | F1 9
5017863 | 0. Cokolinis Vandentiekis | 1632.9 | 976.822 | F1 palubėje 10
5019246 | 1. Pirmas | 243.211 | 972.19 | F1 9
5025153 | 0. Cokolinis Vandentiekis | 21.5862 | 970.541 | F1 9
5031622 | 0. Cokolinis Vandentiekis | 727.094 | -1869.09 | F1 9
5034829 | 0. Cokolinis Vandentiekis | 209.352 | -2317.35 | F1 2 (1) (1) (1) (1) (1)
5041494 | 1. Pirmas | 946.731 | 4975.9 | F1 palubėje 5
5041550 | 1. Pirmas | 2197.81 | 4988.13 | F1 palubėje 5
5042182 | 0. Cokolinis Vandentiekis | 982.955 | 5000.22 | F1 9; F1 palubėje 5
5095051 | Pirmo aukšto antresolė | 1347.28 | 10508.1 | F1 palubėje 12
5095101 | Pirmo aukšto antresolė | 958.426 | 10698.6 | F1 palubėje 12
5206277 | 0. Cokolinis Vandentiekis | 1161.45 | 7104.73 | F1 4 (1) (2)
5211644 | 0. Cokolinis Vandentiekis | 1685.29 | 5257.56 | F1 4 (1) (2)
5215482 | Pirmo aukšto antresolė | 1228.54 | 8974.33 | F1 palubėje 12
5286940 | 1. Pirmas | 464.737 | 1452.3 | F1 palubėje 15
5287014 | 0. Cokolinis Vandentiekis | 811.147 | 1240.56 | F1 palubėje 15
5287054 | 0. Cokolinis Vandentiekis | 11161.8 | 1119.48 | F1 palubėje 15
5287074 | 0. Cokolinis Vandentiekis | 3835.5 | 995.31 | F1 palubėje 10
5287112 | 0. Cokolinis Vandentiekis | 297.012 | 1332.8 | F1 palubėje 20
5287138 | 0. Cokolinis Vandentiekis | 11895.7 | 1090.79 | F1 palubėje 20
5287189 | 0. Cokolinis Vandentiekis | 940.757 | -1900 | F1 2 (1) (1) (1) (1) (1)
5287695 | 0. Cokolinis Vandentiekis | 1841.61 | 3022 | F1 9
5287801 | 1. Pirmas | 2544.46 | -948.5 | F1 9
5287959 | 1. Pirmas | 1112.24 | 1778.96 | F1 9
5296586 | 1. Pirmas | 2368.74 | -678.693 | F1 9
5357560 | 1. Pirmas | 1050.28 | 5287.04 | F1 9; F1 palubėje 12
5357725 | 1. Pirmas | 1025.27 | 5299.17 | F1 palubėje 12
5393694 | 1. Pirmas | 990.875 | 10591.4 | F1 4 (3)
5406865 | -1 Baseino dugnas | 184.937 | 1515.88 | F1 9
5406954 | -1 Baseino dugnas | 7095.02 | 3092.5 | F1 9
5421959 | 0. Cokolinis Vandentiekis | 2049.66 | -888 | F1 9
5422893 | 0. Cokolinis Vandentiekis | 682.226 | 5723 | F1 palubėje 12
5422942 | 0. Cokolinis Vandentiekis | 1010.77 | 1867.23 | F1 9
5423012 | 1. Pirmas | 1092.35 | 3019.37 | F1 9
5428567 | 0. Cokolinis Vandentiekis | 242.05 | 963.345 | F1 palubėje 11
5428575 | 0. Cokolinis Vandentiekis | 2255.41 | 967.805 | F1 palubėje 11
5428622 | 0. Cokolinis Vandentiekis | 859.531 | 943.687 | F1 palubėje 11
5430067 | 0. Cokolinis Vandentiekis | 362.999 | 709.22 | F1 palubėje 11
5430226 | 1. Pirmas | 283.505 | 985.997 | F1 palubėje 11
5430834 | 1. Pirmas | 288.677 | 1056.48 | F1 palubėje 11
5431959 | 0. Cokolinis Vandentiekis | 1238.22 | 919.097 | F1 palubėje 11
5434615 | 0. Cokolinis Vandentiekis | 396.11 | 720.807 | F1 palubėje 11
5434907 | 0. Cokolinis Vandentiekis | 519.008 | 699.028 | F1 palubėje 11
5435007 | 0. Cokolinis Vandentiekis | 792.77 | 679.841 | F1 palubėje 11
5435179 | 0. Cokolinis Vandentiekis | 7317.38 | 1035.31 | F1 palubėje 15
5436487 | 0. Cokolinis Vandentiekis | 1373.01 | -926 | F1 9
5436562 | 0. Cokolinis Vandentiekis | 113.914 | 709.008 | F1 9
5444972 | 0. Cokolinis Vandentiekis | 10574.7 | 992.518 | F1 palubėje 11
5445043 | 0. Cokolinis Vandentiekis | 2231.43 | 875.895 | F1 palubėje 11
5445089 | 0. Cokolinis Vandentiekis | 2523.84 | 731.665 | F1 palubėje 11
5445988 | 1. Pirmas | 809.374 | -1944.37 | F1 9
5446282 | 1. Pirmas | 2181.28 | -928 | F1 9
5455917 | 0. Cokolinis Vandentiekis | 1460.86 | 6612.23 | F1 palubėje 12
5457203 | -1 Baseino dugnas | 975.179 | 1910.32 | F1 9
5457336 | 1. Pirmas | 1080.11 | 1873.05 | F1 9
5462385 | 0. Cokolinis Vandentiekis | 5145.35 | 780.79 | F1 palubėje 11

# IfcFlowSegment: Pipe Types:PE, Pipe Types:PE:4894406
In: 1. Pirmas
Type - Material: F1
Pset_DistributionFlowElementCommon - Reference: PE; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 13027.7 mm
Pset_FlowSegmentPipeSegment - Length: 13027.7 mm; InvertElevation: -3028.5 mm
Group: F1 2 1

# IfcFlowSegment: Pipe Types:PE100 vamzdis, Pipe Types:PE100 vamzdis:4894398
In: 1. Pirmas
Type - Material: F1
Pset_DistributionFlowElementCommon - Reference: PE100 vamzdis; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1117.2 mm
Pset_FlowSegmentPipeSegment - Length: 1117.2 mm; InvertElevation: -2672.07 mm
Group: F1 2 1

# IfcFlowSegment: Pipe Types:PVC - DWV (94)
Type - Material: K1
Pset_DistributionFlowElementCommon - Reference: PVC - DWV; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:PVC - DWV:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
5198853 | 0. Cokolinis Vandentiekis | 38.2735 | 1443 | K1 1
5198967 | 0. Cokolinis Vandentiekis | 713.808 | 3389.49 | K1 2
5202077 | 0. Cokolinis Vandentiekis | 32.7859 | 1371.6 | K1 1
5202092 | 0. Cokolinis Vandentiekis | 175.15 | 1393 | K1 1
5202416 | 0. Cokolinis Vandentiekis | 417.762 | 1443 | K1 1
5202426 | 0. Cokolinis Vandentiekis | 418.123 | 1443 | K1 1
5202448 | 0. Cokolinis Vandentiekis | 1379.71 | 1443 | K1 1
5202696 | 0. Cokolinis Vandentiekis | 2365.44 | 1443 | K1 1
5202929 | 0. Cokolinis Vandentiekis | 1658.56 | 1443 | K1 4
5203020 | 0. Cokolinis Vandentiekis | 111.582 | 1443 | K1 4
5203031 | 0. Cokolinis Vandentiekis | 450.694 | 1443 | K1 4
5203109 | 0. Cokolinis Vandentiekis | 75.2281 | 1404.38 | K1 8
5203129 | 0. Cokolinis Vandentiekis | 108.541 | 1413 | K1 12
5203639 | 1. Pirmas | 373.479 | 3389.49 | K1 2
5203652 | 1. Pirmas | 830.66 | 3389.49 | K1 2
5203714 | 1. Pirmas | 678.054 | 3389.49 | K1 2
5203728 | 1. Pirmas | 2822.7 | 3389.49 | K1 2
5204454 | 1. Pirmas | 377.762 | 5140.5 | K1 3
5204466 | 1. Pirmas | 120.465 | 5140.5 | K1 3
5204474 | 1. Pirmas | 3.28702 | 5140.5 | K1 3
5204534 | 1. Pirmas | 16.3996 | 5055.25 | K1 3
5204793 | 1. Pirmas | 2599.52 | 2417.11 | K1 3
5204855 | 1. Pirmas | 112.314 | 2350.5 | K1 3
5204907 | 1. Pirmas | 1317.02 | 7049.2 | K1 5
5204960 | Pirmo aukšto antresolė | 3287.27 | 7049.2 | K1 5
5205222 | Pirmo aukšto antresolė | 288.034 | 6722.55 | K1 5
5205232 | Pirmo aukšto antresolė | 133.222 | 6743.95 | K1 5
5205802 | 1. Pirmas | 177.762 | 7049.2 | K1 6
5205814 | 1. Pirmas | 137.762 | 7049.2 | K1 6
5205895 | 1. Pirmas | 1397.44 | 7049.2 | K1 6
5206700 | 1. Pirmas | 930.993 | 7049.2 | K1 2
5206739 | 1. Pirmas | 312.658 | 7053.2 | K1 2
5207046 | 1. Pirmas | 975.376 | 7055.5 | K1 2
5207056 | 1. Pirmas | 439.524 | 7049.2 | K1 2
5207090 | 1. Pirmas | 920.931 | 7049.2 | K1 2
5207168 | 1. Pirmas | 168.89 | 7053.2 | K1 2
5207308 | 1. Pirmas | 2810.73 | 7049.2 | K1 2
5207466 | 1. Pirmas | 29.7327 | 3356.38 | K1 2
5207531 | 1. Pirmas | 14.7 | 7047.94 | K1 2
5208031 | 1. Pirmas | 123.057 | 7049.2 | K1 7
5208069 | 1. Pirmas | 1303.31 | 7049.2 | K1 7
5208157 | 1. Pirmas | 2987.49 | 7049.2 | K1 9
5208207 | 1. Pirmas | 288.117 | 6864.2 | K1 9
5208254 | 1. Pirmas | 627.961 | 7049.2 | K1 9
5208755 | 1. Pirmas | 61.7078 | 6864.2 | K1 9
5209005 | 1. Pirmas | 162.295 | 7049.2 | K1 9
5209225 | 1. Pirmas | 79.7719 | 6930.81 | K1 9
5209406 | 1. Pirmas | 88.8793 | 6674.2 | K1 9
5210634 | 1. Pirmas | 2898.67 | 7049.2 | K1 10
5210735 | 1. Pirmas | 521.84 | 7049.2 | K1 10
5210777 | 1. Pirmas | 111.947 | 7049.2 | K1 10
5210830 | 1. Pirmas | 384.149 | 7049.2 | K1 10
5210925 | 1. Pirmas | 241.353 | 6769.23 | K1 10
5210935 | 1. Pirmas | 228.223 | 6790.63 | K1 10
5211273 | 1. Pirmas | 172.786 | 6652.8 | K1 9
5211373 | 1. Pirmas | 68.033 | 5033.85 | K1 3
5211561 | 1. Pirmas | 31.977 | 6978.61 | K1 6
5211583 | 1. Pirmas | 74.723 | 7000.01 | K1 6
5211954 | 1. Pirmas | 32.7859 | 6977.8 | K1 2
5211964 | 1. Pirmas | 55.3262 | 6999.2 | K1 2
5212039 | 1. Pirmas | 3557.06 | 3405.12 | K1 2
5212108 | 1. Pirmas | 15.8935 | 3334.98 | K1 2
5212172 | 1. Pirmas | 1958.74 | 1360.62 | K1 2
5214081 | Pirmo aukšto antresolė | 55.2617 | 10544.6 | K1 11
5214093 | Pirmo aukšto antresolė | 83.0561 | 10544.6 | K1 11
5214101 | Pirmo aukšto antresolė | 1680.69 | 10544.6 | K1 11
5215461 | Pirmo aukšto antresolė | 247.786 | 10258.2 | K1 11
5215471 | Pirmo aukšto antresolė | 78.2381 | 10279.6 | K1 11
5215749 | 1. Pirmas | 1765.02 | 7049.2 | K1 7
5215760 | 1. Pirmas | 283.272 | 7049.2 | K1 7
5215775 | 1. Pirmas | 144.989 | 7012.8 | K1 7
5215783 | 1. Pirmas | 32.2485 | 7012.8 | K1 7
5215794 | 1. Pirmas | 4862.58 | 2111.6 | K1 7
5215942 | 1. Pirmas | 938.733 | 7049.2 | K1 7
5216021 | 1. Pirmas | 19.1905 | 6991.4 | K1 7
5270489 | 1. Pirmas | 1340.84 | 1424.78 | F1 palubėje 11
5272703 | 1. Pirmas | 322.161 | 1609.22 | F1 palubėje 11; K1 7
5272985 | 1. Pirmas | 1130.66 | 1831.61 | F1 2
5273085 | 1. Pirmas | 526.101 | 1472.35 | F1 palubėje 11
5273202 | 1. Pirmas | 576.038 | 1497.78 | F1 palubėje 11
5273332 | 1. Pirmas | 559.805 | 1482.78 | F1 palubėje 11
5273335 | 1. Pirmas | 218.819 | 1463.63 | F1 palubėje 11
5273450 | 1. Pirmas | 626.395 | 2044.99 | K1 7
5437275 | 1. Pirmas | 176.277 | 1598.77 | F1 2
5437392 | 1. Pirmas | 333.023 | 1583.78 | F1 3
5437873 | 1. Pirmas | 349.807 | 7049.2 | K1 7
5458740 | 0. Cokolinis Vandentiekis | 161.672 | 1422.77 | F1 palubėje 11
5458797 | 0. Cokolinis Vandentiekis | 4330.47 | 1290.56 | F1 palubėje 11
5458848 | 0. Cokolinis Vandentiekis | 240.641 | 1069.68 | F1 palubėje 11
5461015 | 1. Pirmas | 221.129 | 1289.47 | K1 2
5461027 | 1. Pirmas | 3143.14 | -1896.84 | K1 2
5462272 | 0. Cokolinis Vandentiekis | 18.0398 | 806.062 | F1 palubėje 11
5462455 | 0. Cokolinis Vandentiekis | 70.3057 | 877.791 | F1 palubėje 11
5462467 | 0. Cokolinis Vandentiekis | 3272.94 | 978.205 | F1 palubėje 11

# IfcFlowSegment: Pipe Types:Wavin PVC Grey OD (100)
Type - Material: F1 Palube
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: Wavin PVC Grey OD; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:Wavin PVC Grey OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4749779 | 0. Cokolinis Vandentiekis | 36.7193 | -1602.5 | F1 2 (1) (1) (1) (1) (1); F1 3 (6)
4754143 | 0. Cokolinis Vandentiekis | 36.4233 | -1602.5 | F1 2 (1) (1) (1) (1) (1); F1 3 (5)
4755663 | 0. Cokolinis Vandentiekis | 213.079 | 2040.02 | F1 9
4755775 | 1. Pirmas | 92.1475 | 1865.74 | F1 9
4780762 | 0. Cokolinis Vandentiekis | 251 | -1911.86 | F1 2 (1) (1) (1) (1) (1)
4781046 | 0. Cokolinis Vandentiekis | 359.85 | -2020.71 | F1 2 (1) (1) (1) (1) (1)
4782313 | 0. Cokolinis Vandentiekis | 531.151 | -1941.89 | F1 2 (1) (1) (1) (1) (1)
4782972 | 0. Cokolinis Vandentiekis | 105.313 | -1941.89 | F1 2 (1) (1) (1) (1) (1)
4784142 | 0. Cokolinis Vandentiekis | 78.5911 | -1569.22 | F1 2 (1) (1) (1) (1) (1)
4784424 | 0. Cokolinis Vandentiekis | 162.884 | -1705.89 | F1 2 (1) (1) (1) (1) (1)
4784498 | 0. Cokolinis Vandentiekis | 228.837 | -1709.58 | F1 2 (1) (1) (1) (1) (1)
4785480 | 1. Pirmas | 1020.79 | 1829.65 | F1 9
4791076 | 1. Pirmas | 301.869 | 2002.45 | F1 9
4793091 | 1. Pirmas | 62.702 | 2450.37 | F1 9
4793373 | 1. Pirmas | 443.938 | 1911.13 | F1 9
4793825 | 1. Pirmas | 75.2873 | 2543.76 | F1 9
4794377 | 1. Pirmas | 233.818 | 1822.63 | F1 9
4794411 | 1. Pirmas | 121.157 | 1678.92 | F1 9
4795109 | 1. Pirmas | 82.3057 | 1679.04 | F1 9
4796919 | 1. Pirmas | 809.739 | 1771.65 | F1 9
4797643 | 1. Pirmas | 2414.23 | 1736.19 | F1 9
4797944 | 1. Pirmas | 63.2244 | 1871.12 | F1 4 (1)
4804490 | 1. Pirmas | 56.2424 | 1753.83 | F1 9
4805892 | 1. Pirmas | 394.322 | 1871.12 | F1 4 (1)
4806898 | 1. Pirmas | 293.509 | 1811.22 | F1 4 (1)
4811824 | 1. Pirmas | 51.1578 | 1807 | F1 4 (1)
4811832 | 1. Pirmas | 766 | 1809.5 | F1 4 (1)
4814683 | 1. Pirmas | 620.466 | 1763.31 | F1 9
4817248 | 1. Pirmas | 77.36 | 1751.74 | F1 9
4817258 | 1. Pirmas | 5.61417 | 1753.83 | F1 9
4818757 | 1. Pirmas | 83.0538 | 1765.7 | F1 9
4837438 | 1. Pirmas | 378.715 | 1786.03 | F1 9
4837645 | 1. Pirmas | 439.464 | 1869.55 | F1 9
4838578 | 1. Pirmas | 1518 | 1788.86 | F1 9
4839044 | 0. Cokolinis Vandentiekis | 671.634 | -2068.6 | F1 3 (4)
4842142 | 1. Pirmas | 260.994 | 2008.23 | F1 9
4844626 | 0. Cokolinis Vandentiekis | 118.153 | 2652.84 | F1 4 (3)
4847297 | 1. Pirmas | 5.78188 | 1807 | F1 4 (1)
4848868 | 1. Pirmas | 85.6475 | 1807 | F1 4 (1)
4849292 | 1. Pirmas | 328.984 | 1469.42 | F1 4 (1)
4849589 | 1. Pirmas | 29.3991 | 4244.47 | F1 9
4850350 | 1. Pirmas | 62.8132 | 1876.45 | F1 9
4850358 | 1. Pirmas | 394.766 | 1876.45 | F1 9
4850369 | 1. Pirmas | 293.509 | 1816.55 | F1 9
4850378 | 1. Pirmas | 11 | 1816.55 | F1 9
4850381 | 1. Pirmas | 766 | 1816.55 | F1 9
4850388 | 1. Pirmas | 60.5251 | 1816.55 | F1 9
4850394 | 1. Pirmas | 54.2273 | 1816.55 | F1 9
4851261 | 1. Pirmas | 329.219 | 1879.73 | F1 9
4851463 | 1. Pirmas | 151.481 | 1760.88 | F1 9
4852824 | 1. Pirmas | 7.29597 | 2417.7 | F1 9
4852875 | 1. Pirmas | 416.437 | 1986.77 | F1 9
4853766 | 1. Pirmas | 184.627 | 1767.56 | F1 9
4871344 | 1. Pirmas | 621.678 | 1840.68 | F1 9
4875220 | 1. Pirmas | 1010.56 | -2345.29 | F1 2 (1) (1) (1) (1) (1)
4875868 | 1. Pirmas | 3.09785 | 2502.7 | F1 4 (3)
4875870 | 1. Pirmas | 111.22 | 2376.98 | F1 9
4875943 | 1. Pirmas | 29.5235 | 2220.47 | F1 9
4875964 | 0. Cokolinis Vandentiekis | 382.311 | 2256.03 | F1 9
4880162 | 1. Pirmas | 277.248 | 1755.2 | F1 9
4891325 | 1. Pirmas | 308.669 | 1499.28 | F1 9
4894020 | 1. Pirmas | 247.11 | 1833.34 | F1 9
4896631 | 0. Cokolinis Vandentiekis | 254.506 | 1780.96 | F1 9
4982766 | 1. Pirmas | 594.507 | 1188.81 | F1 palubėje 20
5010824 | 1. Pirmas | 178.579 | 1604.73 | F1 palubėje 20
5010835 | 1. Pirmas | 263.395 | 1378.37 | F1 palubėje 20
5011161 | 1. Pirmas | 147.762 | 1635.55 | F1 palubėje 15
5011819 | 0. Cokolinis Vandentiekis | 451.041 | 1076.64 | F1 palubėje 20
5014043 | 1. Pirmas | 123.617 | 1659.7 | F1 palubėje 11
5023807 | 0. Cokolinis Vandentiekis | 115.4 | -1415.15 | F1 2 (1) (1) (1) (1) (1)
5023822 | 0. Cokolinis Vandentiekis | 49.4564 | -1392.25 | F1 2 (1) (1) (1) (1) (1)
5024571 | 0. Cokolinis Vandentiekis | 572.127 | -2022.74 | F1 2 (1) (1) (1) (1) (1)
5104002 | 0. Cokolinis Vandentiekis | 424.517 | -2692.06 | F1 palubėje 17
5204873 | 1. Pirmas | 81.6186 | 2407.64 | F1 9
5348041 | 1. Pirmas | 178.684 | 1852.97 | F1 9
5351093 | 1. Pirmas | 205.637 | 1831.8 | F1 9
5351449 | 1. Pirmas | 100.334 | 1811.26 | F1 9
5353145 | 1. Pirmas | 502.552 | 1838.37 | F1 9
5353960 | 1. Pirmas | 10.0055 | 1808.43 | F1 9
5354241 | 1. Pirmas | 144.006 | 1785.04 | F1 9
5356942 | 1. Pirmas | 1029.53 | 1760.06 | F1 9
5384091 | 1. Pirmas | 1541.01 | 1849.71 | F1 9
5384193 | 1. Pirmas | 289.55 | 1816.55 | F1 9
5384232 | 1. Pirmas | 402.45 | 1816.55 | F1 9
5384473 | 1. Pirmas | 1541.04 | 1844.29 | F1 4 (1)
5384495 | 1. Pirmas | 292.329 | 1811.22 | F1 4 (1)
5384535 | 1. Pirmas | 399.671 | 1811.22 | F1 4 (1)
5391780 | 0. Cokolinis Vandentiekis | 221.333 | 1914.69 | F1 9
5392585 | 0. Cokolinis Vandentiekis | 337.069 | 1788.72 | F1 9
5392597 | 0. Cokolinis Vandentiekis | 1059.33 | 1797.92 | F1 9
5393840 | 1. Pirmas | 113.676 | 10320.3 | F1 4 (3)
5397649 | 0. Cokolinis Vandentiekis | 121.489 | 1785.11 | F1 9
5399273 | 1. Pirmas | 644.957 | 1860.2 | F1 9
5407361 | -1 Baseino dugnas | 95.4789 | 1787.63 | F1 9
5408239 | 1. Pirmas | 194.697 | 1853.66 | F1 9
5408285 | 1. Pirmas | 378.396 | 1863.1 | F1 9
5408700 | 1. Pirmas | 57.9192 | 1879.81 | F1 9
5408714 | 1. Pirmas | 608.525 | 1857.51 | F1 9
5408872 | 1. Pirmas | 381.068 | 1783.6 | F1 9
5408896 | 1. Pirmas | 27.7005 | 1853.71 | F1 9

# IfcFlowSegment: Pipe Types:Wavin PVC White OD (24)
Type - Material: F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: Wavin PVC White OD; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:Wavin PVC White OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4782293 | 0. Cokolinis Vandentiekis | 82.1394 | -1379.14 | F1 2 (1) (1) (1) (1) (1)
4782299 | 0. Cokolinis Vandentiekis | 135.454 | -1356.94 | F1 2 (1) (1) (1) (1) (1)
4782958 | 0. Cokolinis Vandentiekis | 92.1394 | -1449.14 | F1 2 (1) (1) (1) (1) (1); F1 3 (9)
4782964 | 0. Cokolinis Vandentiekis | 53.3557 | -1426.94 | F1 2 (1) (1) (1) (1) (1)
4784132 | 0. Cokolinis Vandentiekis | 52.1394 | -1459.03 | F1 2 (1) (1) (1) (1) (1); F1 3 (10)
4784138 | 0. Cokolinis Vandentiekis | 44.9074 | -1436.83 | F1 2 (1) (1) (1) (1) (1)
4791064 | 1. Pirmas | 82.1394 | 2520.86 | F1 9
4791070 | 1. Pirmas | 140.303 | 2543.06 | F1 9
4791117 | 1. Pirmas | 82.1394 | 2520.86 | F1 9
4791123 | 1. Pirmas | 137.884 | 2543.06 | F1 9
4791406 | 1. Pirmas | 596.651 | 1892.61 | F1 9
4791797 | 1. Pirmas | 82.1394 | 2520.86 | F1 9
4792610 | 1. Pirmas | 50.5441 | 2543.06 | F1 9
4793819 | 1. Pirmas | 82.1394 | 2520.86 | F1 9
4793981 | 1. Pirmas | 87.7585 | 2440.5 | F1 9
4852724 | 1. Pirmas | 131.831 | 2394.8 | F1 9
4875860 | 1. Pirmas | 56.8306 | 2479.8 | F1 4 (3)
5053886 | 1. Pirmas | 192 | 2230 | F1 3
5054006 | 1. Pirmas | 4.00979 | 2175.8 | F1 3
5054101 | 1. Pirmas | 169.795 | 2309.2 | F1 3
5054187 | 1. Pirmas | 84.7954 | 2180.8 | F1 3
5325471 | 1. Pirmas | 84.1 | 2076.9 | F1 3
5325642 | 1. Pirmas | 5.5 | 2099.1 | F1 3
5326238 | 1. Pirmas | 166.5 | 1917.8 | F1 3

# IfcFlowTerminal: 9320008 350 0:Tece Pisuaro remas (2)
Type - Material: RGBA(175,175,175,255), RGBA(174,49,30,255)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tece
Pset_DistributionFlowElementCommon - Reference: Tece Pisuaro remas; sets with these values: 2
Name (9320008 350 0:Tece Pisuaro remas:...) | In | Group
4747280 | 0. Cokolinis Vandentiekis | Other 2; F1 3 (6)
4754139 | -1 Baseino dugnas | Other 3; F1 3 (5)

# IfcFlowTerminal: Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm_PRO_100825:111.300.00.5 Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm (10)
Type - Description: Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm; PredefinedType: CISTERN; Material: Geberit, PE-HD, Black, Geberit, Plastic, Opaque white, Geberit, Laminate, Ivory, Matte, Geberit, Steel, galvanized, Geberit, Steel, Paint Finish, Blue, Laminate, Navy
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm
Pset_DistributionFlowElementCommon - Reference: 111.300.00.5 Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm; sets with these values: 2
Name (Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm_PRO_100825:111.300.00.5 Geberit Duofix rėmas pakabinamam WC puodui, 112 cm, su Sigma potinkiniu bakeliu 12 cm:...) | In
4714504 | 0. Cokolinis Vandentiekis
4718681 | 0. Cokolinis Vandentiekis
4718716 | 0. Cokolinis Vandentiekis
4778424 | 0. Cokolinis Vandentiekis
4785265 | 1. Pirmas
4786506 | 1. Pirmas
4793497 | 1. Pirmas
4794379 | 1. Pirmas
4845147 | 1. Pirmas
4872543 | 1. Pirmas

# IfcFlowTerminal: HL_Balkon und Terrassenablauf_HL5100TG-A-200505:HL_Balkon und Terrassenablauf_HL5100TG (3)
In: Pirmo aukšto antresolė
Type - Material: <Unnamed>, Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Uniformat (Uniformat); Material: Plactic - Black, Plactic - Gray, Plactic - White; Group: L1 1
Pset_DistributionFlowElementCommon - Reference: HL_Balkon und Terrassenablauf_HL5100TG; sets with these values: 2
Name (HL_Balkon und Terrassenablauf_HL5100TG-A-200505:HL_Balkon und Terrassenablauf_HL5100TG:...)
4702333
4702904
5045367

# IfcFlowTerminal: HL_Floor drain_HL510NG-B_V21_240612:HL510NG (11)
Type - Material: Stainless Steel, Plactic - Gray, Plactic - White, Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Pset_DistributionFlowElementCommon - Reference: HL510NG; sets with these values: 2
Name (HL_Floor drain_HL510NG-B_V21_240612:HL510NG:...) | In | Group
4837101 | 1. Pirmas | F1 9
4837611 | 1. Pirmas | F1 9
4838888 | 0. Cokolinis Vandentiekis | F1 3 (4)
4853992 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4879710 | 1. Pirmas | F1 9
4880024 | 1. Pirmas | F1 9
4890632 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5272979 | 1. Pirmas | F1 2
5383912 | 1. Pirmas | F1 9
5384472 | 1. Pirmas | F1 4 (1)
5399122 | 1. Pirmas | F1 9

# IfcFlowTerminal: IS_Contour21_A4129_3DPL_GB_BIM:A4129AA - Contour 21 Lever Operated Concealed Thermostatic Mixer, IS_Contour21_A4129_3DPL_GB_BIM:A4129AA - Contour 21 Lever Operated Concealed Thermostatic Mixer:5374631
In: 1. Pirmas
Type - Material: Polished, <Unnamed>
Type - Pset_ManufacturerOccurrence - SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: A4129AA; Manufacturer: Productinfo@thebluebook.co.uk
Type - Pset_ProductRequirements - Name: SHOWERS_Contour21_LeverOpConcealedThermoMixer-A4129; Category: n/a
Type - Pset_QuantityTakeOff - Reference: n/a
Classification: C1030200 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2

# IfcFlowTerminal: PF_PE_UN_Xtrapoint_ACO:Xtrapoint with GS grate (6)
In: 0. Cokolinis Vandentiekis
Type - Description: Xtrapoint; PredefinedType: USERDEFINED; Material: Plastic, galvanised steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: Xtrapoint with GS grate; sets with these values: 2
Name (PF_PE_UN_Xtrapoint_ACO:Xtrapoint with GS grate:...) | Group
5331406 | L1 3
5334429 | L1 4
5385279 | L1 6
5385812 | L1 2
5385819 | L1 2
5424398 | L1 7

# IfcFlowTerminal: PRD_AR_Shlvs_MaximaShelfForCommercialSinks_MAXT:MAXT120-70, PRD_AR_Shlvs_MaximaShelfForCommercialSinks_MAXT:MAXT120-70:5053528
In: 1. Pirmas
Type - Material: PRD_AR_StainlessSteel_SatinFinished
Type - Pset_ElementShading - Color: stainless steel
Type - Pset_ManufacturerTypeInformation - ModelReference: MAXT120-70; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Maxima shelve for sinks width 1200 mm / depth 700 mm
Pset_DistributionFlowElementCommon - Reference: MAXT120-70; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a

# IfcFlowTerminal: PRD_AR_SnksSuprts_MaximaUnderframeToCommercialSinks_MAXF:MAXF120-70, PRD_AR_SnksSuprts_MaximaUnderframeToCommercialSinks_MAXF:MAXF120-70:5053527
In: 1. Pirmas
Type - Material: PRD_AR_StainlessSteel_SatinFinished
Type - Pset_ElementShading - Color: stainless steel
Type - Pset_ManufacturerTypeInformation - ModelReference: MAXF120-70; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Underframe to Maxima sinks width 1200 mm / depth 700 mm
Type - Pset_QuantityTakeOff - Reference: n/a
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a

# IfcFlowTerminal: PRD_AR_Snks_MaximaCommercialSink_MAXL200-120:MAXL200-120, PRD_AR_Snks_MaximaCommercialSink_MAXL200-120:MAXL200-120:5053526
In: 1. Pirmas
Type - PredefinedType: SINK; Material: PRD_AR_StainlessSteel_SatinFinished
Type - Pset_ElementShading - Color: stainless steel
Type - Pset_ManufacturerTypeInformation - ModelReference: MAXL200-120; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Maxima catering sink MAXL200-120
Type - Pset_SanitaryTerminalTypeSink - SinkType: Rinsing; NominalWidth: 1200 mm; NominalDepth: 700 mm; Color: stainless steel
Pset_DistributionFlowElementCommon - Reference: MAXL200-120; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Group: F1 3

# IfcFlowTerminal: Plumbing-Urinals-Sloan-Valve-HYB-4000:Pisuaras (2)
In: -1 Baseino dugnas
Type - Material: Sloan Valve - Finish - Stainless Steel, Sloan Valve - Plastic - White, Sloan Valve - Vitreous China - White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Sloan Valve
Classification: D2010 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pisuaras; sets with these values: 2
Name (Plumbing-Urinals-Sloan-Valve-HYB-4000:Pisuaras:...)
4722353
4722514 | Group: F1 1; Other 1

# IfcFlowTerminal: Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 (4)
In: 1. Pirmas
Type - Material: Steel - Global Drain Technologies - Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Global Drain Techologies
Classification: D2030300 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: LTF60C5-102; sets with these values: 2
Name (Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102:...)
4942450
4960285
4982762
4982764

# IfcFlowTerminal: Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 100cm (4)
In: 1. Pirmas
Type - Material: Steel - Global Drain Technologies - Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Global Drain Techologies
Classification: D2030300 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: LTF60C5-102 100cm; sets with these values: 2
Name (Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 100cm:...)
5008372
5009803
5010432
5010572

# IfcFlowTerminal: Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 200cm (8)
In: 1. Pirmas
Type - Material: Steel - Global Drain Technologies - Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Global Drain Techologies
Classification: D2030300 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: LTF60C5-102 200cm; sets with these values: 2
Name (Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 200cm:...)
4944068
4982651
4982672
4982691
4982769
4982770
4992493
5009925

# IfcFlowTerminal: Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 300cm (4)
In: 1. Pirmas
Type - Material: Steel - Global Drain Technologies - Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Global Drain Techologies
Classification: D2030300 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: LTF60C5-102 300cm; sets with these values: 2
Name (Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 300cm:...)
5009675
5010054
5010219
5010252

# IfcFlowTerminal: Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 50cm (3)
In: 1. Pirmas
Type - Material: Steel - Global Drain Technologies - Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Global Drain Techologies
Classification: D2030300 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: LTF60C5-102 50cm; sets with these values: 2
Name (Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 50cm:...)
4982763
5010312
5010483

# IfcFlowTerminal: Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 600cm, Plumbing_Drainage_Global-Drain-Trechnologies_Landscape-Flat Bottom Trench Drain:LTF60C5-102 600cm:5009985
In: 1. Pirmas
Type - Material: Steel - Global Drain Technologies - Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Global Drain Techologies
Classification: D2030300 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: LTF60C5-102 600cm; sets with these values: 2

# IfcFlowTerminal: Plumbing_Drainage_Menzies-Metal_Spun-Aluminum-Value-Drain-TPO:4" (24)
Type - Material: Metal - Menzies Metal Products - Stainless Steel, Metal - Menzies Metal Products - Aluminum
Type - Pset_ManufacturerTypeInformation - Manufacturer: Menzies Metal Products
Classification: D2040200 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 4"; sets with these values: 2
Name (Plumbing_Drainage_Menzies-Metal_Spun-Aluminum-Value-Drain-TPO:4":...) | In | Group
4647952 | Stogo ilaju aukštas | L1 2
4651617 | Stogo ilaju aukštas | L1 2
4652182 | Stogo ilaju aukštas | L1 2
4652455 | Stogo ilaju aukštas | L1 2
4652520 | Stogo ilaju aukštas | L1 2
4652616 | Stogo ilaju aukštas | L1 2
4652938 | Stogo ilaju aukštas | L1 1
4653022 | Stogo ilaju aukštas | L1 1
4653123 | Stogo ilaju aukštas | L1 1
4653200 | Stogo ilaju aukštas | L1 1
4653279 | Stogo ilaju aukštas | L1 1
4653329 | Stogo ilaju aukštas | L1 1
4653369 | Stogo ilaju aukštas | L1 1
4663987 | Pirmo aukšto antresolė
4666271 | 1. Pirmas
4666278 | 1. Pirmas | L1 2
4684699 | 1. Pirmas | L1 2
4684725 | 1. Pirmas | L1 1
4684783 | 1. Pirmas | L1 1
4685650 | 1. Pirmas | L1 1
4703785 | Pirmo aukšto antresolė | L1 1
4704193 | Pirmo aukšto antresolė | L1 1
4704460 | Pirmo aukšto antresolė | L1 1
5363167 | Stogo ilaju aukštas | L1 2

# IfcFlowTerminal: Sanitary_Basins_Ceramica-Globo_T-EDGE-Basin-B6R62:Default (9)
Type - Material: Glossy White BI 32FE5085
Pset_DistributionFlowElementCommon - Reference: Default; sets with these values: 2
Name (Sanitary_Basins_Ceramica-Globo_T-EDGE-Basin-B6R62:Default:...) | In
4746727 | 0. Cokolinis Vandentiekis
4787486 | 1. Pirmas
4791721 | 1. Pirmas
4791756 | 1. Pirmas
4793789 | 1. Pirmas
4794384 | 1. Pirmas
4846506 | 1. Pirmas
4888284 | 1. Pirmas
5102846 | 1. Pirmas

# IfcFlowTerminal: Sanitary_Basins_Sanindusa_Look-Semi-Recessed-Washbasin:SanindusaLavatório134360004 (3)
Type - Material: <Unnamed>
Type - Pset_ElementShading - Color: white
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: Look; Manufacturer: Sanindusa; ProductionYear: 2017
Type - Pset_ProductRequirements - Name: Look 83x47 semi-recessed
Pset_DistributionFlowElementCommon - Reference: SanindusaLavatório134360004; sets with these values: 2
Name (Sanitary_Basins_Sanindusa_Look-Semi-Recessed-Washbasin:SanindusaLavatório134360004:...) | In
4741252 | 0. Cokolinis Vandentiekis
4741440 | -1 Baseino dugnas
5388167 | 0. Cokolinis Vandentiekis

# IfcFlowTerminal: Sanitary_Toilets_Roca_347687xx0-ONA-Back-to-wall-vitreous-china close-coupled-WC-with-dual-outlet:Įleidžiamas unitazas (10)
Type - Material: F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Roca
Pset_DistributionFlowElementCommon - Reference: Įleidžiamas unitazas; sets with these values: 2
Name (Sanitary_Toilets_Roca_347687xx0-ONA-Back-to-wall-vitreous-china close-coupled-WC-with-dual-outlet:Įleidžiamas unitazas:...) | In
4714503 | 0. Cokolinis Vandentiekis
4718680 | 0. Cokolinis Vandentiekis
4718715 | 0. Cokolinis Vandentiekis
4845243 | 1. Pirmas
4845329 | 1. Pirmas
4845352 | 1. Pirmas
4845409 | 1. Pirmas
4845434 | 1. Pirmas
4890924 | 1. Pirmas
5343848 | 0. Cokolinis Vandentiekis | Group: F1 2 (1) (1) (1) (1) (1); Other 4

# IfcFlowTerminal: Trench_Drain-Blucher-BTS:BTS (11)
In: 1. Pirmas
Type - Material: Metal-Blucher-304-Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Blucher
Classification: D2040100 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: BTS; sets with these values: 2
Pset_DuctConnection - ConnectionType: Spigot Connection; sets with these values: 2
Name (Trench_Drain-Blucher-BTS:BTS:...) | Group
4900782 | F1 palubėje 15
4901107 | F1 palubėje 15
4968174 | F1 palubėje 15
4968554 | F1 9
4982705 | F1 palubėje 11
4982761 | F1 palubėje 20
4982765 | F1 palubėje 20
4982768 | F1 palubėje 11
4992426 | F1 palubėje 11
5009865 | F1 palubėje 20
5010360 | F1 palubėje 15

# IfcFlowTerminal: ZN dusas:S6960AC - Doc M Contour 21 Shower Room Pack - White, ZN dusas:S6960AC - Doc M Contour 21 Shower Room Pack - White:5374630
In: 1. Pirmas
Type - Material: Plastic White AC, Chrome, Polished, Powder Coated Aluminium White 01
Type - Pset_DuctConnection - ConnectionType: Plumbing
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerTypeInformation - ModelReference: Doc M Contour 21 Shower Room Pack; Manufacturer: Productinfo@thebluebook.co.uk
Type - Pset_PipeConnection - ConnectionType: Plumbing
Type - Pset_ProductRequirements - Name: SHOWERS_ArmitageShanks_DocMPack-S6960AC_ArmitageShanks
Classification: C1030200 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: S6960AC - Doc M Contour 21 Shower Room Pack - White; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a

# IfcFlowTerminal: Z_AIR_PVC_ Air_Releaser_Wavin_(nested):GY (3)
Type - Material: PVC - U, Grey, RAL7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: GY; sets with these values: 2
Name (Z_AIR_PVC_ Air_Releaser_Wavin_(nested):GY:...) | In
5094635 | 1. Pirmas
5094804 | 0. Cokolinis Vandentiekis
5095130 | 1. Pirmas

# IfcFlowTerminal: ŽN unitazas1:ŽN unitazas su porankiais - B C tipas, ŽN unitazas1:ŽN unitazas su porankiais - B C tipas:4734389
In: 0. Cokolinis Vandentiekis
Type - Material: Default - Bathroom Fixture
Type - Pset_ManufacturerTypeInformation - Manufacturer: DP metu
Pset_DistributionFlowElementCommon - Reference: ŽN unitazas su porankiais - B C tipas; sets with these values: 2
