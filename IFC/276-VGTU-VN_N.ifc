Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcFlowFitting: Geberit elektrinio suvirinimo mova_PRO_101612:DN40-150 / ø40-160 - OD (6)
Type - Description: Geberit elektrinio suvirinimo mova; PredefinedType: CONNECTOR; Material: GEB_PE100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit elektrinio suvirinimo mova
Pset_DistributionFlowElementCommon - Reference: DN40-150 / ø40-160 - OD; sets with these values: 2
Name (Geberit elektrinio suvirinimo mova_PRO_101612:DN40-150 / ø40-160 - OD:...) | In | Group
5042519 | 1. Pirmas | L1 1
5059939 | Stogo ilaju aukštas | L1 2
5065193 | Pirmo aukšto antresolė | L1 2
5181596 | 1. Pirmas | L1 1
5304744 | 0. Cokolinis Vandentiekis | L1 2
5358789 | 1. Pirmas | L1 1

# IfcFlowFitting: M_Bend - PVC - Sch 40 - DWV:Standard, M_Bend - PVC - Sch 40 - DWV:Standard:5437577
In: 1. Pirmas
Type - Material: F1
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_PipeFittingTypeCommon - NominalDiameter: 50
Group: F1 2

# IfcFlowFitting: M_Bend - PVC - Sch 40 - DWV:Standard (9)
Type - Material: F1 Palube
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Bend - PVC - Sch 40 - DWV:Standard:...) | In | NominalDiameter | Group
5273204 | 1. Pirmas | 50 | F1 palubėje 11
5437436 | 1. Pirmas | 50 | F1 palubėje 11; F1 3
5437572 | 1. Pirmas | 50 | F1 palubėje 11; F1 2
5458757 | 1. Pirmas | 75 | F1 palubėje 11
5458815 | 0. Cokolinis Vandentiekis | 75 | F1 palubėje 11
5458859 | 0. Cokolinis Vandentiekis | 75 | F1 palubėje 11
5458871 | 0. Cokolinis Vandentiekis | 75 | F1 palubėje 11
5462463 | 0. Cokolinis Vandentiekis | 75 | F1 palubėje 11
5462477 | 0. Cokolinis Vandentiekis | 75 | F1 palubėje 11

# IfcFlowFitting: M_Bend - PVC - Sch 40 - DWV:Standard (43)
Type - Material: K1
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Bend - PVC - Sch 40 - DWV:Standard:...) | In | NominalDiameter | Group
5202089 | 0. Cokolinis Vandentiekis | 25 | K1 1
5202445 | 0. Cokolinis Vandentiekis | 25 | K1 1
5202467 | 0. Cokolinis Vandentiekis | 25 | K1 1
5203028 | 0. Cokolinis Vandentiekis | 25 | K1 4
5203037 | 0. Cokolinis Vandentiekis | 25 | K1 4
5203117 | 0. Cokolinis Vandentiekis | 25 | K1 4
5203125 | 0. Cokolinis Vandentiekis | 25 | K1 12
5203650 | 0. Cokolinis Vandentiekis | 25 | K1 2
5203658 | 1. Pirmas | 25 | K1 2
5203792 | 1. Pirmas | 32 | K1 2
5204472 | 1. Pirmas | 25 | K1 3
5204480 | 1. Pirmas | 25 | K1 3
5204876 | 1. Pirmas | 25 | K1 3
5204968 | 1. Pirmas | 25 | K1 5
5205230 | Pirmo aukšto antresolė | 25 | K1 5
5205892 | 1. Pirmas | 25 | K1 6
5205903 | 1. Pirmas | 25 | K1 6
5207064 | 1. Pirmas | 15 | K1 2
5207100 | 1. Pirmas | 25 | K1 2
5207179 | 1. Pirmas | 20 | K1 2
5207305 | 1. Pirmas | 20 | K1 2
5209233 | 1. Pirmas | 25 | K1 9
5209266 | 1. Pirmas | 25 | K1 9
5209268 | 1. Pirmas | 25 | K1 9
5210787 | 1. Pirmas | 25 | K1 10
5210918 | 1. Pirmas | 25 | K1 10
5211285 | 1. Pirmas | 25 | K1 9
5211381 | 1. Pirmas | 25 | K1 3
5211420 | 1. Pirmas | 25 | K1 3
5211569 | 1. Pirmas | 25 | K1 6
5211962 | 1. Pirmas | 25 | K1 2
5212116 | 1. Pirmas | 25 | K1 2
5214099 | Pirmo aukšto antresolė | 25 | K1 11
5214107 | Pirmo aukšto antresolė | 25 | K1 11
5215469 | Pirmo aukšto antresolė | 25 | K1 11
5215703 | 1. Pirmas | 25 | K1 7
5215766 | 1. Pirmas | 25 | K1 7
5216029 | 1. Pirmas | 25 | K1 7
5216088 | 1. Pirmas | 25 | K1 7
5273452 | 1. Pirmas | 25 | K1 7
5273461 | 1. Pirmas | 25 | K1 7
5273465 | 1. Pirmas | 25 | K1 7
5461099 | 1. Pirmas | 32 | K1 2

# IfcFlowFitting: M_Reducer - PVC - Sch 40 - DWV:Standard, M_Reducer - PVC - Sch 40 - DWV:Standard:5461102
In: 1. Pirmas
Type - Material: F1
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: F1 2 (1) (1) (1) (1) (1); K1 2

# IfcFlowFitting: M_Reducer - PVC - Sch 40 - DWV:Standard, M_Reducer - PVC - Sch 40 - DWV:Standard:5273207
In: 1. Pirmas
Type - Material: F1 Palube
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: F1 palubėje 11

# IfcFlowFitting: M_Reducer - PVC - Sch 40 - DWV:Standard (22)
Type - Material: K1
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Reducer - PVC - Sch 40 - DWV:Standard:...) | In | Group
5207054 | 1. Pirmas | K1 2
5207203 | 1. Pirmas | K1 2
5210764 | 1. Pirmas | K1 10
5210827 | 1. Pirmas | K1 10
5211246 | 1. Pirmas | K1 9
5211248 | 1. Pirmas | K1 9
5211297 | 1. Pirmas | K1 3
5211525 | 1. Pirmas | K1 6
5211842 | 1. Pirmas | K1 5
5211904 | 1. Pirmas | K1 2
5211906 | 1. Pirmas | K1 2
5212201 | 0. Cokolinis Vandentiekis | K1 2
5212207 | 1. Pirmas | K1 2
5212215 | 1. Pirmas | K1 7
5212239 | 0. Cokolinis Vandentiekis | K1 1
5212241 | 0. Cokolinis Vandentiekis | K1 1
5215595 | Pirmo aukšto antresolė | K1 11
5215746 | 1. Pirmas | K1 7
5273454 | 1. Pirmas | K1 7
5315514 | 0. Cokolinis Vandentiekis | K1 4
5315516 | 0. Cokolinis Vandentiekis | K1 4
5315518 | 0. Cokolinis Vandentiekis | K1 12

# IfcFlowFitting: PIF_AS+_Branch_Corner_Wavin:socket end - Diameters 110-110/90-90, PIF_AS+_Branch_Corner_Wavin:socket end - Diameters 110-110/90-90:5405121
In: -1 Baseino dugnas
Type - Description: Branch Corner; PredefinedType: JUNCTION; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: socket end - Diameters 110-110/90-90; sets with these values: 2

# IfcFlowFitting: PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023, PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023:5186463
In: 0. Cokolinis Vandentiekis
Type - Description: PVCGravitySystem Reducer; PredefinedType: CONNECTOR; Material: F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Group: F1 3 (2)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Brown RAL8023; sets with these values: 2

# IfcFlowFitting: PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023 (7)
Type - Description: PVCGravitySystem Reducer; PredefinedType: CONNECTOR; Material: F1 Palube
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Brown RAL8023; sets with these values: 2
Name (PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023:...) | In | Group
4891833 | 1. Pirmas | F1 palubėje 3
4891862 | 1. Pirmas | F1 palubėje 6
5056491 | 0. Cokolinis Vandentiekis | F1 palubėje 7
5179162 | 0. Cokolinis Vandentiekis | F1 palubėje 8
5182409 | 1. Pirmas | L1 1
5316604 | 0. Cokolinis Vandentiekis | L1 2
5461865 | 1. Pirmas | F1 2 (1) (1) (1) (1) (1)

# IfcFlowFitting: PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023 (2)
Type - Description: PVCGravitySystem Reducer; PredefinedType: CONNECTOR; Material: PVC, Brown, RAL8023, Aluminum, Anodized Red, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Brown RAL8023; sets with these values: 2
Name (PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023:...) | In | Group
5433933 | 0. Cokolinis Vandentiekis | F1 9
5448611 | Pirmo aukšto antresolė | L1 1

# IfcFlowFitting: PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023, PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023:5453496
In: 0. Cokolinis Vandentiekis
Type - Description: PVCGravitySystem Reducer; PredefinedType: CONNECTOR; Material: PVC, Brown, RAL8023, Aluminum, Anodized Red, L1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Group: L1 1
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Brown RAL8023; sets with these values: 2

# IfcFlowFitting: PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023 (11)
In: 0. Cokolinis Vandentiekis
Type - Description: PVCGravitySystem Reducer; PredefinedType: CONNECTOR; Material: PVC, Brown, RAL8023, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Brown RAL8023; sets with these values: 2
Name (PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023:...) | Group
4870543 | F1 2 (1) (1) (1) (1) (1)
4870655 | F1 2 (1) (1) (1) (1) (1)
4897358 | F1 2 (1) (1) (1) (1) (1)
4897947 | F1 2 (1) (1) (1) (1) (1)
5012373 | F1 2 (1) (1) (1) (1) (1)
5024585 | F1 2 (1) (1) (1) (1) (1)
5047532 | F1 2 (1) (1) (1) (1) (1)
5180267 | F1 2 (1) (1) (1) (1) (1)
5316606 | L1 2
5415291 | F1 2 (1) (1) (1) (1) (1)
5444732 | F1 2 (1) (1) (1) (1) (1)

# IfcFlowFitting: PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023 (5)
Type - Description: PVCGravitySystem Reducer; PredefinedType: CONNECTOR; Material: PVC, Brown, RAL8023, L1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Brown RAL8023; sets with these values: 2
Name (PIF_PVCGravitySystem_MultiReducer_Wavin:Socket End - SN4 Brown RAL8023:...) | In | Group
5045219 | Pirmo aukšto antresolė | L1 1
5047231 | Pirmo aukšto antresolė | L1 1
5180464 | 0. Cokolinis Vandentiekis | L1 1
5441184 | 0. Cokolinis Vandentiekis | L1 2
5452521 | 0. Cokolinis Vandentiekis | F1 9

# IfcFlowFitting: PIF_PVCGravitySystem_Pipe_Socket_Wavin:SN4 Brown RAL8023 Standard Socket (2)
Type - Description: PVCGravitySystem Pipe Socket; PredefinedType: CONNECTOR; Material: PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SN4 Brown RAL8023 Standard Socket; sets with these values: 2
Name (PIF_PVCGravitySystem_Pipe_Socket_Wavin:SN4 Brown RAL8023 Standard Socket:...) | In | Group
5303550 | Stogo ilaju aukštas | L1 1
5335283 | 0. Cokolinis Vandentiekis | L1 3

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend) (3)
In: 0. Cokolinis Vandentiekis
Type - Description: Tee; PredefinedType: JUNCTION; Material: Aluminum, Anodized Red, F1, PVC, Orange, RAL2100, PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 45° (+ bend); sets with these values: 2
Name (PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend):...) | Group
5243734 | F1 2 (1) (1) (1) (1) (1)
5292425 | F1 9
5427102 | F1 9

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend) (2)
Type - Description: Tee; PredefinedType: JUNCTION; Material: Aluminum, Anodized Red, L1, PVC, Orange, RAL2100, PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Group: L1 1
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 45° (+ bend); sets with these values: 2
Name (PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend):...) | In
5185971 | Pirmo aukšto antresolė
5305896 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend) (37)
Type - Description: Tee; PredefinedType: JUNCTION; Material: PVC, Orange, RAL2100, PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 45° (+ bend); sets with these values: 2
Name (PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend):...) | In | Group
4778495 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4784914 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4870647 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4893767 | 0. Cokolinis Vandentiekis | F1 9
4897729 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4898899 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4899322 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5038259 | 1. Pirmas | F1 2 (1) (1) (1) (1) (1)
5057705 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5073361 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5180214 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5180364 | 0. Cokolinis Vandentiekis | L1 1
5182356 | 1. Pirmas | L1 1
5182837 | Pirmo aukšto antresolė | L1 1
5184699 | 0. Cokolinis Vandentiekis | L1 1
5292105 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5345343 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5360170 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5385620 | 0. Cokolinis Vandentiekis | L1 3
5415660 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5416062 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5418209 | 1. Pirmas | F1 9
5419249 | 0. Cokolinis Vandentiekis | F1 9
5426505 | 0. Cokolinis Vandentiekis | L1 2
5433563 | 0. Cokolinis Vandentiekis | F1 9
5438895 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5439146 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5439196 | 0. Cokolinis Vandentiekis | F1 9
5439248 | 0. Cokolinis Vandentiekis | L1 2
5439309 | 0. Cokolinis Vandentiekis | L1 2
5446671 | 1. Pirmas | L1 1
5448056 | 1. Pirmas | L1 1
5448705 | 0. Cokolinis Vandentiekis | L1 1
5452781 | 0. Cokolinis Vandentiekis | L1 1
5455535 | 0. Cokolinis Vandentiekis | F1 9
5461292 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5461810 | 1. Pirmas | F1 2 (1) (1) (1) (1) (1)

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend) (2)
Type - Description: Tee; PredefinedType: JUNCTION; Material: PVC, Orange, RAL2100, PVC, Brown, RAL8023, Aluminum, Anodized Red
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Material: Aluminum, Anodized Red, L1, PVC, Orange, RAL2100, PVC, Brown, RAL8023; Group: L1 1
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 45° (+ bend); sets with these values: 2
Name (PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend):...) | In
5185103 | Pirmo aukšto antresolė
5454167 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend), PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 45° (+ bend):5454403
In: 0. Cokolinis Vandentiekis
Type - Description: Tee; PredefinedType: JUNCTION; Material: PVC, Orange, RAL2100, PVC, Brown, RAL8023, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Material: F1, PVC, Orange, RAL2100, PVC, Brown, RAL8023; Group: F1 9
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 45° (+ bend); sets with these values: 2

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 90°, PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 90°:5424719
In: 0. Cokolinis Vandentiekis
Type - Description: Tee; PredefinedType: JUNCTION; Material: PVC, Orange, RAL2100, PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Group: L1 2
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 90°; sets with these values: 2

# IfcFlowFitting: PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 90°, PIF_PVCGravitySystem_SuperTee_Wavin:Socket End - SN4 Standard Socket - Tee 90°:5306278
In: 0. Cokolinis Vandentiekis
Type - Description: Tee; PredefinedType: JUNCTION; Material: PVC, Orange, RAL2100, PVC, Brown, RAL8023, Aluminum, Anodized Red
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat); Material: Aluminum, Anodized Red, L1, PVC, Orange, RAL2100, PVC, Brown, RAL8023; Group: L1 1
Pset_DistributionFlowElementCommon - Reference: Socket End - SN4 Standard Socket - Tee 90°; sets with these values: 2

# IfcFlowFitting: PIF_PVCGravitySystem_Super_Bend_Wavin:SN4 RAL8023 Socket End - OD 160-500 Standard gasket (50)
Type - Description: Pipe segment - double bend; PredefinedType: BEND; Material: PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SN4 RAL8023 Socket End - OD 160-500 Standard gasket; sets with these values: 2
Name (PIF_PVCGravitySystem_Super_Bend_Wavin:SN4 RAL8023 Socket End - OD 160-500 Standard gasket:...) | In | Group
4712837 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4714204 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4782506 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4784906 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4897907 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4898891 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5038227 | 1. Pirmas | F1 2 (1) (1) (1) (1) (1)
5042527 | 1. Pirmas | L1 1
5057861 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5064613 | Pirmo aukšto antresolė | L1 2
5175933 | Stogo ilaju aukštas | L1 1
5179701 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5182348 | 1. Pirmas | L1 1
5182781 | Pirmo aukšto antresolė | L1 1
5182894 | Pirmo aukšto antresolė | L1 1
5185166 | Pirmo aukšto antresolė | L1 1
5185174 | Pirmo aukšto antresolė | L1 1
5185965 | Pirmo aukšto antresolė | L1 1
5243728 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5334350 | 0. Cokolinis Vandentiekis | L1 3
5334468 | 0. Cokolinis Vandentiekis | L1 4
5345335 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5360248 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5385480 | 0. Cokolinis Vandentiekis | L1 3
5385692 | 0. Cokolinis Vandentiekis | L1 3
5412968 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5414130 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5416086 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5421398 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5423831 | 0. Cokolinis Vandentiekis | L1 2
5424666 | 0. Cokolinis Vandentiekis | L1 2
5424698 | 0. Cokolinis Vandentiekis | L1 2
5426645 | 0. Cokolinis Vandentiekis | L1 7
5435868 | 0. Cokolinis Vandentiekis | F1 9
5436117 | 0. Cokolinis Vandentiekis | F1 9
5441164 | 0. Cokolinis Vandentiekis | L1 2
5442203 | 0. Cokolinis Vandentiekis | L1 2
5444160 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5444563 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5444714 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5446159 | 1. Pirmas | F1 9
5446191 | 0. Cokolinis Vandentiekis | F1 9
5447855 | 1. Pirmas | L1 1
5448522 | 0. Cokolinis Vandentiekis | L1 1
5449316 | 0. Cokolinis Vandentiekis | L1 1
5452481 | 0. Cokolinis Vandentiekis | F1 9
5453205 | Stogo ilaju aukštas | L1 1
5453468 | 0. Cokolinis Vandentiekis | L1 1
5453827 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5461954 | 1. Pirmas | F1 2 (1) (1) (1) (1) (1)

# IfcFlowFitting: PIF_PVC_MultiReducer _Wavin:socket end Grey, PIF_PVC_MultiReducer _Wavin:socket end Grey:4876073
In: 0. Cokolinis Vandentiekis
Type - Material: F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 4 (3)
Pset_DistributionFlowElementCommon - Reference: socket end Grey; sets with these values: 2

# IfcFlowFitting: PIF_PVC_MultiReducer _Wavin:socket end Grey (2)
In: 1. Pirmas
Type - Material: PVC HT, Grey, RAL 7100, Aluminum, Anodized Red, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: socket end Grey; sets with these values: 2
Name (PIF_PVC_MultiReducer _Wavin:socket end Grey:...)
4837508
5357308

# IfcFlowFitting: PIF_PVC_MultiReducer _Wavin:socket end Grey (15)
Type - Material: PVC HT, Grey, RAL 7100, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end Grey; sets with these values: 2
Name (PIF_PVC_MultiReducer _Wavin:socket end Grey:...) | In | Group
4747086 | 0. Cokolinis Vandentiekis | F1 1
4780829 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4782319 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4782978 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4806736 | 1. Pirmas | F1 4 (1)
4818925 | 1. Pirmas | F1 9
4850364 | 1. Pirmas | F1 9
4871531 | 1. Pirmas | F1 9
4875979 | 1. Pirmas | F1 9
4876028 | 1. Pirmas | F1 9
5104054 | 0. Cokolinis Vandentiekis | F1 3 (4); F1 palubėje 17
5351576 | 1. Pirmas | F1 9
5357318 | 1. Pirmas | F1 9
5407535 | 1. Pirmas | F1 9
5409290 | 1. Pirmas | F1 9

# IfcFlowFitting: PIF_PVC_MultiReducer _Wavin:socket end White (10)
Type - Material: Polypropylene, White, RAL9010, Aluminum, Anodized Red, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end White; sets with these values: 2
Name (PIF_PVC_MultiReducer _Wavin:socket end White:...) | In | Group
4782295 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4782960 | 0. Cokolinis Vandentiekis | F1 3 (9)
4784134 | 0. Cokolinis Vandentiekis | F1 3 (10)
4791066 | 1. Pirmas | F1 9
4791119 | 1. Pirmas | F1 9
4791799 | 1. Pirmas | F1 9
4793821 | 1. Pirmas | F1 9
5054002 | 1. Pirmas | F1 3
5325453 | 1. Pirmas | F1 3
5326622 | 1. Pirmas | F1 palubėje 18

# IfcFlowFitting: PIF_PVC_MultiReducer _Wavin:socket end White (2)
In: 1. Pirmas
Type - Material: Polypropylene, White, RAL9010, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end White; sets with these values: 2
Name (PIF_PVC_MultiReducer _Wavin:socket end White:...) | Group
4852726 | F1 9
4875862 | F1 4 (3)

# IfcFlowFitting: PIF_PVC_Pipe_Socket_Wavin:PP, PIF_PVC_Pipe_Socket_Wavin:PP:5326586
In: 1. Pirmas
Type - Description: Pipe Socket; PredefinedType: CONNECTOR; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 3
Pset_DistributionFlowElementCommon - Reference: PP; sets with these values: 2

# IfcFlowFitting: PIF_PVC_Pipe_Socket_Wavin:PVC-HT, PIF_PVC_Pipe_Socket_Wavin:PVC-HT:4797909
In: 1. Pirmas
Type - Description: Pipe Socket; PredefinedType: CONNECTOR; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: PVC-HT; sets with these values: 2

# IfcFlowFitting: PIF_PVC_Super_Bend_Wavin:Grey (43)
Type - Description: Pipe segment - double bend; PredefinedType: BEND; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Grey; sets with these values: 2
Name (PIF_PVC_Super_Bend_Wavin:Grey:...) | In | Group
4749783 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4754145 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4784513 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4797132 | 1. Pirmas | F1 9
4797751 | 1. Pirmas | F1 9
4797984 | 1. Pirmas | F1 4 (1)
4806653 | 1. Pirmas | F1 4 (1)
4818917 | 1. Pirmas | F1 9
4841653 | 1. Pirmas | F1 9
4841695 | 1. Pirmas | F1 9
4847730 | 1. Pirmas | F1 4 (1)
4848876 | 1. Pirmas | F1 4 (1)
4849653 | 1. Pirmas | F1 9
4850352 | 1. Pirmas | F1 9
4850360 | 1. Pirmas | F1 9
4850390 | 1. Pirmas | F1 9
4850396 | 1. Pirmas | F1 9
4852883 | 1. Pirmas | F1 9
4871549 | 1. Pirmas | F1 9
4872267 | 0. Cokolinis Vandentiekis | F1 4 (3)
4875872 | 1. Pirmas | F1 4 (3)
4876022 | 1. Pirmas | F1 9
4889244 | 1. Pirmas | F1 9; F1 palubėje 5
5010985 | 1. Pirmas | F1 palubėje 20
5011726 | 1. Pirmas | F1 palubėje 20
5011740 | 0. Cokolinis Vandentiekis | F1 palubėje 20
5024589 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5042173 | 1. Pirmas | F1 palubėje 5
5095960 | 0. Cokolinis Vandentiekis | F1 9
5104036 | 0. Cokolinis Vandentiekis | F1 3 (4)
5351315 | 1. Pirmas | F1 9
5351568 | 1. Pirmas | F1 9
5357261 | 1. Pirmas | F1 9
5357269 | 1. Pirmas | F1 9
5390500 | 0. Cokolinis Vandentiekis | F1 9
5393848 | 1. Pirmas | F1 4 (3)
5393919 | 1. Pirmas | F1 4 (3)
5407519 | 1. Pirmas | F1 9
5408764 | 1. Pirmas | F1 9
5409282 | 1. Pirmas | F1 9
5412437 | -1 Baseino dugnas | F1 9
5412445 | 0. Cokolinis Vandentiekis | F1 9
5418201 | 1. Pirmas | F1 9

# IfcFlowFitting: PIF_PVC_Super_Bend_Wavin:White (10)
Type - Description: Pipe segment - double bend; PredefinedType: BEND; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: White; sets with these values: 2
Name (PIF_PVC_Super_Bend_Wavin:White:...) | In | Group
4782315 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4782974 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4784144 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4791078 | 1. Pirmas | F1 9
4791503 | 1. Pirmas | F1 9
4793187 | 1. Pirmas | F1 9
4794098 | 1. Pirmas | F1 9
5054525 | 1. Pirmas | F1 3
5325489 | 1. Pirmas | F1 3
5326246 | 1. Pirmas | F1 3

# IfcFlowFitting: PIF_PVC_Super_Tee _Wavin:Grey Socket End - Tee 90° (17)
Type - Description: Branch; PredefinedType: JUNCTION; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Grey Socket End - Tee 90°; sets with these values: 2
Name (PIF_PVC_Super_Tee _Wavin:Grey Socket End - Tee 90°:...) | In | Group
4814897 | 1. Pirmas | F1 9
4815032 | 1. Pirmas | F1 9
4849277 | 1. Pirmas | F1 4 (1)
4849633 | 1. Pirmas | F1 9
4850400 | 1. Pirmas | F1 9
4851462 | 1. Pirmas | F1 9
4870979 | 1. Pirmas | F1 9
4875963 | 1. Pirmas | F1 9
4880161 | 1. Pirmas | F1 9
5011797 | 1. Pirmas | F1 palubėje 20
5011818 | 1. Pirmas | F1 palubėje 20
5042181 | 0. Cokolinis Vandentiekis | F1 palubėje 5
5104004 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1); F1 palubėje 17
5351252 | 1. Pirmas | F1 9
5351448 | 1. Pirmas | F1 9
5392596 | 0. Cokolinis Vandentiekis | F1 9
5408284 | 1. Pirmas | F1 9

# IfcFlowFitting: PIF_PVC_Super_Tee _Wavin:Grey socket End - Tee 45° (+kolano), PIF_PVC_Super_Tee _Wavin:Grey socket End - Tee 45° (+kolano):5354111
In: 1. Pirmas
Type - Description: Branch; PredefinedType: JUNCTION; Material: F1, PVC HT, Grey, RAL 7100, Aluminum, Anodized Red, PVC - U, Grey, RAL7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: Grey socket End - Tee 45° (+kolano); sets with these values: 2

# IfcFlowFitting: PIF_PVC_Super_Tee _Wavin:Grey socket End - Tee 45° (+kolano) (13)
Type - Description: Branch; PredefinedType: JUNCTION; Material: PVC HT, Grey, RAL 7100, PVC - U, Grey, RAL7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Grey socket End - Tee 45° (+kolano); sets with these values: 2
Name (PIF_PVC_Super_Tee _Wavin:Grey socket End - Tee 45° (+kolano):...) | In | Group
4806897 | 1. Pirmas | F1 4 (1)
4809922 | 1. Pirmas | F1 4 (1)
4811831 | 1. Pirmas | F1 4 (1)
4817257 | 1. Pirmas | F1 9
4838003 | 1. Pirmas | F1 9
4850368 | 1. Pirmas | F1 9
4850374 | 1. Pirmas | F1 9
4850380 | 1. Pirmas | F1 9
4894019 | 1. Pirmas | F1 9
4896810 | 0. Cokolinis Vandentiekis | F1 9
5384231 | 1. Pirmas | F1 9
5384534 | 1. Pirmas | F1 4 (1)
5408789 | 1. Pirmas | F1 9

# IfcFlowFitting: PIF_PVC_Super_Tee _Wavin:White Socket End - Tee 90°, PIF_PVC_Super_Tee _Wavin:White Socket End - Tee 90°:5054305
In: 1. Pirmas
Type - Description: Branch; PredefinedType: JUNCTION; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 3
Pset_DistributionFlowElementCommon - Reference: White Socket End - Tee 90°; sets with these values: 2

# IfcFlowFitting: PIF_PVC_Super_Tee _Wavin:White socket End - Tee 45° (+kolano), PIF_PVC_Super_Tee _Wavin:White socket End - Tee 45° (+kolano):4784497
In: 0. Cokolinis Vandentiekis
Type - Description: Branch; PredefinedType: JUNCTION; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 2 (1) (1) (1) (1) (1)
Pset_DistributionFlowElementCommon - Reference: White socket End - Tee 45° (+kolano); sets with these values: 2

# IfcFlowFitting: PIF_UN_S&W PVC-HT Branch double GY_Wavin:double branch DN1=100 (2)
Type - Description: HT PVC Double branch; PredefinedType: JUNCTION; Material: PVC, Pilka, RAL7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: double branch DN1=100; sets with these values: 2
Name (PIF_UN_S&W PVC-HT Branch double GY_Wavin:double branch DN1=100:...) | In | Group
4712329 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4794872 | 1. Pirmas | F1 9

# IfcFlowFitting: Pravala:vamzdis su mova (12)
Type - Description: AS Acces pipe; PredefinedType: EXIT; Material: Polipropilena - Astolan, balta, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: vamzdis su mova; sets with these values: 2
Name (Pravala:vamzdis su mova:...) | In | Group
5279380 | 0. Cokolinis Vandentiekis | L1 1
5279592 | 0. Cokolinis Vandentiekis | L1 1
5279768 | 0. Cokolinis Vandentiekis | L1 1
5279967 | 0. Cokolinis Vandentiekis | L1 1
5280220 | 1. Pirmas | L1 1
5280795 | 0. Cokolinis Vandentiekis | L1 1
5281026 | Pirmo aukšto antresolė | L1 1
5281634 | 0. Cokolinis Vandentiekis | L1 2
5282057 | 0. Cokolinis Vandentiekis | L1 2
5445218 | Stogo ilaju aukštas | L1 1
5456253 | Stogo ilaju aukštas | L1 1
5457468 | Pirmo aukšto antresolė | L1 1

# IfcFlowFitting: Taper Concentric - Plain - CI:Perėjimas, Taper Concentric - Plain - CI:Perėjimas:5293468
In: 1. Pirmas
Type - Material: F1
Pset_DistributionFlowElementCommon - Reference: Perėjimas; sets with these values: 2
Group: F1 2 1

# IfcFlowFitting: Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard, Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard:5204872
In: 1. Pirmas
Type - Material: F1
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: F1 9; K1 3

# IfcFlowFitting: Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard (3)
Type - Material: F1 Palube
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: F1 palubėje 11
Name (Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard:...) | In
5273073 | 1. Pirmas
5273334 | 1. Pirmas
5462384 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard (9)
Type - Material: K1
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard:...) | In | Group
5202461 | 0. Cokolinis Vandentiekis | K1 1
5203727 | 1. Pirmas | K1 2
5207307 | 1. Pirmas | K1 2
5208253 | 1. Pirmas | K1 9
5210829 | 1. Pirmas | K1 10
5212038 | 1. Pirmas | K1 2
5212171 | 1. Pirmas | K1 2
5215759 | 1. Pirmas | K1 7
5437872 | 1. Pirmas | K1 7

# IfcFlowFitting: Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard (6)
Type - Material: L1
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (Tee Reducing Sanitary - PVC - Sch 40 - DWV:Standard:...) | In | Group
5203190 | 0. Cokolinis Vandentiekis | L1 1; K1 12
5205496 | Pirmo aukšto antresolė | L1 1; K1 5
5210327 | 1. Pirmas | L1 1; K1 9
5211053 | 1. Pirmas | L1 1; K1 10
5211643 | 1. Pirmas | F1 4 (1) (2); K1 6
5215481 | Pirmo aukšto antresolė | F1 palubėje 12; K1 11

# IfcFlowFitting: Trap P - PVC - Sch 40 - DWV:Standard (13)
Type - Material: F1
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (Trap P - PVC - Sch 40 - DWV:Standard:...) | In | NominalDiameter | Group
4782301 | 0. Cokolinis Vandentiekis | 50 | F1 2 (1) (1) (1) (1) (1)
4782966 | 0. Cokolinis Vandentiekis | 50 | F1 2 (1) (1) (1) (1) (1)
4784140 | 0. Cokolinis Vandentiekis | 50 | F1 2 (1) (1) (1) (1) (1)
4788295 | 1. Pirmas | 40 | F1 9
4791072 | 1. Pirmas | 50 | F1 9
4791125 | 1. Pirmas | 50 | F1 9
4791805 | 1. Pirmas | 50 | F1 9
4793827 | 1. Pirmas | 50 | F1 9
4794395 | 1. Pirmas | 40 | F1 9
4852732 | 1. Pirmas | 50 | F1 9
4875866 | 1. Pirmas | 50 | F1 4 (3)
5023828 | 0. Cokolinis Vandentiekis | 50 | F1 2 (1) (1) (1) (1) (1)
5326019 | 1. Pirmas | 50 | F1 3

# IfcFlowFitting: Trap P - PVC - Sch 40 - DWV:Standard (10)
Type - Material: K1
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_PipeFittingTypeCommon - NominalDiameter: 25
Name (Trap P - PVC - Sch 40 - DWV:Standard:...) | In | Group
5202098 | 0. Cokolinis Vandentiekis | K1 1
5205238 | Pirmo aukšto antresolė | K1 5
5210273 | 1. Pirmas | K1 9
5210941 | 1. Pirmas | K1 10
5211424 | 1. Pirmas | K1 3
5211593 | 1. Pirmas | K1 6
5211970 | 1. Pirmas | K1 2
5212124 | 1. Pirmas | K1 2
5215488 | Pirmo aukšto antresolė | K1 11
5216037 | 1. Pirmas | K1 7

# IfcFlowFitting: Wavin SiTech+ Access Piece:Pravala (22)
Type - Description: Access Pipe; PredefinedType: CONNECTOR; Material: Polypropylene, Black, RAL 9200, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pravala; sets with these values: 2
Name (Wavin SiTech+ Access Piece:Pravala:...) | In | Group
5286701 | 0. Cokolinis Vandentiekis | F1 9
5286927 | 1. Pirmas | F1 palubėje 15
5287011 | 0. Cokolinis Vandentiekis | F1 palubėje 15
5287051 | 0. Cokolinis Vandentiekis | F1 palubėje 15
5287071 | 0. Cokolinis Vandentiekis | F1 palubėje 10
5287109 | 0. Cokolinis Vandentiekis | F1 palubėje 20
5287135 | 0. Cokolinis Vandentiekis | F1 palubėje 20
5287692 | 0. Cokolinis Vandentiekis | F1 9
5287798 | 1. Pirmas | F1 9
5287956 | 1. Pirmas | F1 9
5288150 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5296583 | 1. Pirmas | F1 9
5421956 | 0. Cokolinis Vandentiekis | F1 9
5422939 | 0. Cokolinis Vandentiekis | F1 9
5423009 | 1. Pirmas | F1 9
5444969 | 0. Cokolinis Vandentiekis | F1 palubėje 11
5445040 | 0. Cokolinis Vandentiekis | F1 palubėje 11
5445086 | 0. Cokolinis Vandentiekis | F1 palubėje 11
5446279 | 0. Cokolinis Vandentiekis | F1 9
5455914 | 0. Cokolinis Vandentiekis | F1 palubėje 12
5457200 | -1 Baseino dugnas | F1 9
5457333 | 1. Pirmas | F1 9

# IfcFlowFitting: Wavin SiTech+ MultiReducer:socket end (2)
In: 1. Pirmas
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: F1 Palube
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 palubėje 11
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2
Name (Wavin SiTech+ MultiReducer:socket end:...)
5431854
5431995

# IfcFlowFitting: Wavin SiTech+ MultiReducer:socket end (3)
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: Polypropylene, Black, RAL 9200, Aluminum, Anodized Red, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2
Name (Wavin SiTech+ MultiReducer:socket end:...) | In
4789350 | 1. Pirmas
5017830 | 1. Pirmas
5031705 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Wavin SiTech+ MultiReducer:socket end (2)
In: 1. Pirmas
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: Polypropylene, Black, RAL 9200, F1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2
Name (Wavin SiTech+ MultiReducer:socket end:...)
4787746
4794387

# IfcFlowFitting: Wavin SiTech+ MultiReducer:socket end, Wavin SiTech+ MultiReducer:socket end:5017636
In: 0. Cokolinis Vandentiekis
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: Polypropylene, Black, RAL 9200, F1 Palube
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 palubėje 15
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2

# IfcFlowFitting: Wavin SiTech+ Pipe Socket:socket end (4)
In: 1. Pirmas
Type - Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2
Name (Wavin SiTech+ Pipe Socket:socket end:...) | Group
4794096 | F1 9
4842151 | F1 9
5015387 | F1 palubėje 15
5446026 | F1 9

# IfcFlowFitting: Wavin SiTech+ SuperBend1:socket end (40)
Type - Description: Pipe segment - double bend; PredefinedType: BEND; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2
Name (Wavin SiTech+ SuperBend1:socket end:...) | In | Group
4707840 | 1. Pirmas | L1 1
4712558 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4712623 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4714307 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4788358 | 1. Pirmas | F1 9
4788623 | 1. Pirmas | F1 9
4789797 | 1. Pirmas | F1 9
4794397 | 1. Pirmas | F1 9
4801194 | 0. Cokolinis Vandentiekis | F1 palubėje 12
4801277 | 0. Cokolinis Vandentiekis | F1 palubėje 12
4801305 | Pirmo aukšto antresolė | F1 palubėje 12
4883628 | 1. Pirmas | F1 palubėje 12
4884434 | 1. Pirmas | F1 palubėje 12
4885754 | 1. Pirmas | F1 palubėje 12
4888841 | 0. Cokolinis Vandentiekis | F1 9
4888849 | 0. Cokolinis Vandentiekis | F1 4 (1) (2)
4890161 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4890693 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4891349 | 0. Cokolinis Vandentiekis | F1 9
4892475 | 1. Pirmas | F1 9
4893761 | 1. Pirmas | F1 9
5011141 | 1. Pirmas | F1 palubėje 15
5011450 | 1. Pirmas | F1 palubėje 15
5011525 | 0. Cokolinis Vandentiekis | F1 palubėje 15
5095065 | Pirmo aukšto antresolė | F1 palubėje 12
5095177 | Pirmo aukšto antresolė | F1 palubėje 12
5357908 | 0. Cokolinis Vandentiekis | F1 9; F1 palubėje 12
5357945 | 1. Pirmas | F1 9
5357967 | 1. Pirmas | F1 palubėje 12
5392839 | 0. Cokolinis Vandentiekis | F1 9
5422903 | 0. Cokolinis Vandentiekis | F1 palubėje 12
5428662 | 0. Cokolinis Vandentiekis | F1 palubėje 11
5430281 | 1. Pirmas | F1 palubėje 11
5430289 | 1. Pirmas | F1 palubėje 11
5430424 | 0. Cokolinis Vandentiekis | F1 palubėje 11
5430931 | 1. Pirmas | F1 palubėje 11
5431848 | 1. Pirmas | F1 palubėje 11
5433731 | 1. Pirmas | F1 9
5434994 | 0. Cokolinis Vandentiekis | F1 palubėje 11
5436555 | 0. Cokolinis Vandentiekis | F1 palubėje 11

# IfcFlowFitting: Wavin SiTech+ SuperBend:Alkūnė 45°, Wavin SiTech+ SuperBend:Alkūnė 45°:5433737
In: 0. Cokolinis Vandentiekis
Type - Description: Pipe segment - double bend; PredefinedType: BEND; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat); Group: F1 9
Pset_DistributionFlowElementCommon - Reference: Alkūnė 45°; sets with these values: 2

# IfcFlowFitting: Wavin SiTech+ SuperTee1:Socket End - Tee 45° (+bend) (5)
Type - Description: Branch; PredefinedType: JUNCTION; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - Tee 45° (+bend); sets with these values: 2
Name (Wavin SiTech+ SuperTee1:Socket End - Tee 45° (+bend):...) | In | Group
4707697 | Pirmo aukšto antresolė | L1 1
4889890 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
5011172 | 1. Pirmas | F1 palubėje 15
5430228 | 1. Pirmas | F1 palubėje 11
5436561 | 0. Cokolinis Vandentiekis | F1 9; F1 palubėje 11

# IfcFlowFitting: Wavin SiTech+ SuperTee1:Socket End - Tee 90° (12)
Type - Description: Branch; PredefinedType: JUNCTION; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Socket End - Tee 90°; sets with these values: 2
Name (Wavin SiTech+ SuperTee1:Socket End - Tee 90°:...) | In | Group
4714254 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4789731 | 1. Pirmas | F1 9
4872341 | 0. Cokolinis Vandentiekis | F1 9
4885235 | 0. Cokolinis Vandentiekis | F1 palubėje 12
4890132 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4890685 | 0. Cokolinis Vandentiekis | F1 2 (1) (1) (1) (1) (1)
4891324 | 0. Cokolinis Vandentiekis | F1 9
5011554 | 1. Pirmas | F1 palubėje 15
5015481 | 1. Pirmas | F1 palubėje 15
5017862 | 1. Pirmas | F1 9; F1 palubėje 10
5428574 | 1. Pirmas | F1 palubėje 11
5431958 | 1. Pirmas | F1 palubėje 11

# IfcFlowFitting: Z_DO_NOT_USE_Wavin SiTech+ Bend -nested_Wavin:Alkūnė 45 (2)
In: 0. Cokolinis Vandentiekis
Type - Description: Bend; PredefinedType: JUNCTION; Material: Polypropylene, Black, RAL 9200, PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Alkūnė 45; sets with these values: 2
Name (Z_DO_NOT_USE_Wavin SiTech+ Bend -nested_Wavin:Alkūnė 45:...)
5433758
5436706

# IfcFlowFitting: Z_DO_NOT_USE_Wavin SiTech+ Bend -nested_Wavin:socket_end (66)
Type - Description: Bend; PredefinedType: JUNCTION; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket_end; sets with these values: 2
Name (Z_DO_NOT_USE_Wavin SiTech+ Bend -nested_Wavin:socket_end:...) | In
4707842 | 1. Pirmas
4712560 | 0. Cokolinis Vandentiekis
4712562 | 0. Cokolinis Vandentiekis
4712625 | 0. Cokolinis Vandentiekis
4712627 | 0. Cokolinis Vandentiekis
4714309 | 0. Cokolinis Vandentiekis
4714311 | 0. Cokolinis Vandentiekis
4788360 | 1. Pirmas
4788644 | 1. Pirmas
4788646 | 1. Pirmas
4789806 | 1. Pirmas
4789808 | 1. Pirmas
4794399 | 1. Pirmas
4801203 | 0. Cokolinis Vandentiekis
4801205 | 0. Cokolinis Vandentiekis
4801279 | 0. Cokolinis Vandentiekis
4801281 | 0. Cokolinis Vandentiekis
4801314 | Pirmo aukšto antresolė
4883630 | 1. Pirmas
4883632 | 1. Pirmas
4884436 | 1. Pirmas
4884438 | 1. Pirmas
4885756 | 1. Pirmas
4885758 | 1. Pirmas
4888843 | 0. Cokolinis Vandentiekis
4888845 | 0. Cokolinis Vandentiekis
4888851 | 0. Cokolinis Vandentiekis
4888853 | 0. Cokolinis Vandentiekis
4890182 | 0. Cokolinis Vandentiekis
4890184 | 0. Cokolinis Vandentiekis
4890695 | 0. Cokolinis Vandentiekis
4890697 | 0. Cokolinis Vandentiekis
4891358 | 0. Cokolinis Vandentiekis
4892477 | 1. Pirmas
4892479 | 1. Pirmas
4893763 | 1. Pirmas
5011143 | 1. Pirmas
5011145 | 1. Pirmas
5011454 | 1. Pirmas
5011529 | 0. Cokolinis Vandentiekis
5095067 | Pirmo aukšto antresolė
5095069 | Pirmo aukšto antresolė
5095186 | Pirmo aukšto antresolė
5095188 | Pirmo aukšto antresolė
5357910 | 0. Cokolinis Vandentiekis
5357912 | 0. Cokolinis Vandentiekis
5357947 | 1. Pirmas
5357949 | 1. Pirmas
5357976 | 1. Pirmas
5357978 | 1. Pirmas
5392848 | 0. Cokolinis Vandentiekis
5392850 | 0. Cokolinis Vandentiekis
5422905 | 0. Cokolinis Vandentiekis
5428664 | 0. Cokolinis Vandentiekis
5430283 | 1. Pirmas
5430285 | 1. Pirmas
5430291 | 1. Pirmas
5430293 | 1. Pirmas
5430426 | 0. Cokolinis Vandentiekis
5430933 | 1. Pirmas
5430935 | 1. Pirmas
5431850 | 1. Pirmas
5431852 | 1. Pirmas
5433733 | 1. Pirmas
5434996 | 0. Cokolinis Vandentiekis
5436557 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Z_DO_NOT_USE_Wavin SiTech+ Reducer long -nested_Wavin:Perėjimas (6)
Type - Description: Reducer Long; PredefinedType: TRANSITION; Material: Polypropylene, Black, RAL 9200, PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Perėjimas; sets with these values: 2
Name (Z_DO_NOT_USE_Wavin SiTech+ Reducer long -nested_Wavin:Perėjimas:...) | In
4787786 | 1. Pirmas
4789352 | 1. Pirmas
4794389 | 1. Pirmas
5017665 | 0. Cokolinis Vandentiekis
5017859 | 1. Pirmas
5031745 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Z_DO_NOT_USE_Wavin SiTech+Bend for branch -nested_Wavin:socket_end (5)
Type - Description: Bend; PredefinedType: JUNCTION; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket_end; sets with these values: 2
Name (Z_DO_NOT_USE_Wavin SiTech+Bend for branch -nested_Wavin:socket_end:...) | In
4707882 | Pirmo aukšto antresolė
4889914 | 0. Cokolinis Vandentiekis
5015014 | 1. Pirmas
5430339 | 1. Pirmas
5436650 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Z_PIF_PVCGravitySystem_BendForTee_Wavin_(nested):Orange, RAL2100 Standard Socket (73)
Type - Material: PVC, Orange, RAL2100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Orange, RAL2100 Standard Socket; sets with these values: 2
Name (Z_PIF_PVCGravitySystem_BendForTee_Wavin_(nested):Orange, RAL2100 Standard Socket:...) | In
4712855 | 0. Cokolinis Vandentiekis
4714206 | 0. Cokolinis Vandentiekis
4778499 | 0. Cokolinis Vandentiekis
4782508 | 0. Cokolinis Vandentiekis
4784908 | 0. Cokolinis Vandentiekis
4784958 | 0. Cokolinis Vandentiekis
4870651 | 0. Cokolinis Vandentiekis
4893833 | 0. Cokolinis Vandentiekis
4897773 | 0. Cokolinis Vandentiekis
4897909 | 0. Cokolinis Vandentiekis
4898893 | 0. Cokolinis Vandentiekis
4898943 | 0. Cokolinis Vandentiekis
5038245 | 1. Pirmas
5038303 | 1. Pirmas
5042529 | 1. Pirmas
5057748 | 0. Cokolinis Vandentiekis
5057879 | 0. Cokolinis Vandentiekis
5065312 | Pirmo aukšto antresolė
5073409 | 0. Cokolinis Vandentiekis
5175935 | Stogo ilaju aukštas
5179703 | 0. Cokolinis Vandentiekis
5180258 | 0. Cokolinis Vandentiekis
5182350 | 1. Pirmas
5182400 | 1. Pirmas
5182881 | Pirmo aukšto antresolė
5185147 | Pirmo aukšto antresolė
5185168 | Pirmo aukšto antresolė
5185176 | Pirmo aukšto antresolė
5186014 | Pirmo aukšto antresolė
5243730 | 0. Cokolinis Vandentiekis
5243738 | 0. Cokolinis Vandentiekis
5292149 | 0. Cokolinis Vandentiekis
5292468 | 0. Cokolinis Vandentiekis
5305939 | 0. Cokolinis Vandentiekis
5334352 | 0. Cokolinis Vandentiekis
5334470 | 0. Cokolinis Vandentiekis
5345337 | 0. Cokolinis Vandentiekis
5345387 | 0. Cokolinis Vandentiekis
5360250 | 0. Cokolinis Vandentiekis
5385482 | 0. Cokolinis Vandentiekis
5412970 | 0. Cokolinis Vandentiekis
5415702 | 0. Cokolinis Vandentiekis
5416066 | 0. Cokolinis Vandentiekis
5416088 | 0. Cokolinis Vandentiekis
5418213 | 1. Pirmas
5419293 | 0. Cokolinis Vandentiekis
5421400 | 0. Cokolinis Vandentiekis
5423833 | 0. Cokolinis Vandentiekis
5424684 | 0. Cokolinis Vandentiekis
5424700 | 0. Cokolinis Vandentiekis
5426647 | 0. Cokolinis Vandentiekis
5427144 | 0. Cokolinis Vandentiekis
5432392 | 0. Cokolinis Vandentiekis
5435886 | 0. Cokolinis Vandentiekis
5439294 | 0. Cokolinis Vandentiekis
5441166 | 0. Cokolinis Vandentiekis
5442205 | 0. Cokolinis Vandentiekis
5444565 | 0. Cokolinis Vandentiekis
5444716 | 0. Cokolinis Vandentiekis
5446177 | 1. Pirmas
5447857 | 1. Pirmas
5448524 | 0. Cokolinis Vandentiekis
5448749 | 0. Cokolinis Vandentiekis
5449318 | 0. Cokolinis Vandentiekis
5452483 | 0. Cokolinis Vandentiekis
5453470 | 0. Cokolinis Vandentiekis
5453829 | 0. Cokolinis Vandentiekis
5454171 | 0. Cokolinis Vandentiekis
5454452 | 0. Cokolinis Vandentiekis
5455539 | 0. Cokolinis Vandentiekis
5461296 | 0. Cokolinis Vandentiekis
5461854 | 1. Pirmas
5461956 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVCGravitySystem_BendForTee_Wavin_(nested):Orange, RAL2100 Standard Socket (50)
Type - Material: PVC, Orange, RAL2100, PVC, Brown, RAL8023
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Orange, RAL2100 Standard Socket; sets with these values: 2
Name (Z_PIF_PVCGravitySystem_BendForTee_Wavin_(nested):Orange, RAL2100 Standard Socket:...) | In
4712857 | 0. Cokolinis Vandentiekis
4714208 | 0. Cokolinis Vandentiekis
4782510 | 0. Cokolinis Vandentiekis
4784910 | 0. Cokolinis Vandentiekis
4897911 | 0. Cokolinis Vandentiekis
4898895 | 0. Cokolinis Vandentiekis
5038247 | 1. Pirmas
5042531 | 1. Pirmas
5057881 | 0. Cokolinis Vandentiekis
5065314 | Pirmo aukšto antresolė
5175937 | Stogo ilaju aukštas
5179705 | 0. Cokolinis Vandentiekis
5182352 | 1. Pirmas
5182799 | Pirmo aukšto antresolė
5182896 | Pirmo aukšto antresolė
5185170 | Pirmo aukšto antresolė
5185178 | Pirmo aukšto antresolė
5185967 | Pirmo aukšto antresolė
5243732 | 0. Cokolinis Vandentiekis
5334354 | 0. Cokolinis Vandentiekis
5334472 | 0. Cokolinis Vandentiekis
5345339 | 0. Cokolinis Vandentiekis
5360252 | 0. Cokolinis Vandentiekis
5385484 | 0. Cokolinis Vandentiekis
5385694 | 0. Cokolinis Vandentiekis
5412972 | 0. Cokolinis Vandentiekis
5414148 | 0. Cokolinis Vandentiekis
5416090 | 0. Cokolinis Vandentiekis
5421402 | 0. Cokolinis Vandentiekis
5423835 | 0. Cokolinis Vandentiekis
5424686 | 0. Cokolinis Vandentiekis
5424702 | 0. Cokolinis Vandentiekis
5426649 | 0. Cokolinis Vandentiekis
5435888 | 0. Cokolinis Vandentiekis
5436135 | 0. Cokolinis Vandentiekis
5441168 | 0. Cokolinis Vandentiekis
5442207 | 0. Cokolinis Vandentiekis
5444162 | 0. Cokolinis Vandentiekis
5444567 | 0. Cokolinis Vandentiekis
5444718 | 0. Cokolinis Vandentiekis
5446179 | 1. Pirmas
5446193 | 0. Cokolinis Vandentiekis
5447859 | 1. Pirmas
5448526 | 0. Cokolinis Vandentiekis
5449320 | 0. Cokolinis Vandentiekis
5452485 | 0. Cokolinis Vandentiekis
5453207 | Stogo ilaju aukštas
5453472 | 0. Cokolinis Vandentiekis
5453831 | 0. Cokolinis Vandentiekis
5461958 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVCGravitySystem_Reducer_Long_Wavin_(nested):SN4, Orange RAL2100 (17)
Type - Description: PVCGravitySystem Reducer long; PredefinedType: TRANSITION; Material: PVC, Orange, RAL2100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SN4, Orange RAL2100; sets with these values: 2
Name (Z_PIF_PVCGravitySystem_Reducer_Long_Wavin_(nested):SN4, Orange RAL2100:...) | In
5180483 | 0. Cokolinis Vandentiekis
5186016 | Pirmo aukšto antresolė
5243740 | 0. Cokolinis Vandentiekis
5292470 | 0. Cokolinis Vandentiekis
5305941 | 0. Cokolinis Vandentiekis
5306323 | 0. Cokolinis Vandentiekis
5415293 | 0. Cokolinis Vandentiekis
5433978 | 0. Cokolinis Vandentiekis
5434024 | 0. Cokolinis Vandentiekis
5441186 | 0. Cokolinis Vandentiekis
5444734 | 0. Cokolinis Vandentiekis
5448652 | Pirmo aukšto antresolė
5448654 | Pirmo aukšto antresolė
5452523 | 0. Cokolinis Vandentiekis
5453540 | 0. Cokolinis Vandentiekis
5454173 | 0. Cokolinis Vandentiekis
5454481 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Z_PIF_PVCGravitySystem_Reducer_Long_Wavin_(nested):SN8, Orange RAL2100 (11)
Type - Description: PVCGravitySystem Reducer long; PredefinedType: TRANSITION; Material: PVC, Orange, RAL2100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SN8, Orange RAL2100; sets with these values: 2
Name (Z_PIF_PVCGravitySystem_Reducer_Long_Wavin_(nested):SN8, Orange RAL2100:...) | In
4870578 | 0. Cokolinis Vandentiekis
4870657 | 0. Cokolinis Vandentiekis
4897392 | 0. Cokolinis Vandentiekis
4897949 | 0. Cokolinis Vandentiekis
5012375 | 0. Cokolinis Vandentiekis
5024587 | 0. Cokolinis Vandentiekis
5045221 | Pirmo aukšto antresolė
5047266 | Pirmo aukšto antresolė
5047534 | 0. Cokolinis Vandentiekis
5180269 | 0. Cokolinis Vandentiekis
5316608 | 0. Cokolinis Vandentiekis

# IfcFlowFitting: Z_PIF_PVC_Bend_For_Branch_Wavin_(nested):grey (14)
Type - Description: Bend; PredefinedType: JUNCTION; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: grey; sets with these values: 2
Name (Z_PIF_PVC_Bend_For_Branch_Wavin_(nested):grey:...) | In
4807033 | 1. Pirmas
4812273 | 1. Pirmas
4812326 | 1. Pirmas
4817468 | 1. Pirmas
4838153 | 1. Pirmas
4850372 | 1. Pirmas
4850384 | 1. Pirmas
4850386 | 1. Pirmas
4894121 | 1. Pirmas
4896838 | 0. Cokolinis Vandentiekis
5354589 | 1. Pirmas
5384259 | 1. Pirmas
5384613 | 1. Pirmas
5422430 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVC_Bend_For_Branch_Wavin_(nested):white, Z_PIF_PVC_Bend_For_Branch_Wavin_(nested):white:4784605
In: 0. Cokolinis Vandentiekis
Type - Description: Bend; PredefinedType: JUNCTION; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: white; sets with these values: 2

# IfcFlowFitting: Z_PIF_PVC_Bend_Wavin_(nested):Grey (74)
Type - Description: Bend; PredefinedType: JUNCTION; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Grey; sets with these values: 2
Name (Z_PIF_PVC_Bend_Wavin_(nested):Grey:...) | In
4749785 | 0. Cokolinis Vandentiekis
4749787 | 0. Cokolinis Vandentiekis
4754147 | 0. Cokolinis Vandentiekis
4754149 | 0. Cokolinis Vandentiekis
4784515 | 0. Cokolinis Vandentiekis
4784517 | 0. Cokolinis Vandentiekis
4797153 | 1. Pirmas
4797155 | 1. Pirmas
4797753 | 1. Pirmas
4797986 | 1. Pirmas
4806662 | 1. Pirmas
4818919 | 1. Pirmas
4818921 | 1. Pirmas
4841655 | 1. Pirmas
4841657 | 1. Pirmas
4841697 | 1. Pirmas
4841699 | 1. Pirmas
4847753 | 1. Pirmas
4848899 | 1. Pirmas
4849655 | 1. Pirmas
4849657 | 1. Pirmas
4850354 | 1. Pirmas
4850362 | 1. Pirmas
4850392 | 1. Pirmas
4850398 | 1. Pirmas
4852887 | 1. Pirmas
4871551 | 1. Pirmas
4871553 | 1. Pirmas
4872269 | 0. Cokolinis Vandentiekis
4875874 | 1. Pirmas
4876024 | 1. Pirmas
4876026 | 1. Pirmas
4889246 | 1. Pirmas
4889248 | 1. Pirmas
5011006 | 1. Pirmas
5011008 | 1. Pirmas
5011728 | 1. Pirmas
5011730 | 1. Pirmas
5011742 | 0. Cokolinis Vandentiekis
5011744 | 0. Cokolinis Vandentiekis
5024591 | 0. Cokolinis Vandentiekis
5024593 | 0. Cokolinis Vandentiekis
5042175 | 1. Pirmas
5042177 | 1. Pirmas
5095962 | 0. Cokolinis Vandentiekis
5095964 | 0. Cokolinis Vandentiekis
5104038 | 0. Cokolinis Vandentiekis
5104040 | 0. Cokolinis Vandentiekis
5351317 | 1. Pirmas
5351319 | 1. Pirmas
5351570 | 1. Pirmas
5351572 | 1. Pirmas
5357263 | 1. Pirmas
5357265 | 1. Pirmas
5357293 | 1. Pirmas
5357295 | 1. Pirmas
5390502 | 0. Cokolinis Vandentiekis
5390504 | 0. Cokolinis Vandentiekis
5393850 | 1. Pirmas
5393852 | 1. Pirmas
5393921 | 1. Pirmas
5393923 | 1. Pirmas
5407528 | 1. Pirmas
5407530 | 1. Pirmas
5408768 | 1. Pirmas
5408770 | 1. Pirmas
5409284 | 1. Pirmas
5409286 | 1. Pirmas
5412439 | -1 Baseino dugnas
5412441 | -1 Baseino dugnas
5412447 | 0. Cokolinis Vandentiekis
5412449 | 0. Cokolinis Vandentiekis
5418203 | 1. Pirmas
5418205 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVC_Bend_Wavin_(nested):White (12)
Type - Description: Bend; PredefinedType: JUNCTION; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: White; sets with these values: 2
Name (Z_PIF_PVC_Bend_Wavin_(nested):White:...) | In
4782317 | 0. Cokolinis Vandentiekis
4782976 | 0. Cokolinis Vandentiekis
4784146 | 0. Cokolinis Vandentiekis
4791080 | 1. Pirmas
4791507 | 1. Pirmas
4793189 | 1. Pirmas
4793191 | 1. Pirmas
4794102 | 1. Pirmas
5054527 | 1. Pirmas
5054529 | 1. Pirmas
5325493 | 1. Pirmas
5326250 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVC_Reducer_Long_Wavin_(nested):Grey (19)
Type - Description: Reducer long; PredefinedType: TRANSITION; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Grey; sets with these values: 2
Name (Z_PIF_PVC_Reducer_Long_Wavin_(nested):Grey:...) | In
4747088 | 0. Cokolinis Vandentiekis
4780859 | 0. Cokolinis Vandentiekis
4806762 | 1. Pirmas
4818951 | 1. Pirmas
4837510 | 1. Pirmas
4850366 | 1. Pirmas
4871533 | 1. Pirmas
4876005 | 1. Pirmas
4876007 | 1. Pirmas
4876030 | 1. Pirmas
4876032 | 1. Pirmas
4876100 | 0. Cokolinis Vandentiekis
5104094 | 0. Cokolinis Vandentiekis
5351578 | 1. Pirmas
5354797 | 1. Pirmas
5357310 | 1. Pirmas
5357340 | 1. Pirmas
5407537 | 1. Pirmas
5409292 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVC_Reducer_Long_Wavin_(nested):White (12)
Type - Description: Reducer long; PredefinedType: TRANSITION; Material: Polypropylene, White, RAL9010
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: White; sets with these values: 2
Name (Z_PIF_PVC_Reducer_Long_Wavin_(nested):White:...) | In
4782297 | 0. Cokolinis Vandentiekis
4782962 | 0. Cokolinis Vandentiekis
4784136 | 0. Cokolinis Vandentiekis
4791068 | 1. Pirmas
4791121 | 1. Pirmas
4791801 | 1. Pirmas
4793823 | 1. Pirmas
4852728 | 1. Pirmas
4875864 | 1. Pirmas
5054004 | 1. Pirmas
5325455 | 1. Pirmas
5326624 | 1. Pirmas

# IfcFlowFitting: Z_PIF_PVC_Reducer_Short_Wavin_(nested):Grey (2)
In: 0. Cokolinis Vandentiekis
Type - Description: Reducer Short; PredefinedType: TRANSITION; Material: PVC HT, Grey, RAL 7100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Grey; sets with these values: 2
Name (Z_PIF_PVC_Reducer_Short_Wavin_(nested):Grey:...)
4782321
4782980

# IfcFlowSegment: Pipe Types:BERSnl_52_PI_UN_Wavin_PVCGravitySystem, Brown, RAL8023 - SN4 Socket End - OD 110-500, Standard gasket (163)
Type - Material: L1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Classification: 90.52 Uniformat (Uniformat)
