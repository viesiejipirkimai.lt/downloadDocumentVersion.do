Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcDistributionPort (2718)
Name | FlowDirection | Group
Port_5180424_0 | SOURCEANDSINK | L1 1
Port_5180364_3 | SOURCEANDSINK | L1 1
Port_5306279_0 | SOURCEANDSINK | L1 1
Port_5180424_1 | SOURCEANDSINK | L1 1
Port_5180464_2 | SOURCEANDSINK | L1 1
InPort_5210328_0 | SINK | L1 1
OutPort_5181211_2 | SOURCE | L1 1
Port_5181216_0 | SOURCEANDSINK | L1 1
Port_5181596_2 | SOURCEANDSINK | L1 1
Port_5181216_1 | SOURCEANDSINK | L1 1
Port_5182348_1 | SOURCEANDSINK | L1 1
Port_5181596_1 | SOURCEANDSINK | L1 1
Port_5209973_1 | SOURCEANDSINK | L1 1
Port_5181866_0 | SOURCEANDSINK | L1 1
Port_5182348_2 | SOURCEANDSINK | L1 1
Port_5181866_1 | SOURCEANDSINK | L1 1
Port_5182409_2 | SOURCEANDSINK | L1 1
Port_5182264_0 | SOURCEANDSINK | L1 1
Port_5448611_2 | SOURCEANDSINK | L1 1
Port_5182264_1 | SOURCEANDSINK | L1 1
Port_5182837_1 | SOURCEANDSINK | L1 1
Port_5182356_1 | SOURCEANDSINK | L1 1
Port_5448706_0 | SOURCEANDSINK | L1 1
InPort_5182356_2 | SINK | L1 1
OutPort_5183781_0 | SOURCE | L1 1
Port_5182356_3 | SOURCEANDSINK | L1 1
Port_5182409_1 | SOURCEANDSINK | L1 1
InPort_5182781_1 | SINK | L1 1
OutPort_5182676_1 | SOURCE | L1 1
InPort_5182773_0 | SINK | L1 1
OutPort_5182781_2 | SOURCE | L1 1
InPort_5182894_1 | SINK | L1 1
OutPort_5182773_1 | SOURCE | L1 1
InPort_5182837_3 | SINK | L1 1
OutPort_5182803_0 | SOURCE | L1 1
InPort_5182803_1 | SINK | L1 1
OutPort_5182894_2 | SOURCE | L1 1
Port_5182837_2 | SOURCEANDSINK | L1 1
Port_5182838_1 | SOURCEANDSINK | L1 1
Port_5182838_0 | SOURCEANDSINK | L1 1
Port_5448705_1 | SOURCEANDSINK | L1 1
Port_5183029_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415291_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5183029_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415660_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5183781_1 | SINK | L1 1
OutPort_5448056_1 | SOURCE | L1 1
Port_5184562_0 | SOURCEANDSINK | L1 1
Port_5305896_1 | SOURCEANDSINK | L1 1
Port_5184562_1 | SOURCEANDSINK | L1 1
Port_5184699_1 | SOURCEANDSINK | L1 1
Port_5305897_0 | SOURCEANDSINK | L1 1
Port_5184699_2 | SOURCEANDSINK | L1 1
Port_5307108_1 | SOURCEANDSINK | L1 1
InPort_5185061_0 | SINK | L1 1
OutPort_5203198_2 | SOURCE | L1 1
InPort_5185103_3 | SINK | L1 1
OutPort_5185101_0 | SOURCE | L1 1
InPort_5185101_1 | SINK | L1 1
OutPort_5185174_1 | SOURCE | L1 1
Port_5185103_1 | SOURCEANDSINK | L1 1
Port_5185104_1 | SOURCEANDSINK | L1 1
Port_5185103_2 | SOURCEANDSINK | L1 1
Port_5448611_1 | SOURCEANDSINK | L1 1
Port_5185104_0 | SOURCEANDSINK | L1 1
Port_5454167_2 | SOURCEANDSINK | L1 1
Port_5185971_1 | SOURCEANDSINK | L1 1
Port_5185972_1 | SOURCEANDSINK | L1 1
Port_5185971_2 | SOURCEANDSINK | L1 1
Port_5454168_0 | SOURCEANDSINK | L1 1
Port_5185972_0 | SOURCEANDSINK | L1 1
Port_5306278_2 | SOURCEANDSINK | L1 1
Port_5186463_1 | SOURCEANDSINK | F1 3 (2)
Port_5186463_2 | SOURCEANDSINK | F1 3 (2)
OutPort_5191658_12 | SOURCE
OutPort_5191658_14 | SOURCE
OutPort_5191658_15 | SOURCE
InPort_5191658_16 | SINK
OutPort_5191658_17 | SOURCE
InPort_5191658_18 | SINK | K1 9
OutPort_5211246_1 | SOURCE | K1 9
Port_5191658_19 | SOURCEANDSINK
Port_5191658_20 | SOURCEANDSINK
OutPort_5193082_12 | SOURCE
OutPort_5193082_14 | SOURCE
OutPort_5193082_15 | SOURCE
InPort_5193082_16 | SINK
OutPort_5193082_17 | SOURCE
InPort_5193082_18 | SINK | K1 10
OutPort_5210764_1 | SOURCE | K1 10
Port_5193082_19 | SOURCEANDSINK
Port_5193082_20 | SOURCEANDSINK
OutPort_5193214_12 | SOURCE
OutPort_5193214_14 | SOURCE
OutPort_5193214_15 | SOURCE
InPort_5193214_16 | SINK
OutPort_5193214_17 | SOURCE
InPort_5193214_18 | SINK | K1 9
OutPort_5211248_1 | SOURCE | K1 9
Port_5193214_19 | SOURCEANDSINK
Port_5193214_20 | SOURCEANDSINK
OutPort_5193318_12 | SOURCE
OutPort_5193318_14 | SOURCE
OutPort_5193318_15 | SOURCE
InPort_5193318_16 | SINK
OutPort_5193318_17 | SOURCE
InPort_5193318_18 | SINK | K1 10
OutPort_5210827_1 | SOURCE | K1 10
Port_5193318_19 | SOURCEANDSINK
Port_5193318_20 | SOURCEANDSINK
OutPort_5193412_12 | SOURCE
OutPort_5193412_14 | SOURCE
OutPort_5193412_15 | SOURCE
InPort_5193412_16 | SINK
OutPort_5193412_17 | SOURCE
InPort_5193412_18 | SINK | K1 6
OutPort_5211525_1 | SOURCE | K1 6
Port_5193412_19 | SOURCEANDSINK
Port_5193412_20 | SOURCEANDSINK
OutPort_5193529_12 | SOURCE
OutPort_5193529_14 | SOURCE
OutPort_5193529_15 | SOURCE
InPort_5193529_16 | SINK
OutPort_5193529_17 | SOURCE
InPort_5193529_18 | SINK | K1 5
OutPort_5211842_1 | SOURCE | K1 5
Port_5193529_19 | SOURCEANDSINK
Port_5193529_20 | SOURCEANDSINK
OutPort_5193617_12 | SOURCE
OutPort_5193617_14 | SOURCE
OutPort_5193617_15 | SOURCE
InPort_5193617_16 | SINK
OutPort_5193617_17 | SOURCE
InPort_5193617_18 | SINK | K1 2
OutPort_5207054_1 | SOURCE | K1 2
Port_5193617_19 | SOURCEANDSINK
Port_5193617_20 | SOURCEANDSINK
OutPort_5193730_12 | SOURCE
OutPort_5193730_14 | SOURCE
OutPort_5193730_15 | SOURCE
InPort_5193730_16 | SINK
OutPort_5193730_17 | SOURCE
InPort_5193730_18 | SINK | K1 2
OutPort_5207203_1 | SOURCE | K1 2
Port_5193730_19 | SOURCEANDSINK
Port_5193730_20 | SOURCEANDSINK
OutPort_5193827_12 | SOURCE
OutPort_5193827_14 | SOURCE
OutPort_5193827_15 | SOURCE
InPort_5193827_16 | SINK
OutPort_5193827_17 | SOURCE
InPort_5193827_18 | SINK | K1 7
OutPort_5212215_1 | SOURCE | K1 7
Port_5193827_19 | SOURCEANDSINK
Port_5193827_20 | SOURCEANDSINK
OutPort_5193881_12 | SOURCE
OutPort_5193881_14 | SOURCE
OutPort_5193881_15 | SOURCE
InPort_5193881_16 | SINK
OutPort_5193881_17 | SOURCE
InPort_5193881_18 | SINK | K1 7
OutPort_5215746_1 | SOURCE | K1 7
Port_5193881_19 | SOURCEANDSINK
Port_5193881_20 | SOURCEANDSINK
OutPort_5194317_12 | SOURCE
OutPort_5194317_14 | SOURCE
OutPort_5194317_15 | SOURCE
InPort_5194317_16 | SINK
OutPort_5194317_17 | SOURCE
InPort_5194317_18 | SINK | K1 11
OutPort_5215595_1 | SOURCE | K1 11
Port_5194317_19 | SOURCEANDSINK
Port_5194317_20 | SOURCEANDSINK
OutPort_5195031_12 | SOURCE
OutPort_5195031_14 | SOURCE
OutPort_5195031_15 | SOURCE
InPort_5195031_16 | SINK | Hydronic Supply 1
OutPort_5195031_17 | SOURCE
InPort_5195031_18 | SINK | K1 1
OutPort_5212239_1 | SOURCE | K1 1
Port_5195031_19 | SOURCEANDSINK
Port_5195031_20 | SOURCEANDSINK
OutPort_5195328_12 | SOURCE
OutPort_5195328_14 | SOURCE
OutPort_5195328_15 | SOURCE
InPort_5195328_16 | SINK
OutPort_5195328_17 | SOURCE
InPort_5195328_18 | SINK | K1 3
OutPort_5211297_1 | SOURCE | K1 3
Port_5195328_19 | SOURCEANDSINK
Port_5195328_20 | SOURCEANDSINK
OutPort_5195643_12 | SOURCE
OutPort_5195643_14 | SOURCE
OutPort_5195643_15 | SOURCE
InPort_5195643_16 | SINK
OutPort_5195643_17 | SOURCE
InPort_5195643_18 | SINK | K1 2
OutPort_5212207_1 | SOURCE | K1 2
Port_5195643_19 | SOURCEANDSINK
Port_5195643_20 | SOURCEANDSINK
OutPort_5197811_12 | SOURCE
OutPort_5197811_14 | SOURCE
OutPort_5197811_15 | SOURCE
InPort_5197811_16 | SINK
OutPort_5197811_17 | SOURCE
InPort_5197811_18 | SINK | K1 2
OutPort_5212201_1 | SOURCE | K1 2
Port_5197811_19 | SOURCEANDSINK
Port_5197811_20 | SOURCEANDSINK
InPort_5202461_1 | SINK | K1 1
OutPort_5198853_0 | SOURCE | K1 1
InPort_5198853_1 | SINK | K1 1
OutPort_5202089_1 | SOURCE | K1 1
InPort_5212201_2 | SINK | K1 2
OutPort_5198967_0 | SOURCE | K1 2
InPort_5198967_1 | SINK | K1 2
OutPort_5203650_2 | SOURCE | K1 2
OutPort_5199093_12 | SOURCE
OutPort_5199093_14 | SOURCE
OutPort_5199093_15 | SOURCE
InPort_5199093_16 | SINK
OutPort_5199093_17 | SOURCE
InPort_5199093_18 | SINK | K1 1
OutPort_5212241_1 | SOURCE | K1 1
Port_5199093_19 | SOURCEANDSINK
Port_5199093_20 | SOURCEANDSINK
OutPort_5201226_12 | SOURCE
OutPort_5201226_14 | SOURCE
OutPort_5201226_15 | SOURCE
InPort_5201226_16 | SINK
OutPort_5201226_17 | SOURCE
InPort_5201226_18 | SINK | K1 4
OutPort_5315514_1 | SOURCE | K1 4
Port_5201226_19 | SOURCEANDSINK
Port_5201226_20 | SOURCEANDSINK
InPort_5202089_2 | SINK | K1 1
OutPort_5202077_0 | SOURCE | K1 1
InPort_5202077_1 | SINK | K1 1
OutPort_5202098_1 | SOURCE | K1 1
InPort_5202098_2 | SINK | K1 1
OutPort_5202092_0 | SOURCE | K1 1
InPort_5202092_1 | SINK | K1 1
InPort_5212241_2 | SINK | K1 1
OutPort_5202416_0 | SOURCE | K1 1
InPort_5202416_1 | SINK | K1 1
OutPort_5202445_2 | SOURCE | K1 1
InPort_5202445_1 | SINK | K1 1
OutPort_5202426_0 | SOURCE | K1 1
InPort_5202426_1 | SINK | K1 1
OutPort_5202467_1 | SOURCE | K1 1
InPort_5202448_0 | SINK | K1 1
OutPort_5202461_3 | SOURCE | K1 1
InPort_5202467_2 | SINK | K1 1
OutPort_5202448_1 | SOURCE | K1 1
InPort_5202696_1 | SINK | K1 1
OutPort_5202461_2 | SOURCE | K1 1
InPort_5212239_2 | SINK | K1 1
OutPort_5202696_0 | SOURCE | K1 1
InPort_5315514_2 | SINK | K1 4
OutPort_5202929_0 | SOURCE | K1 4
InPort_5202929_1 | SINK | K1 4
OutPort_5203028_1 | SOURCE | K1 4
InPort_5203028_2 | SINK | K1 4
OutPort_5203020_0 | SOURCE | K1 4
InPort_5203020_1 | SINK | K1 4
OutPort_5203037_2 | SOURCE | K1 4
InPort_5203037_1 | SINK | K1 4
OutPort_5203031_0 | SOURCE | K1 4
InPort_5203031_1 | SINK | K1 4
OutPort_5203117_1 | SOURCE | K1 4
Port_5203109_0 | SOURCEANDSINK | K1 8
Port_5203109_1 | SOURCEANDSINK | K1 8
InPort_5203117_2 | SINK | K1 4
OutPort_5315516_1 | SOURCE | K1 4
InPort_5315518_1 | SINK | K1 12
OutPort_5203125_1 | SOURCE | K1 12
InPort_5203125_2 | SINK | K1 12
OutPort_5203129_0 | SOURCE | K1 12
InPort_5203129_1 | SINK | K1 12
OutPort_5203190_3 | SOURCE | K1 12
InPort_5203187_0 | SINK | L1 1
OutPort_5279967_3 | SOURCE | L1 1
InPort_5203198_1 | SINK | L1 1
OutPort_5203187_1 | SOURCE | L1 1
InPort_5279970_0 | SINK | L1 1
OutPort_5203190_1 | SOURCE | L1 1
InPort_5203190_2 | SINK | L1 1
OutPort_5203191_1 | SOURCE | L1 1
InPort_5203191_0 | SINK | L1 1
OutPort_5457468_3 | SOURCE | L1 1
InPort_5203650_1 | SINK | K1 2
OutPort_5203639_0 | SOURCE | K1 2
InPort_5203639_1 | SINK | K1 2
OutPort_5203658_2 | SOURCE | K1 2
InPort_5203727_1 | SINK | K1 2
OutPort_5203652_0 | SOURCE | K1 2
InPort_5203652_1 | SINK | K1 2
OutPort_5212116_1 | SOURCE | K1 2
InPort_5203658_1 | SINK | K1 2
OutPort_5203728_0 | SOURCE | K1 2
InPort_5203714_0 | SINK | K1 2
OutPort_5203727_3 | SOURCE | K1 2
InPort_5212207_2 | SINK | K1 2
OutPort_5203714_1 | SOURCE | K1 2
InPort_5203728_1 | SINK | K1 2
OutPort_5203727_2 | SOURCE | K1 2
InPort_5212172_0 | SINK | K1 2
OutPort_5203792_1 | SOURCE | K1 2
InPort_5203792_2 | SINK | K1 2
OutPort_5461015_0 | SOURCE | K1 2
InPort_5211297_2 | SINK | K1 3
OutPort_5204454_0 | SOURCE | K1 3
InPort_5204454_1 | SINK | K1 3
OutPort_5204472_1 | SOURCE | K1 3
InPort_5204472_2 | SINK | K1 3
OutPort_5204466_0 | SOURCE | K1 3
InPort_5204466_1 | SINK | K1 3
OutPort_5204480_2 | SOURCE | K1 3
InPort_5204480_1 | SINK | K1 3
OutPort_5204474_0 | SOURCE | K1 3
InPort_5204474_1 | SINK | K1 3
OutPort_5211381_1 | SOURCE | K1 3
InPort_5204534_0 | SINK | K1 3
OutPort_5211420_2 | SOURCE | K1 3
InPort_5211424_2 | SINK | K1 3
OutPort_5204534_1 | SOURCE | K1 3
InPort_5211420_1 | SINK | K1 3
OutPort_5204793_0 | SOURCE | K1 3
InPort_5204793_1 | SINK | K1 3
OutPort_5204876_1 | SOURCE | K1 3
InPort_5204855_0 | SINK | K1 3
OutPort_5204872_3 | SOURCE | K1 3
InPort_5204876_2 | SINK | K1 3
OutPort_5204855_1 | SOURCE | K1 3
Port_5204872_2 | SOURCEANDSINK | F1 9
Port_5204873_1 | SOURCEANDSINK | F1 9
InPort_5211842_2 | SINK | K1 5
OutPort_5204907_0 | SOURCE | K1 5
InPort_5204907_1 | SINK | K1 5
OutPort_5204968_1 | SOURCE | K1 5
InPort_5204968_2 | SINK | K1 5
OutPort_5204960_0 | SOURCE | K1 5
InPort_5204960_1 | SINK | K1 5
OutPort_5205230_1 | SOURCE | K1 5
InPort_5205230_2 | SINK | K1 5
OutPort_5205222_0 | SOURCE | K1 5
InPort_5205222_1 | SINK | K1 5
OutPort_5205238_1 | SOURCE | K1 5
InPort_5205238_2 | SINK | K1 5
OutPort_5205232_0 | SOURCE | K1 5
InPort_5205232_1 | SINK | K1 5
OutPort_5205496_3 | SOURCE | K1 5
Port_5205492_0 | SOURCEANDSINK | L1 1
Port_5280220_3 | SOURCEANDSINK | L1 1
Port_5205496_1 | SOURCEANDSINK | L1 1
Port_5280223_0 | SOURCEANDSINK | L1 1
InPort_5205496_2 | SINK | L1 1
OutPort_5205497_1 | SOURCE | L1 1
InPort_5211525_2 | SINK | K1 6
OutPort_5205802_0 | SOURCE | K1 6
InPort_5205802_1 | SINK | K1 6
OutPort_5205892_2 | SOURCE | K1 6
InPort_5205892_1 | SINK | K1 6
OutPort_5205814_0 | SOURCE | K1 6
InPort_5205814_1 | SINK | K1 6
OutPort_5205903_2 | SOURCE | K1 6
InPort_5205903_1 | SINK | K1 6
OutPort_5205895_0 | SOURCE | K1 6
InPort_5205895_1 | SINK | K1 6
OutPort_5211569_1 | SOURCE | K1 6
InPort_5206277_0 | SINK | F1 4 (1) (2)
OutPort_5211643_1 | SOURCE | F1 4 (1) (2)
InPort_5211906_2 | SINK | K1 2
OutPort_5206700_0 | SOURCE | K1 2
InPort_5206700_1 | SINK | K1 2
OutPort_5207307_3 | SOURCE | K1 2
InPort_5207203_2 | SINK | K1 2
OutPort_5206739_0 | SOURCE | K1 2
InPort_5206739_1 | SINK | K1 2
OutPort_5207179_2 | SOURCE | K1 2
InPort_5207054_2 | SINK | K1 2
OutPort_5207046_0 | SOURCE | K1 2
InPort_5207046_1 | SINK | K1 2
OutPort_5207064_2 | SOURCE | K1 2
InPort_5211904_2 | SINK | K1 2
OutPort_5207056_0 | SOURCE | K1 2
InPort_5207056_1 | SINK | K1 2
OutPort_5207100_2 | SOURCE | K1 2
InPort_5207064_1 | SINK | K1 2
OutPort_5211904_1 | SOURCE | K1 2
InPort_5207307_1 | SINK | K1 2
OutPort_5207090_0 | SOURCE | K1 2
InPort_5207090_1 | SINK | K1 2
OutPort_5211962_1 | SOURCE | K1 2
InPort_5207100_1 | SINK | K1 2
OutPort_5207308_0 | SOURCE | K1 2
InPort_5207179_1 | SINK | K1 2
OutPort_5207168_0 | SOURCE | K1 2
InPort_5207168_1 | SINK | K1 2
OutPort_5207305_2 | SOURCE | K1 2
InPort_5207305_1 | SINK | K1 2
OutPort_5211906_1 | SOURCE | K1 2
InPort_5207308_1 | SINK | K1 2
OutPort_5207307_2 | SOURCE | K1 2
InPort_5207466_0 | SINK | K1 2
OutPort_5212171_3 | SOURCE | K1 2
InPort_5212124_2 | SINK | K1 2
OutPort_5207466_1 | SOURCE | K1 2
InPort_5212038_2 | SINK | K1 2
OutPort_5207531_0 | SOURCE | K1 2
InPort_5207531_1 | SINK | K1 2
InPort_5212215_2 | SINK | K1 7
OutPort_5208031_0 | SOURCE | K1 7
InPort_5208031_1 | SINK | K1 7
OutPort_5215703_2 | SOURCE | K1 7
InPort_5215746_2 | SINK | K1 7
OutPort_5208069_0 | SOURCE | K1 7
InPort_5208069_1 | SINK | K1 7
OutPort_5215766_1 | SOURCE | K1 7
InPort_5211248_2 | SINK | K1 9
OutPort_5208157_0 | SOURCE | K1 9
InPort_5208157_1 | SINK | K1 9
OutPort_5208253_3 | SOURCE | K1 9
InPort_5208207_0 | SINK | K1 9
OutPort_5209266_2 | SOURCE | K1 9
InPort_5209268_2 | SINK | K1 9
OutPort_5208207_1 | SOURCE | K1 9
InPort_5208253_1 | SINK | K1 9
OutPort_5209005_0 | SOURCE | K1 9
InPort_5208254_1 | SINK | K1 9
OutPort_5208253_2 | SOURCE | K1 9
InPort_5211246_2 | SINK | K1 9
OutPort_5208254_0 | SOURCE | K1 9
InPort_5209266_1 | SINK | K1 9
OutPort_5208755_0 | SOURCE | K1 9
InPort_5208755_1 | SINK | K1 9
OutPort_5211285_1 | SOURCE | K1 9
InPort_5209005_1 | SINK | K1 9
OutPort_5209233_1 | SOURCE | K1 9
InPort_5209233_2 | SINK | K1 9
OutPort_5209225_0 | SOURCE | K1 9
InPort_5209225_1 | SINK | K1 9
OutPort_5209268_1 | SOURCE | K1 9
InPort_5209406_0 | SINK | K1 9
OutPort_5210327_3 | SOURCE | K1 9
InPort_5210273_2 | SINK | K1 9
OutPort_5209406_1 | SOURCE | K1 9
Port_5209973_0 | SOURCEANDSINK | L1 1
Port_5279592_3 | SOURCEANDSINK | L1 1
InPort_5211273_0 | SINK | K1 9
OutPort_5210273_1 | SOURCE | K1 9
Port_5210327_1 | SOURCEANDSINK | L1 1
Port_5279595_0 | SOURCEANDSINK | L1 1
InPort_5210327_2 | SINK | L1 1
OutPort_5210328_1 | SOURCE | L1 1
InPort_5210827_2 | SINK | K1 10
OutPort_5210634_0 | SOURCE | K1 10
InPort_5210634_1 | SINK | K1 10
OutPort_5210829_3 | SOURCE | K1 10
InPort_5210764_2 | SINK | K1 10
OutPort_5210735_0 | SOURCE | K1 10
InPort_5210735_1 | SINK | K1 10
OutPort_5210787_2 | SOURCE | K1 10
InPort_5210829_1 | SINK | K1 10
OutPort_5210777_0 | SOURCE | K1 10
InPort_5210777_1 | SINK | K1 10
OutPort_5210918_1 | SOURCE | K1 10
InPort_5210787_1 | SINK | K1 10
OutPort_5210830_0 | SOURCE | K1 10
InPort_5210830_1 | SINK | K1 10
OutPort_5210829_2 | SOURCE | K1 10
InPort_5210918_2 | SINK | K1 10
OutPort_5210925_0 | SOURCE | K1 10
InPort_5210925_1 | SINK | K1 10
OutPort_5210941_1 | SOURCE | K1 10
InPort_5210941_2 | SINK | K1 10
OutPort_5210935_0 | SOURCE | K1 10
InPort_5210935_1 | SINK | K1 10
OutPort_5211053_3 | SOURCE | K1 10
InPort_5211049_0 | SINK | L1 1
OutPort_5358789_2 | SOURCE | L1 1
InPort_5447855_1 | SINK | L1 1
OutPort_5211049_1 | SOURCE | L1 1
InPort_5279383_0 | SINK | L1 1
OutPort_5211053_1 | SOURCE | L1 1
InPort_5211053_2 | SINK | L1 1
OutPort_5211054_1 | SOURCE | L1 1
InPort_5211285_2 | SINK | K1 9
OutPort_5211273_1 | SOURCE | K1 9
InPort_5211381_2 | SINK | K1 3
OutPort_5211373_0 | SOURCE | K1 3
InPort_5211373_1 | SINK | K1 3
OutPort_5211424_1 | SOURCE | K1 3
InPort_5211569_2 | SINK | K1 6
OutPort_5211561_0 | SOURCE | K1 6
InPort_5211561_1 | SINK | K1 6
OutPort_5211593_1 | SOURCE | K1 6
InPort_5211593_2 | SINK | K1 6
OutPort_5211583_0 | SOURCE | K1 6
InPort_5211583_1 | SINK | K1 6
OutPort_5211643_3 | SOURCE | K1 6
InPort_5211643_2 | SINK | F1 4 (1) (2)
OutPort_5211644_1 | SOURCE | F1 4 (1) (2)
InPort_5211962_2 | SINK | K1 2
OutPort_5211954_0 | SOURCE | K1 2
InPort_5211954_1 | SINK | K1 2
OutPort_5211970_1 | SOURCE | K1 2
InPort_5211970_2 | SINK | K1 2
OutPort_5211964_0 | SOURCE | K1 2
InPort_5211964_1 | SINK | K1 2
OutPort_5212038_3 | SOURCE | K1 2
InPort_5212039_1 | SINK | K1 2
OutPort_5212038_1 | SOURCE | K1 2
InPort_5212171_2 | SINK | K1 2
OutPort_5212039_0 | SOURCE | K1 2
InPort_5212116_2 | SINK | K1 2
OutPort_5212108_0 | SOURCE | K1 2
InPort_5212108_1 | SINK | K1 2
OutPort_5212124_1 | SOURCE | K1 2
InPort_5212171_1 | SINK | K1 2
OutPort_5212172_1 | SOURCE | K1 2
InPort_5215595_2 | SINK | K1 11
OutPort_5214081_0 | SOURCE | K1 11
InPort_5214081_1 | SINK | K1 11
OutPort_5214099_2 | SOURCE | K1 11
InPort_5214099_1 | SINK | K1 11
OutPort_5214093_0 | SOURCE | K1 11
InPort_5214093_1 | SINK | K1 11
OutPort_5214107_2 | SOURCE | K1 11
InPort_5214107_1 | SINK | K1 11
OutPort_5214101_0 | SOURCE | K1 11
InPort_5214101_1 | SINK | K1 11
OutPort_5215469_1 | SOURCE | K1 11
InPort_5215469_2 | SINK | K1 11
OutPort_5215461_0 | SOURCE | K1 11
InPort_5215461_1 | SINK | K1 11
OutPort_5215488_1 | SOURCE | K1 11
InPort_5215471_0 | SINK | K1 11
OutPort_5215481_3 | SOURCE | K1 11
InPort_5215488_2 | SINK | K1 11
OutPort_5215471_1 | SOURCE | K1 11
InPort_5215481_1 | SINK | F1 palubėje 12
OutPort_5215482_1 | SOURCE | F1 palubėje 12
InPort_5215703_1 | SINK | K1 7
OutPort_5437873_0 | SOURCE | K1 7
InPort_5215749_0 | SINK | K1 7
OutPort_5215759_3 | SOURCE | K1 7
InPort_5215766_2 | SINK | K1 7
OutPort_5215749_1 | SOURCE | K1 7
InPort_5215759_1 | SINK | K1 7
OutPort_5215760_1 | SOURCE | K1 7
InPort_5215759_2 | SINK | K1 7
OutPort_5215942_0 | SOURCE | K1 7
InPort_5215760_0 | SINK | K1 7
OutPort_5437872_2 | SOURCE | K1 7
InPort_5215775_0 | SINK | K1 7
OutPort_5216088_2 | SOURCE | K1 7
InPort_5216037_2 | SINK | K1 7
OutPort_5215775_1 | SOURCE | K1 7
InPort_5215783_0 | SINK | K1 7
OutPort_5273461_1 | SOURCE | K1 7
InPort_5216088_1 | SINK | K1 7
OutPort_5215783_1 | SOURCE | K1 7
InPort_5273461_2 | SINK | K1 7
OutPort_5215794_0 | SOURCE | K1 7
InPort_5215794_1 | SINK | K1 7
OutPort_5273465_2 | SOURCE | K1 7
InPort_5215942_1 | SINK | K1 7
OutPort_5216029_1 | SOURCE | K1 7
InPort_5216029_2 | SINK | K1 7
OutPort_5216021_0 | SOURCE | K1 7
InPort_5216021_1 | SINK | K1 7
OutPort_5216037_1 | SOURCE | K1 7
Port_5242842_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5243734_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5243728_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5345254_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5243734_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5290717_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5270489_0 | SINK | F1 palubėje 11
OutPort_5273073_1 | SOURCE | F1 palubėje 11
InPort_5458757_2 | SINK | F1 palubėje 11
OutPort_5270489_1 | SOURCE | F1 palubėje 11
InPort_5273073_3 | SINK | F1 palubėje 11
OutPort_5272703_0 | SOURCE | F1 palubėje 11
InPort_5273454_1 | SINK | K1 7
OutPort_5272703_1 | SOURCE | K1 7
InPort_5272985_0 | SINK | F1 2
OutPort_5272979_1 | SOURCE | F1 2
InPort_5272979_1 | SINK | F1 2
OutPort_5272985_0 | SOURCE | F1 2
InPort_5272985_1 | SINK | F1 2
OutPort_5437577_1 | SOURCE | F1 2
InPort_5273073_2 | SINK | F1 palubėje 11
OutPort_5273335_0 | SOURCE | F1 palubėje 11
InPort_5273334_2 | SINK | F1 palubėje 11
OutPort_5273085_0 | SOURCE | F1 palubėje 11
InPort_5273085_1 | SINK | F1 palubėje 11
OutPort_5273207_1 | SOURCE | F1 palubėje 11
InPort_5273204_1 | SINK | F1 palubėje 11
OutPort_5273202_0 | SOURCE | F1 palubėje 11
InPort_5273202_1 | SINK | F1 palubėje 11
OutPort_5437572_1 | SOURCE | F1 palubėje 11
InPort_5273207_2 | SINK | F1 palubėje 11
OutPort_5273204_2 | SOURCE | F1 palubėje 11
InPort_5273334_3 | SINK | F1 palubėje 11
OutPort_5273332_0 | SOURCE | F1 palubėje 11
InPort_5273332_1 | SINK | F1 palubėje 11
OutPort_5437436_1 | SOURCE | F1 palubėje 11
InPort_5273335_1 | SINK | F1 palubėje 11
OutPort_5273334_1 | SOURCE | F1 palubėje 11
InPort_5273450_0 | SINK | K1 7
OutPort_5273452_2 | SOURCE | K1 7
InPort_5273465_1 | SINK | K1 7
OutPort_5273450_1 | SOURCE | K1 7
InPort_5273452_1 | SINK | K1 7
OutPort_5273454_2 | SOURCE | K1 7
InPort_5279380_1 | SINK | L1 1
OutPort_5279383_1 | SOURCE | L1 1
InPort_5358787_0 | SINK | L1 1
OutPort_5279380_3 | SOURCE | L1 1
Port_5279592_1 | SOURCEANDSINK | L1 1
Port_5279595_1 | SOURCEANDSINK | L1 1
InPort_5279768_1 | SINK | L1 1
OutPort_5279773_1 | SOURCE | L1 1
InPort_5279967_1 | SINK | L1 1
OutPort_5279970_1 | SOURCE | L1 1
Port_5280220_1 | SOURCEANDSINK | L1 1
Port_5280223_1 | SOURCEANDSINK | L1 1
InPort_5280798_1 | SINK | L1 1
OutPort_5280795_1 | SOURCE | L1 1
Port_5280895_0 | SOURCEANDSINK | L1 1
Port_5445218_1 | SOURCEANDSINK | L1 1
Port_5280895_1 | SOURCEANDSINK | L1 1
Port_5303550_2 | SOURCEANDSINK | L1 1
InPort_5281026_1 | SINK | L1 1
OutPort_5281029_1 | SOURCE | L1 1
Port_5281634_1 | SOURCEANDSINK | L1 2
Port_5304658_0 | SOURCEANDSINK | L1 2
Port_5282057_1 | SOURCEANDSINK | L1 2
Port_5282060_1 | SOURCEANDSINK | L1 2
Port_5286701_2 | SOURCEANDSINK | F1 9
Port_5436487_1 | SOURCEANDSINK | F1 9
InPort_5286927_2 | SINK | F1 palubėje 15
OutPort_5286940_1 | SOURCE | F1 palubėje 15
InPort_5287054_1 | SINK | F1 palubėje 15
OutPort_5287011_1 | SOURCE | F1 palubėje 15
InPort_5287011_2 | SINK | F1 palubėje 15
OutPort_5287014_1 | SOURCE | F1 palubėje 15
InPort_5287051_2 | SINK | F1 palubėje 15
OutPort_5287054_0 | SOURCE | F1 palubėje 15
InPort_5287074_0 | SINK | F1 palubėje 10
OutPort_5287071_2 | SOURCE | F1 palubėje 10
OutPort_5287074_1 | SOURCE | F1 palubėje 10
InPort_5287138_0 | SINK | F1 palubėje 20
OutPort_5287109_1 | SOURCE | F1 palubėje 20
InPort_5287109_2 | SINK | F1 palubėje 20
OutPort_5287112_1 | SOURCE | F1 palubėje 20
InPort_5287135_2 | SINK | F1 palubėje 20
OutPort_5287138_1 | SOURCE | F1 palubėje 20
Port_5287189_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5288150_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5287692_2 | SINK | F1 9
OutPort_5287695_1 | SOURCE | F1 9
InPort_5287798_2 | SINK | F1 9
OutPort_5287801_1 | SOURCE | F1 9
InPort_5287959_1 | SINK | F1 9
OutPort_5287956_2 | SOURCE | F1 9
Port_5290417_1 | SOURCEANDSINK | F1 9
Port_5433564_0 | SOURCEANDSINK | F1 9
InPort_5290717_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5290417_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_5290754_0 | SOURCEANDSINK | F1 9
Port_5292425_1 | SOURCEANDSINK | F1 9
Port_5290754_1 | SOURCEANDSINK | F1 9
Port_5291092_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5291160_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5291160_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444563_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5291174_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444563_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5291976_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292052_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292052_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292105_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5292105_2 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5292098_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_5292105_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292106_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292191_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292238_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292238_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415660_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5292399_1 | SOURCEANDSINK | F1 9
Port_5292412_1 | SOURCEANDSINK | F1 9
Port_5292412_0 | SOURCEANDSINK | F1 9
Port_5292425_3 | SOURCEANDSINK | F1 9
Port_5292425_2 | SOURCEANDSINK | F1 9
Port_5433476_1 | SOURCEANDSINK | F1 9
Port_5293466_2 | SOURCEANDSINK | F1 2 1
Port_5293468_1 | SOURCEANDSINK | F1 2 1
Port_5296583_2 | SOURCEANDSINK | F1 9
Port_5296586_1 | SOURCEANDSINK | F1 9
Port_5304443_1 | SOURCEANDSINK | L1 2
Port_5304523_1 | SOURCEANDSINK | L1 2
Port_5304469_0 | SOURCEANDSINK | L1 2
Port_5304519_2 | SOURCEANDSINK | L1 2
Port_5304469_1 | SOURCEANDSINK | L1 2
Port_5304523_2 | SOURCEANDSINK | L1 2
Port_5304658_1 | SOURCEANDSINK | L1 2
Port_5304744_1 | SOURCEANDSINK | L1 2
Port_5304694_0 | SOURCEANDSINK | L1 2
Port_5304744_2 | SOURCEANDSINK | L1 2
Port_5304694_1 | SOURCEANDSINK | L1 2
Port_5423831_2 | SOURCEANDSINK | L1 2
Port_5305802_1 | SOURCEANDSINK | L1 1
Port_5305826_1 | SOURCEANDSINK | L1 1
Port_5305826_0 | SOURCEANDSINK | L1 1
Port_5305896_3 | SOURCEANDSINK | L1 1
Port_5305896_2 | SOURCEANDSINK | L1 1
Port_5305897_1 | SOURCEANDSINK | L1 1
Port_5306232_1 | SOURCEANDSINK | L1 1
Port_5306265_1 | SOURCEANDSINK | L1 1
Port_5306265_0 | SOURCEANDSINK | L1 1
Port_5306278_3 | SOURCEANDSINK | L1 1
Port_5306278_1 | SOURCEANDSINK | L1 1
Port_5306279_1 | SOURCEANDSINK | L1 1
Port_5307108_0 | SOURCEANDSINK | L1 1
Port_5452781_1 | SOURCEANDSINK | L1 1
Port_5307941_1 | SOURCEANDSINK | L1 2
Port_5307943_1 | SOURCEANDSINK | L1 2
Port_5307943_2 | SOURCEANDSINK | L1 2
Port_5364555_0 | SOURCEANDSINK | L1 2
InPort_5315516_2 | SINK | K1 4
OutPort_5315518_2 | SOURCE | K1 12
Port_5316604_1 | SOURCEANDSINK | L1 2
Port_5316604_2 | SOURCEANDSINK | L1 2
Port_5316606_1 | SOURCEANDSINK | L1 2
InPort_5325489_2 | SINK | F1 3
OutPort_5325471_0 | SOURCE | F1 3
InPort_5325471_1 | SINK | F1 3
OutPort_5326019_1 | SOURCE | F1 3
InPort_5326019_2 | SINK | F1 3
OutPort_5325642_0 | SOURCE | F1 3
InPort_5325642_1 | SINK | F1 3
OutPort_5326246_1 | SOURCE | F1 3
InPort_5326246_2 | SINK | F1 3
OutPort_5326238_0 | SOURCE | F1 3
InPort_5326238_1 | SINK | F1 3
OutPort_5326586_1 | SOURCE | F1 3
InPort_5326586_2 | SINK | F1 3
OutPort_5437392_1 | SOURCE | F1 3
Port_5326622_1 | SOURCEANDSINK | F1 palubėje 18
Port_5326622_2 | SOURCEANDSINK | F1 palubėje 18
Port_5330468_3 | SOURCEANDSINK
InPort_5334331_0 | SINK | L1 3
OutPort_5331406_1 | SOURCE | L1 3
Port_5334331_1 | SOURCEANDSINK | L1 3
Port_5334350_1 | SOURCEANDSINK | L1 3
Port_5334344_0 | SOURCEANDSINK | L1 3
Port_5335283_2 | SOURCEANDSINK | L1 3
Port_5334344_1 | SOURCEANDSINK | L1 3
Port_5334350_2 | SOURCEANDSINK | L1 3
Port_5385621_0 | SOURCEANDSINK | L1 3
InPort_5334447_0 | SINK | L1 4
OutPort_5334429_1 | SOURCE | L1 4
Port_5334447_1 | SOURCEANDSINK | L1 4
Port_5334468_1 | SOURCEANDSINK | L1 4
Port_5334468_2 | SOURCEANDSINK | L1 4
Port_5335055_0 | SOURCEANDSINK | L1 4
Port_5335281_0 | SOURCEANDSINK | L1 3
Port_5385620_1 | SOURCEANDSINK | L1 3
Port_5335281_1 | SOURCEANDSINK | L1 3
Port_5335283_1 | SOURCEANDSINK | L1 3
OutPort_5343848_1 | SOURCE | Other 4
InPort_5343871_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5343848_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5345335_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5343871_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5343902_0 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5345335_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5345343_3 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5343902_1 | SOURCE | F1 2 (1) (1) (1) (1) (1)
Port_5345254_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5345343_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5345343_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5345344_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5357261_2 | SINK | F1 9
OutPort_5348041_1 | SOURCE | F1 9
Port_5351093_0 | SOURCEANDSINK | F1 9
Port_5351448_2 | SOURCEANDSINK | F1 9
Port_5351093_1 | SOURCEANDSINK | F1 9
Port_5351576_2 | SOURCEANDSINK | F1 9
Port_5351252_1 | SOURCEANDSINK | F1 9
Port_5353960_0 | SOURCEANDSINK | F1 9
Port_5351252_2 | SOURCEANDSINK | F1 9
Port_5351449_0 | SOURCEANDSINK | F1 9
Port_5351448_1 | SOURCEANDSINK | F1 9
Port_5351449_1 | SOURCEANDSINK | F1 9
InPort_5353145_0 | SINK | F1 9
OutPort_5357261_1 | SOURCE | F1 9
InPort_5357318_2 | SINK | F1 9
OutPort_5353145_1 | SOURCE | F1 9
Port_5353960_1 | SOURCEANDSINK | F1 9
Port_5354111_3 | SOURCEANDSINK | F1 9
Port_5354111_1 | SOURCEANDSINK | F1 9
Port_5356942_1 | SOURCEANDSINK | F1 9
InPort_5354111_2 | SINK | F1 9
OutPort_5354241_0 | SOURCE | F1 9
InPort_5354241_1 | SINK | F1 9
OutPort_5357308_1 | SOURCE | F1 9
InPort_5357269_1 | SINK | F1 9
OutPort_5357318_1 | SOURCE | F1 9
InPort_5357308_2 | SINK | F1 9
OutPort_5357269_2 | SOURCE | F1 9
InPort_5357945_2 | SINK | F1 9
OutPort_5357560_0 | SOURCE | F1 9
InPort_5357967_1 | SINK | F1 palubėje 12
OutPort_5357560_1 | SOURCE | F1 palubėje 12
InPort_5357725_0 | SINK | F1 palubėje 12
OutPort_5357908_2 | SOURCE | F1 palubėje 12
InPort_5358789_1 | SINK | L1 1
OutPort_5358787_1 | SOURCE | L1 1
Port_5360080_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360170_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360080_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360248_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360170_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360171_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5360171_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5438895_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5363028_1 | SINK | L1 1
OutPort_5362819_1 | SOURCE | L1 1
InPort_5363217_0 | SINK | L1 2
OutPort_5363167_1 | SOURCE | L1 2
Port_5363217_1 | SOURCEANDSINK | L1 2
Port_5363686_1 | SOURCEANDSINK | L1 2
Port_5363270_2 | SOURCEANDSINK | L1 2
Port_5363314_0 | SOURCEANDSINK | L1 2
Port_5363279_0 | SOURCEANDSINK | L1 2
Port_5363686_2 | SOURCEANDSINK | L1 2
Port_5363279_1 | SOURCEANDSINK | L1 2
Port_5363690_1 | SOURCEANDSINK | L1 2
Port_5363314_1 | SOURCEANDSINK | L1 2
Port_5363356_1 | SOURCEANDSINK | L1 2
Port_5363344_0 | SOURCEANDSINK | L1 2
Port_5363356_2 | SOURCEANDSINK | L1 2
Port_5363344_1 | SOURCEANDSINK | L1 2
Port_5363370_1 | SOURCEANDSINK | L1 2
Port_5363360_0 | SOURCEANDSINK | L1 2
Port_5363370_2 | SOURCEANDSINK | L1 2
Port_5363360_1 | SOURCEANDSINK | L1 2
Port_5363383_2 | SOURCEANDSINK | L1 2
Port_5363383_1 | SOURCEANDSINK | L1 2
Port_5363555_0 | SOURCEANDSINK | L1 2
Port_5363555_1 | SOURCEANDSINK | L1 2
Port_5363690_2 | SOURCEANDSINK | L1 2
InPort_5374630_1 | SINK
InPort_5374630_2 | SINK
InPort_5374630_3 | SINK
OutPort_5374630_4 | SOURCE
InPort_5374630_5 | SINK
InPort_5374631_1 | SINK
OutPort_5374631_2 | SOURCE
InPort_5374631_3 | SINK
InPort_5384091_0 | SINK | F1 9
OutPort_5383912_1 | SOURCE | F1 9
InPort_5384231_3 | SINK | F1 9
OutPort_5384091_1 | SOURCE | F1 9
InPort_5384193_0 | SINK | F1 9
OutPort_5384231_1 | SOURCE | F1 9
InPort_5384231_2 | SINK | F1 9
OutPort_5384232_1 | SOURCE | F1 9
InPort_5384473_0 | SINK | F1 4 (1)
OutPort_5384472_1 | SOURCE | F1 4 (1)
Port_5384473_1 | SOURCEANDSINK | F1 4 (1)
Port_5384534_3 | SOURCEANDSINK | F1 4 (1)
Port_5384495_0 | SOURCEANDSINK | F1 4 (1)
Port_5384534_1 | SOURCEANDSINK | F1 4 (1)
Port_5384534_2 | SOURCEANDSINK | F1 4 (1)
Port_5384535_1 | SOURCEANDSINK | F1 4 (1)
Port_5384965_0 | SOURCEANDSINK | L1 3
Port_5384965_1 | SOURCEANDSINK | L1 3
Port_5385480_1 | SOURCEANDSINK | L1 3
Port_5385055_0 | SOURCEANDSINK | L1 3
Port_5385480_2 | SOURCEANDSINK | L1 3
Port_5385055_1 | SOURCEANDSINK | L1 3
Port_5385692_1 | SOURCEANDSINK | L1 3
InPort_5388651_0 | SINK | L1 6
OutPort_5385279_1 | SOURCE | L1 6
Port_5385576_0 | SOURCEANDSINK | L1 3
Port_5385620_3 | SOURCEANDSINK | L1 3
Port_5385576_1 | SOURCEANDSINK | L1 3
Port_5385692_2 | SOURCEANDSINK | L1 3
Port_5385620_2 | SOURCEANDSINK | L1 3
Port_5385621_1 | SOURCEANDSINK | L1 3
OutPort_5388167_2 | SOURCE
Port_5388651_1 | SOURCEANDSINK | L1 6
Port_5390500_2 | SOURCEANDSINK | F1 9
Port_5392597_0 | SOURCEANDSINK | F1 9
Port_5391780_1 | SOURCEANDSINK | F1 9
Port_5392596_3 | SOURCEANDSINK | F1 9
Port_5392585_0 | SOURCEANDSINK | F1 9
Port_5392596_1 | SOURCEANDSINK | F1 9
Port_5392596_2 | SOURCEANDSINK | F1 9
Port_5392597_1 | SOURCEANDSINK | F1 9
Port_5393694_1 | SOURCEANDSINK | F1 4 (3)
Port_5393919_2 | SOURCEANDSINK | F1 4 (3)
Port_5393840_0 | SOURCEANDSINK | F1 4 (3)
Port_5393848_2 | SOURCEANDSINK | F1 4 (3)
Port_5393840_1 | SOURCEANDSINK | F1 4 (3)
Port_5393919_1 | SOURCEANDSINK | F1 4 (3)
Port_5393848_1 | SOURCEANDSINK | F1 4 (3)
Port_5397649_0 | SOURCEANDSINK | F1 9
Port_5405121_4 | SOURCEANDSINK | F1 9
Port_5397649_1 | SOURCEANDSINK | F1 9
InPort_5399273_0 | SINK | F1 9
OutPort_5399122_1 | SOURCE | F1 9
InPort_5408284_3 | SINK | F1 9
OutPort_5399273_1 | SOURCE | F1 9
InPort_5405121_1 | SINK | F1 9
OutPort_5406865_1 | SOURCE | F1 9
Port_5405121_2 | SOURCEANDSINK | F1 9
Port_5457203_0 | SOURCEANDSINK | F1 9
Port_5405121_5 | SOURCEANDSINK | F1 9
Port_5407361_0 | SOURCEANDSINK | F1 9
InPort_5406865_0 | SINK | F1 9
OutPort_5412437_1 | SOURCE | F1 9
Port_5406954_0 | SOURCEANDSINK | F1 9
Port_5457200_1 | SOURCEANDSINK | F1 9
Port_5406954_1 | SOURCEANDSINK | F1 9
Port_5407361_1 | SOURCEANDSINK | F1 9
Port_5407535_2 | SOURCEANDSINK | F1 9
Port_5407519_2 | SOURCEANDSINK | F1 9
Port_5408285_0 | SOURCEANDSINK | F1 9
Port_5407535_1 | SOURCEANDSINK | F1 9
Port_5408239_1 | SOURCEANDSINK | F1 9
Port_5408239_0 | SOURCEANDSINK | F1 9
Port_5408284_1 | SOURCEANDSINK | F1 9
Port_5408284_2 | SOURCEANDSINK | F1 9
Port_5408285_1 | SOURCEANDSINK | F1 9
InPort_5408764_1 | SINK | F1 9
OutPort_5408700_1 | SOURCE | F1 9
InPort_5408714_0 | SINK | F1 9
OutPort_5408764_2 | SOURCE | F1 9
InPort_5409282_2 | SINK | F1 9
OutPort_5408714_1 | SOURCE | F1 9
InPort_5408789_2 | SINK | F1 9
OutPort_5408872_0 | SOURCE | F1 9
InPort_5408872_1 | SINK | F1 9
OutPort_5409290_2 | SOURCE | F1 9
InPort_5408896_0 | SINK | F1 9
OutPort_5409282_1 | SOURCE | F1 9
InPort_5409290_1 | SINK | F1 9
OutPort_5408896_1 | SOURCE | F1 9
Port_5409991_0 | SOURCEANDSINK | F1 9
Port_5418201_2 | SOURCEANDSINK | F1 9
Port_5409991_1 | SOURCEANDSINK | F1 9
Port_5418209_3 | SOURCEANDSINK | F1 9
InPort_5421959_0 | SINK | F1 9
OutPort_5412445_1 | SOURCE | F1 9
Port_5412527_0 | SOURCEANDSINK | F1 9
Port_5427102_1 | SOURCEANDSINK | F1 9
Port_5412527_1 | SOURCEANDSINK | F1 9
Port_5419249_3 | SOURCEANDSINK | F1 9
Port_5413133_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5439146_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5413542_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5414130_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5413542_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5439146_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415660_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416063_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5415720_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416062_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416060_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416062_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416060_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416086_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416062_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5416063_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5418209_1 | SOURCEANDSINK | F1 9
Port_5419250_0 | SOURCEANDSINK | F1 9
Port_5418209_2 | SOURCEANDSINK | F1 9
Port_5418210_1 | SOURCEANDSINK | F1 9
Port_5419129_0 | SOURCEANDSINK | F1 9
Port_5419249_1 | SOURCEANDSINK | F1 9
Port_5419129_1 | SOURCEANDSINK | F1 9
Port_5439196_3 | SOURCEANDSINK | F1 9
Port_5419249_2 | SOURCEANDSINK | F1 9
Port_5433933_1 | SOURCEANDSINK | F1 9
Port_5419250_1 | SOURCEANDSINK | F1 9
Port_5433933_2 | SOURCEANDSINK | F1 9
InPort_5421956_2 | SINK | F1 9
OutPort_5421959_1 | SOURCE | F1 9
InPort_5455914_1 | SINK | F1 palubėje 12
OutPort_5422893_0 | SOURCE | F1 palubėje 12
InPort_5422893_1 | SINK | F1 palubėje 12
OutPort_5422903_2 | SOURCE | F1 palubėje 12
Port_5422939_2 | SOURCEANDSINK | F1 9
Port_5422942_1 | SOURCEANDSINK | F1 9
Port_5423009_2 | SOURCEANDSINK | F1 9
Port_5423012_1 | SOURCEANDSINK | F1 9
Port_5423746_0 | SOURCEANDSINK | L1 2
Port_5439248_3 | SOURCEANDSINK | L1 2
Port_5423746_1 | SOURCEANDSINK | L1 2
Port_5423831_1 | SOURCEANDSINK | L1 2
InPort_5424932_0 | SINK | L1 7
OutPort_5424398_1 | SOURCE | L1 7
Port_5424457_0 | SOURCEANDSINK | L1 2
Port_5424719_1 | SOURCEANDSINK | L1 2
Port_5424457_1 | SOURCEANDSINK | L1 2
Port_5424698_2 | SOURCEANDSINK | L1 2
Port_5424666_2 | SOURCEANDSINK | L1 2
Port_5424720_0 | SOURCEANDSINK | L1 2
Port_5424711_0 | SOURCEANDSINK | L1 2
Port_5424719_3 | SOURCEANDSINK | L1 2
Port_5424711_1 | SOURCEANDSINK | L1 2
Port_5424719_2 | SOURCEANDSINK | L1 2
Port_5424720_1 | SOURCEANDSINK | L1 2
Port_5424932_1 | SOURCEANDSINK | L1 7
Port_5426645_1 | SOURCEANDSINK | L1 7
Port_5424952_0 | SOURCEANDSINK | L1 7
Port_5426645_2 | SOURCEANDSINK | L1 7
Port_5424952_1 | SOURCEANDSINK | L1 7
Port_5426422_0 | SOURCEANDSINK | L1 2
Port_5426505_1 | SOURCEANDSINK | L1 2
Port_5426422_1 | SOURCEANDSINK | L1 2
Port_5426505_2 | SOURCEANDSINK | L1 2
Port_5426506_0 | SOURCEANDSINK | L1 2
Port_5426506_1 | SOURCEANDSINK | L1 2
Port_5439248_1 | SOURCEANDSINK | L1 2
Port_5427102_2 | SOURCEANDSINK | F1 9
Port_5427164_1 | SOURCEANDSINK | F1 9
Port_5427164_0 | SOURCEANDSINK | F1 9
Port_5454403_1 | SOURCEANDSINK | F1 9
InPort_5428574_1 | SINK | F1 palubėje 11
OutPort_5428567_0 | SOURCE | F1 palubėje 11
InPort_5428567_1 | SINK | F1 palubėje 11
OutPort_5428662_2 | SOURCE | F1 palubėje 11
InPort_5428575_1 | SINK | F1 palubėje 11
OutPort_5428574_2 | SOURCE | F1 palubėje 11
InPort_5444969_1 | SINK | F1 palubėje 11
OutPort_5428575_0 | SOURCE | F1 palubėje 11
InPort_5428662_1 | SINK | F1 palubėje 11
OutPort_5428622_0 | SOURCE | F1 palubėje 11
InPort_5428622_1 | SINK | F1 palubėje 11
OutPort_5430424_2 | SOURCE | F1 palubėje 11
InPort_5430228_1 | SINK | F1 palubėje 11
OutPort_5430067_0 | SOURCE | F1 palubėje 11
InPort_5430067_1 | SINK | F1 palubėje 11
OutPort_5434994_2 | SOURCE | F1 palubėje 11
InPort_5430228_3 | SINK | F1 palubėje 11
OutPort_5430226_0 | SOURCE | F1 palubėje 11
InPort_5430226_1 | SINK | F1 palubėje 11
OutPort_5430289_1 | SOURCE | F1 palubėje 11
InPort_5434615_1 | SINK | F1 palubėje 11
OutPort_5430228_2 | SOURCE | F1 palubėje 11
InPort_5430424_1 | SINK | F1 palubėje 11
OutPort_5431959_0 | SOURCE | F1 palubėje 11
InPort_5430834_0 | SINK | F1 palubėje 11
OutPort_5431854_2 | SOURCE | F1 palubėje 11
InPort_5431995_2 | SINK | F1 palubėje 11
OutPort_5430834_1 | SOURCE | F1 palubėje 11
InPort_5431854_1 | SINK | F1 palubėje 11
OutPort_5431848_2 | SOURCE | F1 palubėje 11
InPort_5431958_1 | SINK | F1 palubėje 11
OutPort_5445043_0 | SOURCE | F1 palubėje 11
InPort_5431959_1 | SINK | F1 palubėje 11
OutPort_5431958_2 | SOURCE | F1 palubėje 11
InPort_5431958_3 | SINK | F1 palubėje 11
OutPort_5431995_1 | SOURCE | F1 palubėje 11
Port_5432946_0 | SOURCEANDSINK | F1 9
Port_5439196_1 | SOURCEANDSINK | F1 9
Port_5432946_1 | SOURCEANDSINK | F1 9
Port_5433563_3 | SOURCEANDSINK | F1 9
Port_5433476_0 | SOURCEANDSINK | F1 9
Port_5433563_1 | SOURCEANDSINK | F1 9
Port_5433563_2 | SOURCEANDSINK | F1 9
Port_5433564_1 | SOURCEANDSINK | F1 9
Port_5433737_1 | SOURCEANDSINK | F1 9
Port_5436562_0 | SOURCEANDSINK | F1 9
InPort_5445086_1 | SINK | F1 palubėje 11
OutPort_5434615_0 | SOURCE | F1 palubėje 11
InPort_5434994_1 | SINK | F1 palubėje 11
OutPort_5434907_0 | SOURCE | F1 palubėje 11
InPort_5434907_1 | SINK | F1 palubėje 11
OutPort_5436555_1 | SOURCE | F1 palubėje 11
InPort_5436555_2 | SINK | F1 palubėje 11
OutPort_5435007_0 | SOURCE | F1 palubėje 11
InPort_5435007_1 | SINK | F1 palubėje 11
OutPort_5436561_3 | SOURCE | F1 palubėje 11
OutPort_5435179_1 | SOURCE | F1 palubėje 15
Port_5435860_0 | SOURCEANDSINK | F1 9
Port_5435868_2 | SOURCEANDSINK | F1 9
Port_5435860_1 | SOURCEANDSINK | F1 9
Port_5436117_2 | SOURCEANDSINK | F1 9
Port_5436117_1 | SOURCEANDSINK | F1 9
Port_5454404_0 | SOURCEANDSINK | F1 9
Port_5436487_0 | SOURCEANDSINK | F1 9
Port_5436561_1 | SOURCEANDSINK | F1 9
Port_5436561_2 | SOURCEANDSINK | F1 9
Port_5436562_1 | SOURCEANDSINK | F1 9
InPort_5437275_0 | SINK | F1 2
OutPort_5437572_2 | SOURCE | F1 2
InPort_5437577_2 | SINK | F1 2
OutPort_5437275_1 | SOURCE | F1 2
InPort_5437392_0 | SINK | F1 3
OutPort_5437436_2 | SOURCE | F1 3
InPort_5437873_1 | SINK | K1 7
OutPort_5437872_1 | SOURCE | K1 7
InPort_5437872_3 | SINK | K1 7
Port_5438895_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444186_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5439146_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453787_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5439196_2 | SOURCEANDSINK | F1 9
Port_5452267_0 | SOURCEANDSINK | F1 9
Port_5439248_2 | SOURCEANDSINK | L1 2
Port_5439835_0 | SOURCEANDSINK | L1 2
Port_5439309_2 | SOURCEANDSINK | L1 2
Port_5441673_0 | SOURCEANDSINK | L1 2
InPort_5439384_1 | SINK | F1 4
OutPort_5439795_0 | SOURCE | F1 4
InPort_5439795_0 | SINK | L1 2
OutPort_5439384_1 | SOURCE | L1 2
InPort_5441184_2 | SINK | L1 2
OutPort_5439795_1 | SOURCE | L1 2
Port_5439835_1 | SOURCEANDSINK | L1 2
Port_5441164_1 | SOURCEANDSINK | L1 2
Port_5441164_2 | SOURCEANDSINK | L1 2
Port_5441184_1 | SOURCEANDSINK | L1 2
Port_5441673_1 | SOURCEANDSINK | L1 2
Port_5442203_1 | SOURCEANDSINK | L1 2
InPort_5441941_1 | SINK | F1 6
OutPort_5442044_1 | SOURCE | F1 6
InPort_5442203_2 | SINK | L1 2
OutPort_5442044_0 | SOURCE | L1 2
InPort_5442044_1 | SINK | L1 2
OutPort_5441941_1 | SOURCE | L1 2
Port_5442425_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461292_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5443515_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444587_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444057_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444160_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444186_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444714_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444587_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444732_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444714_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5444732_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5444972_1 | SINK | F1 palubėje 11
OutPort_5444969_2 | SOURCE | F1 palubėje 11
OutPort_5444972_0 | SOURCE | F1 palubėje 11
InPort_5445040_1 | SINK | F1 palubėje 11
OutPort_5462385_0 | SOURCE | F1 palubėje 11
InPort_5445043_1 | SINK | F1 palubėje 11
OutPort_5445040_2 | SOURCE | F1 palubėje 11
InPort_5445089_1 | SINK | F1 palubėje 11
OutPort_5445086_2 | SOURCE | F1 palubėje 11
InPort_5462384_2 | SINK | F1 palubėje 11
OutPort_5445089_0 | SOURCE | F1 palubėje 11
Port_5445218_3 | SOURCEANDSINK | L1 1
Port_5445229_1 | SOURCEANDSINK | L1 1
Port_5445229_0 | SOURCEANDSINK | L1 1
Port_5445988_0 | SOURCEANDSINK | F1 9
Port_5446279_1 | SOURCEANDSINK | F1 9
Port_5445988_1 | SOURCEANDSINK | F1 9
Port_5446026_2 | SOURCEANDSINK | F1 9
Port_5446017_0 | SOURCEANDSINK | F1 9
Port_5446026_3 | SOURCEANDSINK | F1 9
Port_5446017_1 | SOURCEANDSINK | F1 9
Port_5446159_1 | SOURCEANDSINK | F1 9
Port_5446041_0 | SOURCEANDSINK | F1 9
Port_5446159_2 | SOURCEANDSINK | F1 9
Port_5446041_1 | SOURCEANDSINK | F1 9
Port_5446191_1 | SOURCEANDSINK | F1 9
Port_5446279_2 | SOURCEANDSINK | F1 9
Port_5446282_1 | SOURCEANDSINK | F1 9
InPort_5446671_2 | SINK | L1 1
OutPort_5448873_0 | SOURCE | L1 1
InPort_5448056_2 | SINK | L1 1
OutPort_5448107_0 | SOURCE | L1 1
InPort_5448107_1 | SINK | L1 1
OutPort_5448522_2 | SOURCE | L1 1
InPort_5448131_1 | SINK | F1 5
OutPort_5448268_0 | SOURCE | F1 5
InPort_5448522_1 | SINK | L1 1
OutPort_5448268_1 | SOURCE | L1 1
Port_5448660_1 | SOURCEANDSINK | L1 1
Port_5448692_1 | SOURCEANDSINK | L1 1
Port_5448692_0 | SOURCEANDSINK | L1 1
Port_5448705_3 | SOURCEANDSINK | L1 1
Port_5448705_2 | SOURCEANDSINK | L1 1
Port_5448706_1 | SOURCEANDSINK | L1 1
InPort_5448873_1 | SINK | L1 1
OutPort_5449316_2 | SOURCE | L1 1
InPort_5448891_1 | SINK | F1 7
OutPort_5449304_0 | SOURCE | F1 7
InPort_5449316_1 | SINK | L1 1
OutPort_5449304_1 | SOURCE | L1 1
Port_5449366_1 | SOURCEANDSINK | F1 9
Port_5452438_1 | SOURCEANDSINK | F1 9
Port_5452267_1 | SOURCEANDSINK | F1 9
Port_5452481_1 | SOURCEANDSINK | F1 9
Port_5452438_0 | SOURCEANDSINK | F1 9
Port_5452521_2 | SOURCEANDSINK | F1 9
Port_5452481_2 | SOURCEANDSINK | F1 9
Port_5452521_1 | SOURCEANDSINK | F1 9
InPort_5452781_2 | SINK | L1 1
OutPort_5453226_0 | SOURCE | L1 1
InPort_5453226_1 | SINK | L1 1
OutPort_5453468_2 | SOURCE | L1 1
InPort_5453246_1 | SINK | F1 8
OutPort_5453437_0 | SOURCE | F1 8
InPort_5453496_2 | SINK | L1 1
OutPort_5453437_1 | SOURCE | L1 1
InPort_5453468_1 | SINK | L1 1
OutPort_5453496_1 | SOURCE | L1 1
Port_5453717_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453752_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453752_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453827_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453787_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453827_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5453961_1 | SOURCEANDSINK | L1 1
Port_5453973_0 | SOURCEANDSINK | L1 1
Port_5453973_1 | SOURCEANDSINK | L1 1
Port_5454167_3 | SOURCEANDSINK | L1 1
Port_5454167_1 | SOURCEANDSINK | L1 1
Port_5454168_1 | SOURCEANDSINK | L1 1
Port_5454385_1 | SOURCEANDSINK | F1 9
Port_5454397_0 | SOURCEANDSINK | F1 9
Port_5454397_1 | SOURCEANDSINK | F1 9
Port_5454403_2 | SOURCEANDSINK | F1 9
Port_5454404_1 | SOURCEANDSINK | F1 9
Port_5454403_3 | SOURCEANDSINK | F1 9
Port_5455504_1 | SOURCEANDSINK | F1 9
Port_5455520_1 | SOURCEANDSINK | F1 9
Port_5455520_0 | SOURCEANDSINK | F1 9
Port_5455535_3 | SOURCEANDSINK | F1 9
Port_5455535_1 | SOURCEANDSINK | F1 9
Port_5455536_1 | SOURCEANDSINK | F1 9
InPort_5455917_1 | SINK | F1 palubėje 12
OutPort_5455914_2 | SOURCE | F1 palubėje 12
Port_5456253_1 | SOURCEANDSINK | L1 1
Port_5456253_3 | SOURCEANDSINK | L1 1
Port_5456256_1 | SOURCEANDSINK | L1 1
Port_5457200_2 | SOURCEANDSINK | F1 9
Port_5457203_1 | SOURCEANDSINK | F1 9
InPort_5457336_1 | SINK | F1 9
OutPort_5457333_2 | SOURCE | F1 9
InPort_5457468_1 | SINK | L1 1
OutPort_5457471_1 | SOURCE | L1 1
InPort_5458740_0 | SINK | F1 palubėje 11
OutPort_5458757_1 | SOURCE | F1 palubėje 11
InPort_5458815_2 | SINK | F1 palubėje 11
OutPort_5458740_1 | SOURCE | F1 palubėje 11
InPort_5458797_0 | SINK | F1 palubėje 11
OutPort_5458815_1 | SOURCE | F1 palubėje 11
InPort_5458859_1 | SINK | F1 palubėje 11
OutPort_5458797_1 | SOURCE | F1 palubėje 11
InPort_5458848_0 | SINK | F1 palubėje 11
OutPort_5458859_2 | SOURCE | F1 palubėje 11
InPort_5458871_1 | SINK | F1 palubėje 11
OutPort_5458848_1 | SOURCE | F1 palubėje 11
InPort_5462467_0 | SINK | F1 palubėje 11
OutPort_5458871_2 | SOURCE | F1 palubėje 11
Port_5460163_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461810_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5460163_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5461954_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5460886_0 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5460886_1 | SINK | F1 2 (1) (1) (1) (1) (1)
OutPort_5461102_2 | SOURCE | F1 2 (1) (1) (1) (1) (1)
InPort_5461015_1 | SINK | K1 2
OutPort_5461099_1 | SOURCE | K1 2
InPort_5461099_2 | SINK | K1 2
OutPort_5461027_0 | SOURCE | K1 2
InPort_5461027_1 | SINK | K1 2
OutPort_5461102_1 | SOURCE | K1 2
Port_5461292_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461293_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461292_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461811_0 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461810_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461811_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461810_3 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461865_1 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
Port_5461865_2 | SOURCEANDSINK | F1 2 (1) (1) (1) (1) (1)
InPort_5462384_3 | SINK | F1 palubėje 11
OutPort_5462272_0 | SOURCE | F1 palubėje 11
InPort_5462272_1 | SINK | F1 palubėje 11
OutPort_5462463_1 | SOURCE | F1 palubėje 11
InPort_5462385_1 | SINK | F1 palubėje 11
OutPort_5462384_1 | SOURCE | F1 palubėje 11
InPort_5462463_2 | SINK | F1 palubėje 11
OutPort_5462455_0 | SOURCE | F1 palubėje 11
InPort_5462455_1 | SINK | F1 palubėje 11
OutPort_5462477_1 | SOURCE | F1 palubėje 11
InPort_5462477_2 | SINK | F1 palubėje 11
OutPort_5462467_1 | SOURCE | F1 palubėje 11

# IfcFlowController: BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 1/2" - DCA4, BOSS DCA Solenoid Valve - Revit File:Solenoidinis voztuvas 1/2" - DCA4:5330468
In: 0. Cokolinis Vandentiekis
Type - Material: <Unnamed>, Metal - BSS - DZR Brass, Plastic - BSS- Black, Steel, Chrome Plated
Type - Pset_ElementShading - Color: Black & Bronze
Type - Pset_ManufacturerTypeInformation - ModelReference: BOSS Solenoid DCA; Manufacturer: BSS Industrial; ProductionYear: 2021
Classification: D30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Solenoidinis voztuvas 1/2" - DCA4; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please record on commissioning; SerialNumber: Please record on commissioning

# IfcFlowController: HL_Abdichtgarnitur_HL0540.4E:HL0540.4E_Main Component (10)
In: 1. Pirmas
Type - Material: Plactic - Black, Foil
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL0540.4E_Main Component; sets with these values: 2
Name (HL_Abdichtgarnitur_HL0540.4E:HL0540.4E_Main Component:...)
4770613
4785074
4785098
4785203
4819022
4850312
4850323
4850334
4850343
5348013

# IfcFlowController: HL_Aufstockelement_HL0540.2E:HL0540.2E_Main Component (10)
In: 1. Pirmas
Type - Material: Stainless Steel, Plactic - Gray
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL0540.2E_Main Component; sets with these values: 2
Name (HL_Aufstockelement_HL0540.2E:HL0540.2E_Main Component:...)
4770612
4785073
4785097
4785202
4819021
4850311
4850322
4850333
4850342
5348012

# IfcFlowController: HL_Befestigungswinkel_HL0540.3E:HL0540.3E_Main Component (30)
In: 1. Pirmas
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL0540.3E_Main Component; sets with these values: 2
Name (HL_Befestigungswinkel_HL0540.3E:HL0540.3E_Main Component:...)
4770615
4770616
4770617
4785076
4785077
4785078
4785100
4785101
4785102
4785205
4785206
4785207
4819024
4819025
4819026
4850314
4850315
4850316
4850325
4850326
4850327
4850336
4850337
4850338
4850345
4850346
4850347
5348015
5348016
5348017

# IfcFlowController: HL_Bodenablaufkörper_HL540K:HL540K_Main Component (10)
In: 1. Pirmas
Type - Material: Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL540K_Main Component; sets with these values: 2
Name (HL_Bodenablaufkörper_HL540K:HL540K_Main Component:...)
4770611
4785072
4785096
4785201
4819020
4850310
4850321
4850332
4850341
5348011

# IfcFlowController: HL_Einlaufrost_HL066Q.1E:HL066Q.1E (10)
In: 1. Pirmas
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Pset_DistributionFlowElementCommon - Reference: HL066Q.1E; sets with these values: 2
Name (HL_Einlaufrost_HL066Q.1E:HL066Q.1E:...)
4770610
4785071
4785095
4785200
4819019
4850309
4850320
4850331
4850340
5348010

# IfcFlowController: HL_Extension_HL03910.2E:HL03910.2E_Main Component (7)
In: 0. Cokolinis Vandentiekis
Type - Material: Stainless Steel, Plactic - Gray
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL03910.2E_Main Component; sets with these values: 2
Name (HL_Extension_HL03910.2E:HL03910.2E_Main Component:...)
4870049
4870230
4897206
4898666
5012280
5047480
5316523

# IfcFlowController: HL_Floor drain body_HL3100K:HL3100K_Main Component (7)
In: 0. Cokolinis Vandentiekis
Type - Material: Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL3100K_Main Component; sets with these values: 2
Name (HL_Floor drain body_HL3100K:HL3100K_Main Component:...)
4870050
4870231
4897207
4898667
5012281
5047481
5316524

# IfcFlowController: HL_Geruchverschluss_HL2040:HL2040_Main Component (10)
In: 1. Pirmas
Type - Material: Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL2040_Main Component; sets with these values: 2
Name (HL_Geruchverschluss_HL2040:HL2040_Main Component:...)
4770614
4785075
4785099
4785204
4819023
4850313
4850324
4850335
4850344
5348014

# IfcFlowController: HL_Grate_HL03910.1E:HL03910.1E_Main Component (7)
In: 0. Cokolinis Vandentiekis
Type - Material: Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL03910.1E_Main Component; sets with these values: 2
Name (HL_Grate_HL03910.1E:HL03910.1E_Main Component:...)
4870052
4870233
4897209
4898669
5012283
5047483
5316526

# IfcFlowController: HL_RU_Anti-flooding valve_HL715.2-A_V21_240612:HL_Механический канализационный затвор_HL715.2, HL_RU_Anti-flooding valve_HL715.2-A_V21_240612:HL_Механический канализационный затвор_HL715.2:5290417
In: 0. Cokolinis Vandentiekis
Type - Material: Plastic - Orange, Plactic - White, Plastic - Red
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Pset_DistributionFlowElementCommon - Reference: HL_Механический канализационный затвор_HL715.2; sets with these values: 2
Group: F1 2 (1) (1) (1) (1) (1); F1 9

# IfcFlowController: HL_Rodding_eye_HL98-Index-A-2019-02-07:HL98 (18)
In: 0. Cokolinis Vandentiekis
Type - Material: Stainless Steel, Plactic - White
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Pset_DistributionFlowElementCommon - Reference: HL98; sets with these values: 2
Name (HL_Rodding_eye_HL98-Index-A-2019-02-07:HL98:...) | Group
5291092 | F1 2 (1) (1) (1) (1) (1)
5291976 | F1 2 (1) (1) (1) (1) (1)
5292191 | F1 2 (1) (1) (1) (1) (1)
5292399 | F1 9
5305802 | L1 1
5306232 | L1 1
5439384 | L1 2; F1 4
5441941 | L1 2; F1 6
5443515 | F1 2 (1) (1) (1) (1) (1)
5448131 | F1 5
5448660 | L1 1
5448891 | F1 7
5449366 | F1 9
5453246 | F1 8
5453717 | F1 2 (1) (1) (1) (1) (1)
5453961 | L1 1
5454385 | F1 9
5455504 | F1 9

# IfcFlowController: HL_Trap Seal_HL2100:HL2100_Main Component (7)
In: 0. Cokolinis Vandentiekis
Type - Material: Plactic - White, Plactic - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: HL Hutterer & Lechner GmbH
Classification: Main Component Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: HL2100_Main Component; sets with these values: 2
Name (HL_Trap Seal_HL2100:HL2100_Main Component:...)
4870051
4870232
4897208
4898668
5012282
5047482
5316525

# IfcFlowFitting: Bend - Plain - CI:Alkūnė, Bend - Plain - CI:Alkūnė:5293466
In: 1. Pirmas
Type - Material: F1
Pset_DistributionFlowElementCommon - Reference: Alkūnė; sets with these values: 2
Pset_PipeFittingTypeCommon - NominalDiameter: 150
Group: F1 2 1

# IfcFlowFitting: Geberit PE alkūnė_PRO_101543:DN40-150 / ø40-160 - OD (44)
Type - Description: Geberit PE alkūnė; PredefinedType: BEND; Material: GEB_PE100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit PE alkūnė
Pset_DistributionFlowElementCommon - Reference: DN40-150 / ø40-160 - OD; sets with these values: 2
Name (Geberit PE alkūnė_PRO_101543:DN40-150 / ø40-160 - OD:...) | In | Group
4659543 | Stogo ilaju aukštas | L1 1
4684065 | 1. Pirmas | L1 2
4686380 | 1. Pirmas | L1 1
4703169 | Pirmo aukšto antresolė | L1 1
4705909 | 1. Pirmas | L1 1
4705913 | 1. Pirmas | L1 1
4707125 | 1. Pirmas | L1 1
4707639 | 1. Pirmas | L1 1
5040833 | Stogo ilaju aukštas | L1 1
5040861 | Stogo ilaju aukštas | L1 1
5040865 | Stogo ilaju aukštas | L1 1
5041040 | Stogo ilaju aukštas | L1 1
5041130 | Pirmo aukšto antresolė | L1 1
5042398 | 1. Pirmas | L1 1
5044237 | Pirmo aukšto antresolė | L1 1
5044425 | Pirmo aukšto antresolė | L1 1
5045405 | Pirmo aukšto antresolė | L1 1
5045472 | Pirmo aukšto antresolė | L1 1
5045474 | Pirmo aukšto antresolė | L1 1
5045498 | Pirmo aukšto antresolė | L1 1
5046255 | Pirmo aukšto antresolė | L1 1
5046271 | Pirmo aukšto antresolė | L1 1
5046424 | Pirmo aukšto antresolė | L1 1
5047188 | Pirmo aukšto antresolė | L1 1
5047268 | Pirmo aukšto antresolė | L1 1
5058121 | Stogo ilaju aukštas | L1 2
5058140 | Stogo ilaju aukštas | L1 2
5061898 | 1. Pirmas | L1 1
5061921 | 1. Pirmas | L1 1
5062031 | Pirmo aukšto antresolė | L1 1
5063266 | 1. Pirmas | L1 2
5063790 | Pirmo aukšto antresolė | L1 2
5064246 | 1. Pirmas | L1 2
5064524 | Pirmo aukšto antresolė | L1 2
5181211 | 1. Pirmas | L1 1
5304519 | Stogo ilaju aukštas | L1 2
5304523 | Stogo ilaju aukštas | L1 2
5363024 | Pirmo aukšto antresolė | L1 1
5363028 | 1. Pirmas | L1 1
5363356 | Stogo ilaju aukštas | L1 2
5363370 | Stogas | L1 2
5363383 | Stogas | L1 2
5363686 | Stogo ilaju aukštas | L1 2
5363690 | Stogas | L1 2

# IfcFlowFitting: Geberit PE ekscentrinis redukcinis vamzdis, trumpas_PRO_101571:DN40-150 / ø40-160 - OD (6)
Type - Description: Geberit PE ekscentrinis redukcinis vamzdis, trumpas; PredefinedType: TRANSITION; Material: Aluminum, Anodized Red, GEB_PE100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit PE ekscentrinis redukcinis vamzdis, trumpas
Pset_DistributionFlowElementCommon - Reference: DN40-150 / ø40-160 - OD; sets with these values: 2
Name (Geberit PE ekscentrinis redukcinis vamzdis, trumpas_PRO_101571:DN40-150 / ø40-160 - OD:...) | In | Group
5062024 | Pirmo aukšto antresolė | L1 1
5203198 | Pirmo aukšto antresolė | L1 1
5303552 | Pirmo aukšto antresolė | L1 1
5307943 | Stogo ilaju aukštas | L1 2
5347180 | Stogo ilaju aukštas | L1 2
5347197 | Stogo ilaju aukštas | L1 1

# IfcFlowFitting: Geberit PE trišakis 88,5°_PRO_101559:DN40-300 / ø40-315 - OD (2)
Type - Description: Geberit PE trišakis 88,5°; PredefinedType: USERDEFINED; Material: Aluminum, Anodized Red, GEB_PE100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit PE trišakis 88,5°
Pset_DistributionFlowElementCommon - Reference: DN40-300 / ø40-315 - OD; sets with these values: 2
Name (Geberit PE trišakis 88,5°_PRO_101559:DN40-300 / ø40-315 - OD:...) | In | Group
5062019 | Pirmo aukšto antresolė | L1 1
5064250 | 1. Pirmas | L1 2

# IfcFlowFitting: Geberit PE trišakis 88,5°_PRO_101559:DN40-300 / ø40-315 - OD (13)
Type - Description: Geberit PE trišakis 88,5°; PredefinedType: USERDEFINED; Material: GEB_PE100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Name: Geberit PE trišakis 88,5°
Pset_DistributionFlowElementCommon - Reference: DN40-300 / ø40-315 - OD; sets with these values: 2
Name (Geberit PE trišakis 88,5°_PRO_101559:DN40-300 / ø40-315 - OD:...) | In | Group
4659775 | Stogo ilaju aukštas | L1 1
4659821 | Stogo ilaju aukštas | L1 1
4660752 | Stogo ilaju aukštas | L1 1
4660818 | Stogo ilaju aukštas | L1 1
4661578 | Stogo ilaju aukštas | L1 1
4663390 | Stogo ilaju aukštas | L1 2
4663413 | Stogo ilaju aukštas | L1 2
4663492 | Stogo ilaju aukštas | L1 2
4663528 | Stogo ilaju aukštas | L1 2
4663600 | Stogo ilaju aukštas | L1 2
5041134 | Pirmo aukšto antresolė | L1 1
5042442 | Pirmo aukšto antresolė | L1 1
5363270 | Stogo ilaju aukštas | L1 2
