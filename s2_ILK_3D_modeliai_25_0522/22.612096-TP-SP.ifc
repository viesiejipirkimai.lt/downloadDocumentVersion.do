Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , , ,]
Time: 2023-07-04T09:58:16
Author: User
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2020 - English UK Build 13.2.890.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 4 09:58:16 2023 * Host: DESKTOP-U6JCM4F * Database: C:\Users\User\AppData\Local\Temp\ACAIFCTMP/EDM10488\aec_ifc_db * Database version: 5507 * Database creation date: Tue Jul 4 09:29:33 2023 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Tue Jul 4 09:58:16 2023 * Header model: DataRepository.AecIfc_Header * Header model creation date: Tue Jul 4 09:58:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 3
LongName: 07 04 3d
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, 07 04 3d
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
