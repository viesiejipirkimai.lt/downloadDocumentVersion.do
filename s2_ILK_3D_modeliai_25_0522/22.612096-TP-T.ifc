Properties of the parts of a building model (IFC2X3), part 1 of 5

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-22T13:10:57+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 54, 45, 5, 681646; RefLongitude: 25, 16, 42, 718500; RefElevation: 152840 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 8
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (7)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Rūsys | Rūsys | -3760
Level 1 | Level 1 | 0
2 aukštas | 2 aukštas | 4500
3 aukštas | 3 aukštas | 9300
4 aukštas | 4 aukštas | 13800
5 aukštas | 5 aukštas | 18300
Esamo pastato parapetas | Esamo pastato parapetas | 19355.8

# IfcBuildingElementProxy: 2x230 V1:2x230 V (12)
In: 5 aukštas
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 2x230 V; sets with these values: 2
Pset_ProvisionForVoid - Width: 100 mm; Height: 50 mm; Depth: 100 mm
Name (2x230 V1:2x230 V:...) | Material
1096054
1096088 | <Unnamed>
1097622 | <Unnamed>
1097711 | <Unnamed>
1097798 | <Unnamed>
1107284 | <Unnamed>
1107320
1107530 | <Unnamed>
1107540 | <Unnamed>
1154900 | <Unnamed>
1155740 | <Unnamed>
1348640 | <Unnamed>

# IfcBuildingElementProxy: 2x230 V:2x230 V (342)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 2x230 V; sets with these values: 2
Pset_ProvisionForVoid - Depth: 100 mm
Name (2x230 V:2x230 V:...) | In | Width (mm) | Height (mm) | Material
552955 | 3 aukštas | 100 | 50
557511 | 3 aukštas | 100 | 50 | <Unnamed>
557566 | 3 aukštas | 100 | 50
557590 | 3 aukštas | 100 | 50 | <Unnamed>
566311 | 3 aukštas | 100 | 50 | <Unnamed>
566346 | 3 aukštas | 100 | 50 | <Unnamed>
566362 | 3 aukštas | 100 | 50 | <Unnamed>
566367 | 3 aukštas | 100 | 50 | <Unnamed>
566372 | 3 aukštas | 100 | 50 | <Unnamed>
566965 | 3 aukštas | 100 | 50 | <Unnamed>
569235 | 3 aukštas | 100 | 50
599770 | 4 aukštas | 100 | 50
599799 | 4 aukštas | 100 | 50 | <Unnamed>
609987 | 3 aukštas | 100 | 50 | <Unnamed>
626263 | 3 aukštas | 50 | 100
626294 | 3 aukštas | 100 | 50 | <Unnamed>
626316 | 3 aukštas | 50 | 100 | <Unnamed>
626420 | 3 aukštas | 50 | 100 | <Unnamed>
629069 | 3 aukštas | 100 | 50 | <Unnamed>
629214 | 3 aukštas | 100 | 50 | <Unnamed>
629277 | 3 aukštas | 100 | 50 | <Unnamed>
629418 | 3 aukštas | 100 | 50 | <Unnamed>
629597 | 3 aukštas | 100 | 50 | <Unnamed>
629880 | 3 aukštas | 100 | 50 | <Unnamed>
630029 | 3 aukštas | 100 | 50 | <Unnamed>
630166 | 3 aukštas | 100 | 50 | <Unnamed>
630522 | 3 aukštas | 100 | 50 | <Unnamed>
630782 | 3 aukštas | 100 | 50 | <Unnamed>
630787 | 3 aukštas | 100 | 50 | <Unnamed>
631975 | 3 aukštas | 100 | 50 | <Unnamed>
632085 | 3 aukštas | 100 | 50 | <Unnamed>
632212 | 3 aukštas | 100 | 50 | <Unnamed>
633999 | 3 aukštas | 100 | 50 | <Unnamed>
637107 | 3 aukštas | 100 | 50 | <Unnamed>
637186 | 3 aukštas | 100 | 50 | <Unnamed>
637399 | 3 aukštas | 100 | 50 | <Unnamed>
637668 | 3 aukštas | 100 | 50 | <Unnamed>
638449 | 2 aukštas | 100 | 50 | <Unnamed>
638450 | 2 aukštas | 100 | 50 | <Unnamed>
638492 | 2 aukštas | 100 | 50 | <Unnamed>
638497 | 2 aukštas | 100 | 50 | <Unnamed>
638565 | 2 aukštas | 100 | 50 | <Unnamed>
638570 | 2 aukštas | 100 | 50 | <Unnamed>
698418 | Level 1 | 100 | 50 | <Unnamed>
732601 | Level 1 | 100 | 50 | <Unnamed>
733024 | Level 1 | 100 | 50 | <Unnamed>
758312 | 4 aukštas | 100 | 50 | <Unnamed>
758325 | 4 aukštas | 100 | 50 | <Unnamed>
758351 | 4 aukštas | 50 | 100 | <Unnamed>
758455 | 4 aukštas | 50 | 100 | <Unnamed>
772804 | 3 aukštas | 50 | 100
772805 | 3 aukštas | 50 | 100 | <Unnamed>
772843 | 3 aukštas | 50 | 100 | <Unnamed>
772844 | 3 aukštas | 50 | 100 | <Unnamed>
772907 | 3 aukštas | 100 | 50 | <Unnamed>
772908 | 3 aukštas | 100 | 50 | <Unnamed>
775012 | 4 aukštas | 100 | 50 | <Unnamed>
792685 | Rūsys | 100 | 50 | <Unnamed>
793920 | Rūsys | 100 | 50 | <Unnamed>
794018 | Rūsys | 100 | 50
809360 | Rūsys | 100 | 50 | <Unnamed>
864135 | 2 aukštas | 100 | 50 | <Unnamed>
865499 | 2 aukštas | 100 | 50 | <Unnamed>
865848 | 2 aukštas | 100 | 50 | <Unnamed>
866270 | 2 aukštas | 100 | 50 | <Unnamed>
867218 | 2 aukštas | 100 | 50 | <Unnamed>
867305 | 2 aukštas | 100 | 50 | <Unnamed>
867546 | 2 aukštas | 100 | 50 | <Unnamed>
867758 | 2 aukštas | 100 | 50 | <Unnamed>
867921 | 2 aukštas | 100 | 50 | <Unnamed>
868457 | 2 aukštas | 100 | 50 | <Unnamed>
868578 | 2 aukštas | 100 | 50 | <Unnamed>
868784 | 2 aukštas | 100 | 50 | <Unnamed>
869119 | 2 aukštas | 100 | 50 | <Unnamed>
869190 | 2 aukštas | 100 | 50 | <Unnamed>
869660 | 2 aukštas | 100 | 50 | <Unnamed>
869720 | 2 aukštas | 100 | 50 | <Unnamed>
869798 | 2 aukštas | 100 | 50 | <Unnamed>
869931 | 2 aukštas | 100 | 50 | <Unnamed>
870044 | 2 aukštas | 100 | 50 | <Unnamed>
870197 | 2 aukštas | 100 | 50 | <Unnamed>
870256 | 2 aukštas | 100 | 50 | <Unnamed>
870315 | 2 aukštas | 100 | 50 | <Unnamed>
870510 | 2 aukštas | 100 | 50 | <Unnamed>
870833 | 2 aukštas | 100 | 50 | <Unnamed>
870992 | 2 aukštas | 100 | 50 | <Unnamed>
871149 | 2 aukštas | 100 | 50 | <Unnamed>
871250 | 2 aukštas | 100 | 50 | <Unnamed>
871397 | 2 aukštas | 100 | 50 | <Unnamed>
871592 | 2 aukštas | 100 | 50 | <Unnamed>
871745 | 2 aukštas | 100 | 50 | <Unnamed>
871862 | 2 aukštas | 100 | 50 | <Unnamed>
871923 | 2 aukštas | 100 | 50 | <Unnamed>
872041 | 2 aukštas | 100 | 50 | <Unnamed>
872078 | 2 aukštas | 100 | 50 | <Unnamed>
872083 | 2 aukštas | 100 | 50 | <Unnamed>
872260 | 2 aukštas | 100 | 50 | <Unnamed>
872417 | 2 aukštas | 100 | 50 | <Unnamed>
872596 | 2 aukštas | 100 | 50 | <Unnamed>
872805 | 2 aukštas | 100 | 50 | <Unnamed>
888019 | Level 1 | 100 | 50 | <Unnamed>
888822 | Level 1 | 100 | 50 | <Unnamed>
889000 | Level 1 | 100 | 50 | <Unnamed>
889216 | Level 1 | 100 | 50 | <Unnamed>
889325 | Level 1 | 100 | 50 | <Unnamed>
889460 | Level 1 | 100 | 50 | <Unnamed>
889648 | Level 1 | 100 | 50 | <Unnamed>
889931 | Level 1 | 100 | 50 | <Unnamed>
889970 | Level 1 | 100 | 50 | <Unnamed>
890131 | Level 1 | 100 | 50 | <Unnamed>
890224 | Level 1 | 100 | 50 | <Unnamed>
890876 | 3 aukštas | 100 | 50 | <Unnamed>
890900 | 3 aukštas | 100 | 50 | <Unnamed>
890905 | 3 aukštas | 100 | 50 | <Unnamed>
890910 | 3 aukštas | 100 | 50 | <Unnamed>
891007 | 3 aukštas | 100 | 50 | <Unnamed>
891034 | 3 aukštas | 100 | 50 | <Unnamed>
891039 | 3 aukštas | 100 | 50 | <Unnamed>
891044 | 3 aukštas | 100 | 50 | <Unnamed>
891366 | 3 aukštas | 100 | 50 | <Unnamed>
891655 | 3 aukštas | 100 | 50 | <Unnamed>
891718 | 3 aukštas | 100 | 50 | <Unnamed>
891823 | 3 aukštas | 100 | 50 | <Unnamed>
892280 | 3 aukštas | 100 | 50 | <Unnamed>
892480 | 3 aukštas | 100 | 50 | <Unnamed>
892745 | 3 aukštas | 100 | 50 | <Unnamed>
892864 | 3 aukštas | 100 | 50 | <Unnamed>
893003 | 3 aukštas | 100 | 50 | <Unnamed>
893293 | 3 aukštas | 100 | 50 | <Unnamed>
893298 | 3 aukštas | 100 | 50 | <Unnamed>
893303 | 3 aukštas | 100 | 50 | <Unnamed>
893420 | 3 aukštas | 100 | 50 | <Unnamed>
893612 | 4 aukštas | 100 | 50 | <Unnamed>
893645 | 4 aukštas | 100 | 50 | <Unnamed>
893688 | 4 aukštas | 100 | 50 | <Unnamed>
894067 | 4 aukštas | 100 | 50 | <Unnamed>
894226 | 4 aukštas | 100 | 50 | <Unnamed>
894344 | 4 aukštas | 100 | 50 | <Unnamed>
895631 | 4 aukštas | 100 | 50 | <Unnamed>
895656 | 4 aukštas | 100 | 50 | <Unnamed>
895661 | 4 aukštas | 100 | 50 | <Unnamed>
895666 | 4 aukštas | 100 | 50 | <Unnamed>
895758 | 4 aukštas | 100 | 50 | <Unnamed>
895847 | 4 aukštas | 100 | 50 | <Unnamed>
895852 | 4 aukštas | 100 | 50 | <Unnamed>
895966 | 4 aukštas | 100 | 50 | <Unnamed>
896065 | 4 aukštas | 100 | 50 | <Unnamed>
896391 | Rūsys | 100 | 50 | <Unnamed>
896758 | 2 aukštas | 100 | 50 | <Unnamed>
901696 | 2 aukštas | 100 | 50 | <Unnamed>
902443 | 2 aukštas | 100 | 50 | <Unnamed>
977585 | 2 aukštas | 100 | 50 | <Unnamed>
979883 | 2 aukštas | 100 | 50 | <Unnamed>
980093 | 2 aukštas | 100 | 50 | <Unnamed>
980229 | 3 aukštas | 100 | 50 | <Unnamed>
1005191 | 2 aukštas | 100 | 50 | <Unnamed>
1005240 | 2 aukštas | 100 | 50 | <Unnamed>
1005523 | 2 aukštas | 50 | 100 | <Unnamed>
1005525 | 2 aukštas | 50 | 100 | <Unnamed>
1005582 | 2 aukštas | 50 | 100 | <Unnamed>
1005584 | 2 aukštas | 50 | 100 | <Unnamed>
1005662 | 2 aukštas | 100 | 50 | <Unnamed>
1005664 | 2 aukštas | 100 | 50 | <Unnamed>
1014412 | 3 aukštas | 100 | 50 | <Unnamed>
1014427 | 3 aukštas | 100 | 50 | <Unnamed>
1014432 | 3 aukštas | 100 | 50 | <Unnamed>
1014672 | 3 aukštas | 100 | 50 | <Unnamed>
1014701 | 3 aukštas | 100 | 50 | <Unnamed>
1014748 | 3 aukštas | 100 | 50 | <Unnamed>
1014753 | 3 aukštas | 100 | 50 | <Unnamed>
1014774 | 3 aukštas | 100 | 50 | <Unnamed>
1014779 | 3 aukštas | 100 | 50 | <Unnamed>
1014784 | 3 aukštas | 100 | 50 | <Unnamed>
1026965 | 3 aukštas | 100 | 50 | <Unnamed>
1027896 | 3 aukštas | 100 | 50 | <Unnamed>
1028102 | 3 aukštas | 100 | 50 | <Unnamed>
1028263 | 3 aukštas | 100 | 50 | <Unnamed>
1028566 | 3 aukštas | 100 | 50 | <Unnamed>
1043436 | Level 1 | 100 | 50 | <Unnamed>
1043441 | Level 1 | 100 | 50 | <Unnamed>
1043548 | 4 aukštas | 100 | 50 | <Unnamed>
1043610 | 4 aukštas | 100 | 50 | <Unnamed>
1043685 | 4 aukštas | 50 | 100 | <Unnamed>
1043686 | 4 aukštas | 50 | 100 | <Unnamed>
1043736 | 4 aukštas | 50 | 100 | <Unnamed>
1043737 | 4 aukštas | 50 | 100 | <Unnamed>
1043740 | 4 aukštas | 100 | 50 | <Unnamed>
1043741 | 4 aukštas | 100 | 50 | <Unnamed>
1043797 | 4 aukštas | 50 | 100 | <Unnamed>
1043798 | 4 aukštas | 50 | 100 | <Unnamed>
1043801 | 4 aukštas | 100 | 50 | <Unnamed>
1043802 | 4 aukštas | 100 | 50 | <Unnamed>
1043830 | 4 aukštas | 100 | 50 | <Unnamed>
1043831 | 4 aukštas | 100 | 50 | <Unnamed>
1043936 | 4 aukštas | 50 | 100 | <Unnamed>
1043937 | 4 aukštas | 50 | 100 | <Unnamed>
1044001 | 4 aukštas | 100 | 50 | <Unnamed>
1044002 | 4 aukštas | 100 | 50 | <Unnamed>
1044006 | 4 aukštas | 50 | 100 | <Unnamed>
1044141 | 4 aukštas | 100 | 50 | <Unnamed>
1044180 | 4 aukštas | 100 | 50 | <Unnamed>
1044181 | 4 aukštas | 100 | 50 | <Unnamed>
1044184 | 4 aukštas | 50 | 100 | <Unnamed>
1044185 | 4 aukštas | 50 | 100 | <Unnamed>
1044195 | 4 aukštas | 100 | 50 | <Unnamed>
1044196 | 4 aukštas | 100 | 50 | <Unnamed>
1044199 | 4 aukštas | 50 | 100 | <Unnamed>
1044200 | 4 aukštas | 50 | 100 | <Unnamed>
1044219 | 4 aukštas | 50 | 100 | <Unnamed>
1044220 | 4 aukštas | 50 | 100 | <Unnamed>
1044239 | 4 aukštas | 100 | 50 | <Unnamed>
1044240 | 4 aukštas | 100 | 50 | <Unnamed>
1044285 | 4 aukštas | 100 | 50 | <Unnamed>
1044290 | 4 aukštas | 100 | 50 | <Unnamed>
1044305 | 4 aukštas | 100 | 50 | <Unnamed>
1044310 | 4 aukštas | 100 | 50 | <Unnamed>
1044315 | 4 aukštas | 100 | 50 | <Unnamed>
1044325 | 4 aukštas | 100 | 50 | <Unnamed>
1044362 | 4 aukštas | 100 | 50 | <Unnamed>
1044363 | 4 aukštas | 100 | 50 | <Unnamed>
1044364 | 4 aukštas | 100 | 50 | <Unnamed>
1044365 | 4 aukštas | 100 | 50 | <Unnamed>
1044377 | 4 aukštas | 100 | 50 | <Unnamed>
1044378 | 4 aukštas | 100 | 50 | <Unnamed>
1044379 | 4 aukštas | 100 | 50 | <Unnamed>
1044380 | 4 aukštas | 100 | 50 | <Unnamed>
1044846 | 4 aukštas | 100 | 50 | <Unnamed>
1045003 | 4 aukštas | 100 | 50 | <Unnamed>
1045191 | 4 aukštas | 100 | 50 | <Unnamed>
1045270 | 4 aukštas | 100 | 50 | <Unnamed>
1045408 | 4 aukštas | 100 | 50 | <Unnamed>
1045409 | 4 aukštas | 100 | 50 | <Unnamed>
1045469 | 4 aukštas | 100 | 50 | <Unnamed>
1045470 | 4 aukštas | 100 | 50 | <Unnamed>
1045826 | 4 aukštas | 100 | 50 | <Unnamed>
1049003 | Level 1 | 100 | 50 | <Unnamed>
1049028 | Level 1 | 100 | 50 | <Unnamed>
1049033 | Level 1 | 100 | 50 | <Unnamed>
1051918 | Level 1 | 100 | 50 | <Unnamed>
1051973 | Level 1 | 100 | 50 | <Unnamed>
1051978 | Level 1 | 100 | 50 | <Unnamed>
1051983 | Level 1 | 100 | 50 | <Unnamed>
1051988 | Level 1 | 100 | 50 | <Unnamed>
1051993 | Level 1 | 100 | 50 | <Unnamed>
1051998 | Level 1 | 100 | 50 | <Unnamed>
1052003 | Level 1 | 100 | 50 | <Unnamed>
1052022 | Level 1 | 100 | 50 | <Unnamed>
1052390 | Level 1 | 100 | 50 | <Unnamed>
1052611 | Rūsys | 100 | 50 | <Unnamed>
1052804 | Rūsys | 100 | 50 | <Unnamed>
1052841 | Rūsys | 100 | 50 | <Unnamed>
1060095 | 2 aukštas | 100 | 50 | <Unnamed>
1060100 | 2 aukštas | 100 | 50 | <Unnamed>
1060114 | 2 aukštas | 100 | 50 | <Unnamed>
1060124 | 2 aukštas | 100 | 50 | <Unnamed>
1060156 | 2 aukštas | 100 | 50 | <Unnamed>
1060157 | 2 aukštas | 100 | 50 | <Unnamed>
1060167 | 2 aukštas | 100 | 50 | <Unnamed>
1060168 | 2 aukštas | 100 | 50 | <Unnamed>
1060178 | 2 aukštas | 100 | 50 | <Unnamed>
1060179 | 2 aukštas | 100 | 50 | <Unnamed>
1060228 | 2 aukštas | 100 | 50 | <Unnamed>
1060229 | 2 aukštas | 100 | 50 | <Unnamed>
1060249 | 2 aukštas | 100 | 50 | <Unnamed>
1060250 | 2 aukštas | 100 | 50 | <Unnamed>
1060264 | 2 aukštas | 100 | 50 | <Unnamed>
1060265 | 2 aukštas | 100 | 50 | <Unnamed>
1060275 | 2 aukštas | 100 | 50 | <Unnamed>
1060276 | 2 aukštas | 100 | 50 | <Unnamed>
1060295 | 2 aukštas | 100 | 50 | <Unnamed>
1060318 | 2 aukštas | 100 | 50 | <Unnamed>
1060566 | 2 aukštas | 100 | 50 | <Unnamed>
1060829 | 2 aukštas | 100 | 50 | <Unnamed>
1061163 | 2 aukštas | 100 | 50 | <Unnamed>
1061490 | 2 aukštas | 100 | 50 | <Unnamed>
1061601 | 2 aukštas | 100 | 50 | <Unnamed>
1061606 | 2 aukštas | 100 | 50 | <Unnamed>
1061653 | 2 aukštas | 100 | 50 | <Unnamed>
1061658 | 2 aukštas | 100 | 50 | <Unnamed>
1061733 | 2 aukštas | 100 | 50 | <Unnamed>
1061754 | 2 aukštas | 100 | 50 | <Unnamed>
1061759 | 2 aukštas | 100 | 50 | <Unnamed>
1061768 | 2 aukštas | 100 | 50 | <Unnamed>
1061984 | 2 aukštas | 100 | 50 | <Unnamed>
1061989 | 2 aukštas | 100 | 50 | <Unnamed>
1061994 | 2 aukštas | 100 | 50 | <Unnamed>
1062084 | 2 aukštas | 100 | 50 | <Unnamed>
1062085 | 2 aukštas | 100 | 50 | <Unnamed>
1069000 | 2 aukštas | 100 | 50 | <Unnamed>
1069026 | 2 aukštas | 100 | 50 | <Unnamed>
1069425 | 2 aukštas | 100 | 50 | <Unnamed>
1069791 | 2 aukštas | 100 | 50 | <Unnamed>
1070519 | 2 aukštas | 50 | 100 | <Unnamed>
1070520 | 2 aukštas | 50 | 100 | <Unnamed>
1070731 | 2 aukštas | 100 | 50 | <Unnamed>
1070732 | 2 aukštas | 100 | 50 | <Unnamed>
1070735 | 2 aukštas | 50 | 100 | <Unnamed>
1070736 | 2 aukštas | 50 | 100 | <Unnamed>
1070782 | 2 aukštas | 100 | 50 | <Unnamed>
1070783 | 2 aukštas | 100 | 50 | <Unnamed>
1070786 | 2 aukštas | 50 | 100 | <Unnamed>
1070787 | 2 aukštas | 50 | 100 | <Unnamed>
1070799 | 2 aukštas | 100 | 50 | <Unnamed>
1070800 | 2 aukštas | 100 | 50 | <Unnamed>
1070803 | 2 aukštas | 50 | 100 | <Unnamed>
1070804 | 2 aukštas | 50 | 100 | <Unnamed>
1070866 | 2 aukštas | 50 | 100 | <Unnamed>
1070867 | 2 aukštas | 50 | 100 | <Unnamed>
1070868 | 2 aukštas | 50 | 100 | <Unnamed>
1070878 | 2 aukštas | 50 | 100 | <Unnamed>
1070879 | 2 aukštas | 50 | 100 | <Unnamed>
1070880 | 2 aukštas | 50 | 100 | <Unnamed>
1070945 | 2 aukštas | 100 | 50 | <Unnamed>
1070946 | 2 aukštas | 100 | 50 | <Unnamed>
1070947 | 2 aukštas | 100 | 50 | <Unnamed>
1071012 | 2 aukštas | 50 | 100 | <Unnamed>
1071013 | 2 aukštas | 50 | 100 | <Unnamed>
1071014 | 2 aukštas | 50 | 100 | <Unnamed>
1071015 | 2 aukštas | 100 | 50 | <Unnamed>
1071016 | 2 aukštas | 100 | 50 | <Unnamed>
1071017 | 2 aukštas | 100 | 50 | <Unnamed>
1073569 | 3 aukštas | 100 | 50 | <Unnamed>
1073788 | 3 aukštas | 100 | 50 | <Unnamed>
1073823 | 3 aukštas | 100 | 50 | <Unnamed>
1075461 | 3 aukštas | 100 | 50 | <Unnamed>
1076072 | 3 aukštas | 100 | 50 | <Unnamed>
1076994 | 3 aukštas | 100 | 50 | <Unnamed>
1078334 | 3 aukštas | 100 | 50 | <Unnamed>
1078388 | 3 aukštas | 100 | 50 | <Unnamed>
1078400 | 3 aukštas | 100 | 50 | <Unnamed>
1079056 | 3 aukštas | 100 | 50 | <Unnamed>
1085190 | 5 aukštas | 100 | 50 | <Unnamed>
1085775 | 3 aukštas | 100 | 50 | <Unnamed>
1100430 | 5 aukštas | 100 | 50 | <Unnamed>
1100435 | 5 aukštas | 100 | 50 | <Unnamed>
1103436 | 5 aukštas | 100 | 50 | <Unnamed>
1103640 | 5 aukštas | 100 | 50 | <Unnamed>
1103724 | 5 aukštas | 100 | 50 | <Unnamed>
1117162 | Level 1 | 100 | 50 | <Unnamed>
1154317 | 5 aukštas | 100 | 50 | <Unnamed>
1156044 | 5 aukštas | 100 | 50 | <Unnamed>
1156678 | 5 aukštas | 100 | 50 | <Unnamed>

# IfcBuildingElementProxy: 3 biosaugumo lygio laminarinė spinta:SEA-3 (2 Glove), 3 biosaugumo lygio laminarinė spinta:SEA-3 (2 Glove):1256361
In: 5 aukštas
Type - Material: <Unnamed> (2), Aluminum (4), Default (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: SEA-3 (2 Glove); sets with these values: 2

# IfcBuildingElementProxy: 3x230 V:3x230 V (2)
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 3x230 V; sets with these values: 2
Pset_ProvisionForVoid - Width: 100 mm; Height: 50 mm; Depth: 100 mm
Name (3x230 V:3x230 V:...) | In
888330 | Level 1
1258693 | 5 aukštas

# IfcBuildingElementProxy: 4x230 V:4x230 V (228)
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 4x230 V; sets with these values: 2
Pset_ProvisionForVoid - Depth: 100 mm
Name (4x230 V:4x230 V:...) | In | Width (mm) | Height (mm) | Material
557703 | 3 aukštas | 100 | 50
557789 | 3 aukštas | 100 | 50 | <Unnamed>
557822 | 3 aukštas | 100 | 50 | <Unnamed>
565459 | 3 aukštas | 100 | 50 | <Unnamed>
609861 | 3 aukštas | 100 | 50 | <Unnamed>
609872 | 3 aukštas | 100 | 50 | <Unnamed>
626259 | 3 aukštas | 50 | 100
626261 | 3 aukštas | 50 | 100 | <Unnamed>
626290 | 3 aukštas | 100 | 50 | <Unnamed>
626292 | 3 aukštas | 100 | 50 | <Unnamed>
626312 | 3 aukštas | 50 | 100 | <Unnamed>
626314 | 3 aukštas | 50 | 100 | <Unnamed>
626416 | 3 aukštas | 50 | 100 | <Unnamed>
626418 | 3 aukštas | 50 | 100 | <Unnamed>
628303 | 3 aukštas | 100 | 50 | <Unnamed>
628550 | 3 aukštas | 100 | 50 | <Unnamed>
628555 | 3 aukštas | 100 | 50 | <Unnamed>
635364 | 3 aukštas | 100 | 50 | <Unnamed>
635487 | 3 aukštas | 100 | 50 | <Unnamed>
635492 | 3 aukštas | 100 | 50 | <Unnamed>
635497 | 3 aukštas | 100 | 50 | <Unnamed>
635502 | 3 aukštas | 100 | 50 | <Unnamed>
635595 | 3 aukštas | 100 | 50 | <Unnamed>
635760 | 3 aukštas | 100 | 50 | <Unnamed>
635907 | 3 aukštas | 100 | 50 | <Unnamed>
635941 | 3 aukštas | 100 | 50 | <Unnamed>
636534 | 3 aukštas | 100 | 50 | <Unnamed>
649991 | 3 aukštas | 100 | 50 | <Unnamed>
651195 | 3 aukštas | 100 | 50 | <Unnamed>
651775 | 3 aukštas | 100 | 50 | <Unnamed>
651795 | 3 aukštas | 100 | 50 | <Unnamed>
865773 | 2 aukštas | 100 | 50 | <Unnamed>
868871 | 2 aukštas | 100 | 50
869069 | 2 aukštas | 100 | 50 | <Unnamed>
869333 | 2 aukštas | 100 | 50 | <Unnamed>
869537 | 2 aukštas | 100 | 50 | <Unnamed>
886054 | Level 1 | 100 | 50 | <Unnamed>
886958 | Level 1 | 100 | 50 | <Unnamed>
887265 | Level 1 | 100 | 50 | <Unnamed>
887408 | Level 1 | 100 | 50 | <Unnamed>
890736 | Level 1 | 100 | 50 | <Unnamed>
890827 | Level 1 | 100 | 50 | <Unnamed>
891427 | 3 aukštas | 100 | 50 | <Unnamed>
891445 | 3 aukštas | 100 | 50 | <Unnamed>
891597 | 3 aukštas | 100 | 50 | <Unnamed>
892028 | 3 aukštas | 100 | 50 | <Unnamed>
948415 | 2 aukštas | 50 | 100 | <Unnamed>
954901 | 2 aukštas | 100 | 50 | <Unnamed>
955305 | 2 aukštas | 100 | 50 | <Unnamed>
959558 | 2 aukštas | 50 | 100 | <Unnamed>
977167 | 2 aukštas | 50 | 100 | <Unnamed>
977197 | 2 aukštas | 50 | 100 | <Unnamed>
977379 | 2 aukštas | 100 | 50 | <Unnamed>
977382 | 2 aukštas | 100 | 50 | <Unnamed>
1014565 | 3 aukštas | 100 | 50 | <Unnamed>
1026790 | 3 aukštas | 100 | 50 | <Unnamed>
1026799 | 3 aukštas | 100 | 50 | <Unnamed>
1027057 | 4 aukštas | 100 | 50 | <Unnamed>
1027059 | 4 aukštas | 100 | 50 | <Unnamed>
1027061 | 4 aukštas | 100 | 50 | <Unnamed>
1027063 | 4 aukštas | 100 | 50 | <Unnamed>
1027065 | 4 aukštas | 100 | 50 | <Unnamed>
1027067 | 4 aukštas | 100 | 50 | <Unnamed>
1027069 | 4 aukštas | 100 | 50 | <Unnamed>
1027071 | 4 aukštas | 100 | 50 | <Unnamed>
1027073 | 4 aukštas | 100 | 50 | <Unnamed>
1027075 | 4 aukštas | 100 | 50 | <Unnamed>
1027081 | 4 aukštas | 100 | 50 | <Unnamed>
1027087 | 4 aukštas | 100 | 50 | <Unnamed>
1027089 | 4 aukštas | 50 | 100 | <Unnamed>
1027091 | 4 aukštas | 50 | 100 | <Unnamed>
1027095 | 4 aukštas | 100 | 50 | <Unnamed>
1027097 | 4 aukštas | 100 | 50 | <Unnamed>
1027099 | 4 aukštas | 50 | 100 | <Unnamed>
1027432 | 4 aukštas | 100 | 50 | <Unnamed>
1027471 | 4 aukštas | 100 | 50 | <Unnamed>
1027484 | 4 aukštas | 100 | 50 | <Unnamed>
1027536 | 4 aukštas | 100 | 50 | <Unnamed>
1027547 | 4 aukštas | 100 | 50 | <Unnamed>
1028058 | 3 aukštas | 100 | 50 | <Unnamed>
1028670 | 4 aukštas | 100 | 50 | <Unnamed>
1043430 | Level 1 | 100 | 50 | <Unnamed>
1043434 | Level 1 | 100 | 50 | <Unnamed>
1044489 | 4 aukštas | 100 | 50 | <Unnamed>
1044491 | 4 aukštas | 100 | 50 | <Unnamed>
1044650 | 4 aukštas | 100 | 50 | <Unnamed>
1044659 | 4 aukštas | 50 | 100 | <Unnamed>
1044662 | 4 aukštas | 50 | 100 | <Unnamed>
1045588 | Level 1 | 100 | 50 | <Unnamed>
1045693 | Level 1 | 50 | 100 | <Unnamed>
1045703 | Level 1 | 100 | 50 | <Unnamed>
1045705 | Level 1 | 100 | 50 | <Unnamed>
1045735 | Level 1 | 100 | 50 | <Unnamed>
1045737 | Level 1 | 100 | 50 | <Unnamed>
1045747 | Level 1 | 100 | 50 | <Unnamed>
1045749 | Level 1 | 100 | 50 | <Unnamed>
1045812 | 4 aukštas | 50 | 100 | <Unnamed>
1045814 | 4 aukštas | 50 | 100 | <Unnamed>
1045872 | 4 aukštas | 100 | 50 | <Unnamed>
1045909 | 4 aukštas | 100 | 50 | <Unnamed>
1047890 | Level 1 | 100 | 50 | <Unnamed>
1047892 | Level 1 | 100 | 50 | <Unnamed>
1049074 | Level 1 | 100 | 50 | <Unnamed>
1049250 | 4 aukštas | 100 | 50 | <Unnamed>
1052435 | Level 1 | 50 | 100 | <Unnamed>
1052437 | Level 1 | 50 | 100 | <Unnamed>
1052439 | Level 1 | 50 | 100 | <Unnamed>
1052441 | Level 1 | 50 | 100 | <Unnamed>
1052498 | Level 1 | 100 | 50 | <Unnamed>
1052566 | Rūsys | 100 | 50 | <Unnamed>
1052577 | Rūsys | 100 | 50 | <Unnamed>
1058992 | 2 aukštas | 100 | 50 | <Unnamed>
1059119 | 2 aukštas | 100 | 50 | <Unnamed>
1059130 | 2 aukštas | 100 | 50 | <Unnamed>
1059143 | 2 aukštas | 100 | 50 | <Unnamed>
1059162 | 2 aukštas | 100 | 50 | <Unnamed>
1059187 | 2 aukštas | 100 | 50 | <Unnamed>
1059198 | 2 aukštas | 100 | 50 | <Unnamed>
1059230 | 2 aukštas | 100 | 50 | <Unnamed>
1059243 | 2 aukštas | 100 | 50 | <Unnamed>
1059256 | 2 aukštas | 100 | 50 | <Unnamed>
1059606 | 2 aukštas | 100 | 50 | <Unnamed>
1059608 | 2 aukštas | 100 | 50 | <Unnamed>
1059610 | 2 aukštas | 100 | 50 | <Unnamed>
1059612 | 2 aukštas | 100 | 50 | <Unnamed>
1059614 | 2 aukštas | 100 | 50 | <Unnamed>
1059616 | 2 aukštas | 100 | 50 | <Unnamed>
1059618 | 2 aukštas | 100 | 50 | <Unnamed>
1059620 | 2 aukštas | 100 | 50 | <Unnamed>
1059622 | 2 aukštas | 100 | 50 | <Unnamed>
1059624 | 2 aukštas | 100 | 50 | <Unnamed>
1060899 | 2 aukštas | 100 | 50 | <Unnamed>
1061571 | 2 aukštas | 50 | 100 | <Unnamed>
1061576 | 2 aukštas | 50 | 100 | <Unnamed>
1061613 | 2 aukštas | 50 | 100 | <Unnamed>
1061617 | 2 aukštas | 50 | 100 | <Unnamed>
1061640 | 2 aukštas | 50 | 100 | <Unnamed>
1061673 | 2 aukštas | 50 | 100 | <Unnamed>
1061699 | 2 aukštas | 50 | 100 | <Unnamed>
1061717 | 2 aukštas | 50 | 100 | <Unnamed>
1061719 | 2 aukštas | 50 | 100 | <Unnamed>
1062010 | 2 aukštas | 50 | 100 | <Unnamed>
1062012 | 2 aukštas | 100 | 50 | <Unnamed>
1062014 | 2 aukštas | 100 | 50 | <Unnamed>
1062016 | 2 aukštas | 100 | 50 | <Unnamed>
1062096 | 2 aukštas | 100 | 50 | <Unnamed>
1062141 | 2 aukštas | 50 | 100 | <Unnamed>
1062145 | 2 aukštas | 50 | 100 | <Unnamed>
1062147 | 2 aukštas | 50 | 100 | <Unnamed>
1062157 | 2 aukštas | 100 | 50 | <Unnamed>
1062247 | 2 aukštas | 50 | 100 | <Unnamed>
1062249 | 2 aukštas | 50 | 100 | <Unnamed>
1062278 | 2 aukštas | 100 | 50 | <Unnamed>
1062294 | 2 aukštas | 50 | 100 | <Unnamed>
1062298 | 2 aukštas | 50 | 100 | <Unnamed>
1062300 | 2 aukštas | 100 | 50 | <Unnamed>
1068972 | 2 aukštas | 100 | 50 | <Unnamed>
1069809 | 2 aukštas | 100 | 50 | <Unnamed>
1070195 | 2 aukštas | 100 | 50 | <Unnamed>
1070264 | 2 aukštas | 100 | 50 | <Unnamed>
1071081 | 2 aukštas | 100 | 50 | <Unnamed>
1071083 | 2 aukštas | 100 | 50 | <Unnamed>
1071085 | 2 aukštas | 100 | 50 | <Unnamed>
1071088 | 2 aukštas | 50 | 100 | <Unnamed>
1071090 | 2 aukštas | 50 | 100 | <Unnamed>
1079077 | 3 aukštas | 100 | 50 | <Unnamed>
1086327 | 5 aukštas | 50 | 100 | <Unnamed>
1086329 | 5 aukštas | 50 | 100 | <Unnamed>
1086331 | 5 aukštas | 50 | 100 | <Unnamed>
1086333 | 5 aukštas | 50 | 100 | <Unnamed>
1086335 | 5 aukštas | 50 | 100 | <Unnamed>
1086337 | 5 aukštas | 50 | 100 | <Unnamed>
1086339 | 5 aukštas | 50 | 100 | <Unnamed>
1086341 | 5 aukštas | 50 | 100 | <Unnamed>
1086343 | 5 aukštas | 50 | 100 | <Unnamed>
1086345 | 5 aukštas | 50 | 100 | <Unnamed>
1086347 | 5 aukštas | 50 | 100 | <Unnamed>
1086349 | 5 aukštas | 50 | 100 | <Unnamed>
1086423 | 5 aukštas | 100 | 50 | <Unnamed>
1086448 | 5 aukštas | 100 | 50 | <Unnamed>
1086467 | 5 aukštas | 100 | 50 | <Unnamed>
1086468 | 5 aukštas | 100 | 50 | <Unnamed>
1086478 | 5 aukštas | 100 | 50 | <Unnamed>
1086479 | 5 aukštas | 100 | 50 | <Unnamed>
1095448 | 5 aukštas | 100 | 50 | <Unnamed>
1095453 | 5 aukštas | 100 | 50 | <Unnamed>
1095458 | 5 aukštas | 100 | 50 | <Unnamed>
1095463 | 5 aukštas | 100 | 50 | <Unnamed>
1095468 | 5 aukštas | 100 | 50 | <Unnamed>
1095473 | 5 aukštas | 100 | 50 | <Unnamed>
1095795 | 5 aukštas | 100 | 50 | <Unnamed>
1095800 | 5 aukštas | 100 | 50 | <Unnamed>
1096111 | 5 aukštas | 50 | 100 | <Unnamed>
1100428 | 5 aukštas | 100 | 50 | <Unnamed>
1100646 | 5 aukštas | 50 | 100 | <Unnamed>
1107288 | 5 aukštas | 50 | 100 | <Unnamed>
1107534 | 5 aukštas | 50 | 100 | <Unnamed>
1154610 | 5 aukštas | 100 | 50 | <Unnamed>
1156334 | 5 aukštas | 100 | 50 | <Unnamed>
1156626 | 5 aukštas | 100 | 50 | <Unnamed>
1156758 | 5 aukštas | 100 | 50 | <Unnamed>
1158205 | 4 aukštas | 100 | 50 | <Unnamed>
1158215 | 4 aukštas | 100 | 50 | <Unnamed>
1158234 | 4 aukštas | 100 | 50 | <Unnamed>
1158241 | 4 aukštas | 100 | 50 | <Unnamed>
1158260 | 4 aukštas | 100 | 50 | <Unnamed>
1158263 | 4 aukštas | 100 | 50 | <Unnamed>
1158284 | 4 aukštas | 100 | 50 | <Unnamed>
1158287 | 4 aukštas | 100 | 50 | <Unnamed>
1158299 | 4 aukštas | 100 | 50 | <Unnamed>
1158306 | 4 aukštas | 100 | 50 | <Unnamed>
1158313 | 4 aukštas | 100 | 50 | <Unnamed>
1158320 | 4 aukštas | 100 | 50 | <Unnamed>
1159740 | 4 aukštas | 50 | 100 | <Unnamed>
1209237 | Rūsys | 50 | 100 | <Unnamed>
1209664 | Rūsys | 100 | 50 | <Unnamed>
1210517 | Rūsys | 100 | 50 | <Unnamed>
1211107 | Rūsys | 100 | 50 | <Unnamed>
1342383 | 5 aukštas | 100 | 50 | <Unnamed>
1343364 | 5 aukštas | 100 | 50 | <Unnamed>
1343374 | 5 aukštas | 100 | 50 | <Unnamed>
1343416 | 5 aukštas | 100 | 50 | <Unnamed>
1344888 | 5 aukštas | 100 | 50 | <Unnamed>
1345007 | 5 aukštas | 100 | 50 | <Unnamed>
1345062 | 5 aukštas | 100 | 50 | <Unnamed>
1354587 | 5 aukštas | 100 | 50 | <Unnamed>
1381917 | 5 aukštas | 100 | 50 | <Unnamed>
1393181 | 2 aukštas | 100 | 50 | <Unnamed>

# IfcBuildingElementProxy: 4x230 V:4x230 V, I KAT (2)
In: 2 aukštas
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 4x230 V, I KAT; sets with these values: 2
Pset_ProvisionForVoid - Width: 100 mm; Height: 50 mm; Depth: 100 mm
Name (4x230 V:4x230 V, I KAT:...)
902223
977502 | Material: <Unnamed>

# IfcBuildingElementProxy: 60_inch_undercounter_commercial_refrigerator_11201:Stalas šaldytuvas 1300x700x900, 60_inch_undercounter_commercial_refrigerator_11201:Stalas šaldytuvas 1300x700x900:672570
In: Level 1
Type - Material: True Stainless Steel (20), Black Plastic (4)
Type - Pset_ManufacturerTypeInformation - Manufacturer: TRUE
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Stalas šaldytuvas 1300x700x900; sets with these values: 2
Pset_ProvisionForVoid - Width: 700 mm; Height: 1300 mm; Depth: 38.1 mm

# IfcBuildingElementProxy: 6x230 V:6x230 V (12)
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 6x230 V; sets with these values: 2
Pset_ProvisionForVoid - Depth: 100 mm
Name (6x230 V:6x230 V:...) | In | Width (mm) | Height (mm) | Material
1005158 | 2 aukštas | 100 | 50
1005363 | 2 aukštas | 100 | 50 | <Unnamed>
1005522 | 2 aukštas | 50 | 100
1005530 | 2 aukštas | 50 | 100 | <Unnamed>
1005581 | 2 aukštas | 50 | 100 | <Unnamed>
1005589 | 2 aukštas | 50 | 100 | <Unnamed>
1005661 | 2 aukštas | 100 | 50 | <Unnamed>
1005668 | 2 aukštas | 100 | 50 | <Unnamed>
1099175 | 5 aukštas | 100 | 50
1099273 | 5 aukštas | 100 | 50 | <Unnamed>
1099546 | 5 aukštas | 100 | 50 | <Unnamed>
1099617 | 5 aukštas | 100 | 50 | <Unnamed>

# IfcBuildingElementProxy: Atleikų dezinfekcijos įrenginys:Atleikų dezinfekcijos įrenginys, Atleikų dezinfekcijos įrenginys:Atleikų dezinfekcijos įrenginys:788434
In: Rūsys
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Atleikų dezinfekcijos įrenginys; sets with these values: 2
Pset_ProvisionForVoid - Width: 1200 mm; Height: 1600 mm; Depth: 1250 mm

# IfcBuildingElementProxy: Autoklavas:Autoklavas (LAB), Autoklavas:Autoklavas (LAB):1118695
In: 5 aukštas
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Autoklavas (LAB); sets with these values: 2
Pset_ProvisionForVoid - Width: 1660 mm; Height: 1070 mm; Depth: 100 mm

# IfcBuildingElementProxy: Autoklavas_6200:Autoklavas_6200, Autoklavas_6200:Autoklavas_6200:801506
In: Rūsys
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Autoklavas_6200; sets with these values: 2
Pset_ProvisionForVoid - Width: 1820 mm; Height: 1000 mm; Depth: 2900 mm

# IfcBuildingElementProxy: Autoklavas_6200:Autoklavas_6200 (LAB), Autoklavas_6200:Autoklavas_6200 (LAB):1258890
In: 5 aukštas
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Autoklavas_6200 (LAB); sets with these values: 2
Pset_ProvisionForVoid - Width: 1820 mm; Height: 1000 mm; Depth: 2900 mm

# IfcBuildingElementProxy: Autoklavas_8SV:Autoklavas_8SV, Autoklavas_8SV:Autoklavas_8SV:815746
In: 4 aukštas
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Autoklavas_8SV; sets with these values: 2
Pset_ProvisionForVoid - Width: 1620 mm; Height: 1000 mm; Depth: 2900 mm

# IfcBuildingElementProxy: Bakteriocidinė lempa:Bakteriocidinė lempa (11)
Type - Material: Default, Aluminum (2), Aluminum(1) (2)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Bakteriocidinė lempa; sets with these values: 2
Name (Bakteriocidinė lempa:Bakteriocidinė lempa:...) | In | Material
1111925 | 5 aukštas
1375768 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1375796 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1377486 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1377505 | 5 aukštas | Default, Aluminum, Aluminum(1)
1377746 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1377811 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1377891 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1377937 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1378010 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)
1385898 | Esamo pastato parapetas | Default, Aluminum, Aluminum(1)

# IfcBuildingElementProxy: Baro baldas_prie sienos:3300x600, Baro baldas_prie sienos:3300x600:702288
In: Level 1
Type - Material: <Unnamed> (5), Porcelain, Linen, Steel, Polished
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: 3300x600; sets with these values: 2

# IfcBuildingElementProxy: Basonų plovimo mašina 650x650:Basonų plovimo mašina 650x650 (13)
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Basonų plovimo mašina 650x650; sets with these values: 2
Pset_ProvisionForVoid - Width: 650 mm; Height: 650 mm; Depth: 1800 mm
Name (Basonų plovimo mašina 650x650:Basonų plovimo mašina 650x650:...) | In | Material
633310 | 3 aukštas
633686 | 3 aukštas | <Unnamed>
633821 | 3 aukštas | <Unnamed>
638620 | 2 aukštas | <Unnamed>
638708 | 2 aukštas | <Unnamed>
698357 | 4 aukštas | <Unnamed>
724949 | 2 aukštas | <Unnamed>
726483 | 2 aukštas | <Unnamed>
759037 | 4 aukštas | <Unnamed>
769315 | 2 aukštas | <Unnamed>
777102 | 2 aukštas | <Unnamed>
777146 | 2 aukštas | <Unnamed>
807848 | 4 aukštas | <Unnamed>

# IfcBuildingElementProxy: Cabinet Universal Max 3 Doors With Sink:SP.PL.D_12/6 2 (9)
Type - Material: Porcelain, Linen, Steel, Polished, <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: SP.PL.D_12/6 2; sets with these values: 2
Name (Cabinet Universal Max 3 Doors With Sink:SP.PL.D_12/6 2:...) | In | Material
564550 | 3 aukštas
564889 | 3 aukštas
564993 | 3 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
732597 | Level 1 | Porcelain, Linen, Steel, Polished, <Unnamed>
733020 | Level 1 | Porcelain, Linen, Steel, Polished, <Unnamed>
775006 | 4 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
792681 | Rūsys | Porcelain, Linen, Steel, Polished, <Unnamed>
866267 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
1085186 | 5 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>

# IfcBuildingElementProxy: Cabinet Universal Max 3 Doors With Sink:SP.PL.D_9/6 (11)
Type - Material: Porcelain, Linen, Steel, Polished, <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: SP.PL.D_9/6; sets with these values: 2
Name (Cabinet Universal Max 3 Doors With Sink:SP.PL.D_9/6:...) | In | Material
427648 | 3 aukštas
435279 | 2 aukštas
436371 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
437950 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
560643 | 4 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
566504 | 3 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
776531 | 4 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
830428 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
858697 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
860618 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>
861748 | 2 aukštas | Porcelain, Linen, Steel, Polished, <Unnamed>

# IfcBuildingElementProxy: Cabinet Universal Max 3 Doors With Sink:SP.PL.K_12/6, Cabinet Universal Max 3 Doors With Sink:SP.PL.K_12/6:440841
In: 4 aukštas
Type - Material: Porcelain, Linen, Steel, Polished, <Unnamed> (13)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: SP.PL.K_12/6; sets with these values: 2

# IfcBuildingElementProxy: Cash_Register-POS_4281:Kasos aparatas, Cash_Register-POS_4281:Kasos aparatas:673734
In: Level 1
Type - Material: <Unnamed> (28), Default (18)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Kasos aparatas; sets with these values: 2

# IfcBuildingElementProxy: Cash_Register-POS_4281:Kasos aparatas (kavinėje), Cash_Register-POS_4281:Kasos aparatas (kavinėje):887795
In: Level 1
Type - Material: <Unnamed> (28), Default (18)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Kasos aparatas (kavinėje); sets with these values: 2

# IfcBuildingElementProxy: Cash_Register-POS_4281:Kasos aparatas (vaistinėje) (2)
In: Level 1
Type - Material: <Unnamed> (28), Default (18)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Kasos aparatas (vaistinėje); sets with these values: 2
Name (Cash_Register-POS_4281:Kasos aparatas (vaistinėje):...)
736814
890849 | Material: <Unnamed>, Default

# IfcBuildingElementProxy: Centrifuga:Centrifuga (14)
In: 5 aukštas
Type - Material: Default(grey) (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Centrifuga; sets with these values: 2
Pset_ProvisionForVoid - Width: 585 mm; Height: 630 mm; Depth: 312 mm
Name (Centrifuga:Centrifuga:...) | Material
1113432
1197785 | Default(grey)
1197837 | Default(grey)
1197902 | Default(grey)
1198060 | Default(grey)
1212085 | Default(grey)
1212268 | Default(grey)
1212321 | Default(grey)
1212453 | Default(grey)
1212518 | Default(grey)
1212528 | Default(grey)
1232599 | Default(grey)
1233090 | Default(grey)
1343736 | Default(grey)

# IfcBuildingElementProxy: Convection_Oven 6GN 850x842x1014:38" x 36", Convection_Oven 6GN 850x842x1014:38" x 36":658708
In: Level 1
Type - Classification: E1090320 Food Service - Appliances & Equipment (Uniformat); Material: Metal - Stainless Steel (4), Glass, <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 38" x 36"; sets with these values: 2

# IfcBuildingElementProxy: Deep_fryer_10650:Gruzdintuvė, 15L, 400x730x900, Deep_fryer_10650:Gruzdintuvė, 15L, 400x730x900:662318
In: Level 1
Type - Material: body (7), Led (2), Front Body (5), Button (14), Control Panel, Basket
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Gruzdintuvė, 15L, 400x730x900; sets with these values: 2

# IfcBuildingElementProxy: Dezinfekcijos kamera:Dezinfekcijos kamera, Dezinfekcijos kamera:Dezinfekcijos kamera:718099
In: Rūsys
Type - Material: <Unnamed> (17)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Dezinfekcijos kamera; sets with these values: 2
Pset_ProvisionForVoid - Width: 2422 mm; Height: 2725 mm; Depth: 2300 mm

# IfcBuildingElementProxy: Dezinfekcijos kamera:Dezinfekcijos kamera lovų rėmų, Dezinfekcijos kamera:Dezinfekcijos kamera lovų rėmų:719014
In: Rūsys
Type - Material: <Unnamed> (17)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Dezinfekcijos kamera lovų rėmų; sets with these values: 2
Pset_ProvisionForVoid - Width: 2422 mm; Height: 2725 mm; Depth: 2300 mm

# IfcBuildingElementProxy: Dezinfekcinio skysčio dozavimo sistema:Dezinfekcinio skysčio dozavimo sistema (11)
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Dezinfekcinio skysčio dozavimo sistema; sets with these values: 2
Pset_ProvisionForVoid - Width: 200 mm; Height: 495 mm; Depth: 425 mm
Name (Dezinfekcinio skysčio dozavimo sistema:Dezinfekcinio skysčio dozavimo sistema:...) | In | Material
804883 | 3 aukštas
805252 | Rūsys | <Unnamed>
805337 | 2 aukštas | <Unnamed>
806189 | 2 aukštas | <Unnamed>
806539 | 2 aukštas | <Unnamed>
806861 | 4 aukštas | <Unnamed>
807279 | 4 aukštas | <Unnamed>
807496 | 4 aukštas | <Unnamed>
808753 | 3 aukštas | <Unnamed>
809175 | 3 aukštas | <Unnamed>
811329 | 2 aukštas | <Unnamed>

# IfcBuildingElementProxy: Diagnostinis point-of-care aparatas:Diagnostinis point-of-care aparatas (3)
In: 5 aukštas
Type - Material: Default(grey)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Diagnostinis point-of-care aparatas; sets with these values: 2
Pset_ProvisionForVoid - Width: 560 mm; Height: 570 mm; Depth: 550 mm
Name (Diagnostinis point-of-care aparatas:Diagnostinis point-of-care aparatas:...)
1237190
1237455
1237463

# IfcBuildingElementProxy: ELISA aparatas:ELISA aparatas, ELISA aparatas:ELISA aparatas:1234442
In: 5 aukštas
Type - Material: Default(grey)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: ELISA aparatas; sets with these values: 2
Pset_ProvisionForVoid - Width: 490 mm; Height: 550 mm; Depth: 460 mm

# IfcBuildingElementProxy: Echoskopijos aparatas:Echoskopijos aparatas (2)
In: 2 aukštas
Type - Material: <Unnamed> (3), black tire (5), plastic - blue (3), plastic - beige (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Echoskopijos aparatas; sets with these values: 2
Name (Echoskopijos aparatas:Echoskopijos aparatas:...)
600003
859038

# IfcBuildingElementProxy: Freezer_340:Šaldytuvas 750x830x2010 V (2)
In: Level 1
Type - Classification: E1090320 Food Service - Appliances & Equipment (Uniformat); Material: Metal - Stainless Steel (9), Slate, <Unnamed>
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 750 mm; Height: 2010 mm; Depth: 830 mm
Pset_BuildingElementProxyCommon - Reference: Šaldytuvas 750x830x2010 V; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.2286 mm
Name (Freezer_340:Šaldytuvas 750x830x2010 V:...)
688230
692272 | Material: Metal - Stainless Steel, Slate, <Unnamed>

# IfcBuildingElementProxy: Inkubatorius:Inkubatorius (6)
In: 5 aukštas
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Inkubatorius; sets with these values: 2
Pset_ProvisionForVoid - Width: 640 mm; Height: 755 mm; Depth: 100 mm
Name (Inkubatorius:Inkubatorius:...) | Material
1213956
1214007 | <Unnamed>
1214012 | <Unnamed>
1214196 | <Unnamed>
1214281 | <Unnamed>
1214289 | <Unnamed>

# IfcBuildingElementProxy: Instrumentų plovimo mašina:Instrumentų plovimo mašina, Instrumentų plovimo mašina:Instrumentų plovimo mašina:801409
In: Rūsys
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Instrumentų plovimo mašina; sets with these values: 2
Pset_ProvisionForVoid - Width: 1000 mm; Height: 900 mm; Depth: 1990 mm

# IfcBuildingElementProxy: Integruota indaplovė:Indų plovimo mašina pramoninė, Integruota indaplovė:Indų plovimo mašina pramoninė:689009
In: Level 1
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Indų plovimo mašina pramoninė; sets with these values: 2
Pset_ProvisionForVoid - Width: 600 mm; Height: 558 mm; Depth: 100 mm

# IfcBuildingElementProxy: KT:KT (2)
In: 2 aukštas
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: KT; sets with these values: 2
Pset_ProvisionForVoid - Depth: 2300 mm
Name (KT:KT:...) | Width (mm) | Height (mm)
783889 | 962.078 | 2316.85
784769 | 2316.85 | 962.078

# IfcBuildingElementProxy: Kabelių nuvedimo taškas:Kabelių nuvedimo taškas (2)
In: 5 aukštas
Type - Material: Default(RED)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Kabelių nuvedimo taškas; sets with these values: 2
Name (Kabelių nuvedimo taškas:Kabelių nuvedimo taškas:...)
1378134
1378949

# IfcBuildingElementProxy: Laboratorinis stalas su plautuve 1500x750:1500x750 (4)
In: 5 aukštas
Type - Material: <Unnamed> (13), Johnsonsuisse - Gemelli - 261 White glossy, Johnsonsuisse - Gemelli - Chrome
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: 1500x750; sets with these values: 2
Name (Laboratorinis stalas su plautuve 1500x750:1500x750:...)
494742
494810 | Material: <Unnamed>, Johnsonsuisse - Gemelli - 261 White glossy, Johnsonsuisse - Gemelli - Chrome
495841
1344304 | Material: <Unnamed>, Johnsonsuisse - Gemelli - 261 White glossy, Johnsonsuisse - Gemelli - Chrome

# IfcBuildingElementProxy: Laminaras be ištraukimo:Laminaras be ištraukimo (didelis), Laminaras be ištraukimo:Laminaras be ištraukimo (didelis):1343617
In: 5 aukštas
Type - Material: <Unnamed> (2), Aluminum (4), Default (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Laminaras be ištraukimo (didelis); sets with these values: 2

# IfcBuildingElementProxy: Laminaras:Laminaras su ištraukimu (didelis) (6)
In: 5 aukštas
Type - Material: <Unnamed> (2), Aluminum (5), Default (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Laminaras su ištraukimu (didelis); sets with these values: 2
Name (Laminaras:Laminaras su ištraukimu (didelis):...) | Material
1097504
1180209
1180287 | <Unnamed>, Aluminum, Default
1214624 | <Unnamed>, Aluminum, Default
1214625 | <Unnamed>, Aluminum, Default
1232714 | <Unnamed>, Aluminum, Default

# IfcBuildingElementProxy: Laminaras:Laminaras su ištraukimu (mažas) (3)
In: 5 aukštas
Type - Material: <Unnamed> (2), Aluminum (5), Default (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Laminaras su ištraukimu (mažas); sets with these values: 2
Name (Laminaras:Laminaras su ištraukimu (mažas):...)
1154101
1214800
1232713 | Material: <Unnamed>, Aluminum, Default

# IfcBuildingElementProxy: Ledo gaminimo aparatas:Ledo gaminimo aparatas, Ledo gaminimo aparatas:Ledo gaminimo aparatas:1197622
In: 5 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Ledo gaminimo aparatas; sets with these values: 2

# IfcBuildingElementProxy: Ligoninės lova:Hill-Rom_Patient_Bed_4479 (117)
Type - Material: Bed Bumpers (12), Bed Pin (5), Bed Wheels (4), Bed Frame (34), colchon de cama
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Hill-Rom_Patient_Bed_4479; sets with these values: 2
Name (Ligoninės lova:Hill-Rom_Patient_Bed_4479:...) | In | Material
376847 | 3 aukštas
433957 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
434009 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
434019 | 3 aukštas
434392 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435610 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435637 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435678 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435683 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435688 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435693 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435698 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435703 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435708 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435713 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435718 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435723 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435728 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435733 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435738 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435743 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435748 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435753 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435758 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435763 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435970 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
435975 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
437107 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
437119 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
437133 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
437162 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
438578 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439001 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439223 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439235 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439249 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439491 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439505 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439519 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439531 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439694 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439704 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439720 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439732 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439744 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439754 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439778 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439780 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439782 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439784 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439786 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439788 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439807 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439809 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439811 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439888 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439890 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439892 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
439894 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440060 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440062 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440064 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440066 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440144 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440149 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440174 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440175 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440193 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440194 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440219 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440238 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440266 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440267 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440279 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440280 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440292 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440293 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440349 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440360 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440402 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440421 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440438 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440447 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440468 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440479 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440498 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440716 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440747 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440809 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
440820 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
638443 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
652548 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
758012 | 4 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772023 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772052 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772058 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772153 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772460 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772801 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772802 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772803 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772840 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772841 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772842 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772904 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772905 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
772906 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
773929 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
774005 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
774015 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
774078 | 3 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
776685 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
776686 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
777632 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
816759 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
858968 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama
902056 | 2 aukštas | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame, colchon de cama

# IfcBuildingElementProxy: Ligoninės lovos rėmas:Hill-Rom_Patient_Bed_4479 (7)
In: Rūsys
Type - Material: Bed Bumpers (12), Bed Pin (5), Bed Wheels (4), Bed Frame (33)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Hill-Rom_Patient_Bed_4479; sets with these values: 2
Name (Ligoninės lovos rėmas:Hill-Rom_Patient_Bed_4479:...) | Material
720718
722353 | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame
722361 | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame
795494 | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame
795502 | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame
795510 | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame
795518 | Bed Bumpers, Bed Pin, Bed Wheels, Bed Frame

# IfcBuildingElementProxy: Lovelis:Lovelis (20)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Lovelis; sets with these values: 2
Pset_ProvisionForVoid - Depth: 100 mm
Name (Lovelis:Lovelis:...) | In | Width (mm) | Height (mm)
553092 | 3 aukštas | 50 | 3250
557372 | 3 aukštas | 50 | 2630
557448 | 3 aukštas | 50 | 2470
557512 | 3 aukštas | 50 | 3755.43
557616 | 3 aukštas | 50 | 4050
560407 | 3 aukštas | 50 | 3790.08
562558 | 3 aukštas | 50 | 1744.62
562656 | 3 aukštas | 50 | 5271.53
562726 | 3 aukštas | 50 | 1500.48
566197 | 3 aukštas | 50 | 2500
566693 | 3 aukštas | 50 | 1600
609793 | 3 aukštas | 50 | 3020
626258 | 3 aukštas | 3020 | 50
626289 | 3 aukštas | 50 | 3020
626311 | 3 aukštas | 3020 | 50
626415 | 3 aukštas | 3020 | 50
758309 | 4 aukštas | 50 | 2304.62
758322 | 4 aukštas | 50 | 2311.83
758348 | 4 aukštas | 2323.11 | 50
758452 | 4 aukštas | 2323.11 | 50

# IfcBuildingElementProxy: Maceratorius:Maceratorius (9)
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Maceratorius; sets with these values: 2
Pset_ProvisionForVoid - Width: 500 mm; Height: 623 mm; Depth: 1040 mm
Name (Maceratorius:Maceratorius:...) | In | Material
656075 | 2 aukštas
726715 | 2 aukštas | <Unnamed>
805876 | 2 aukštas | <Unnamed>
806908 | 4 aukštas | <Unnamed>
808008 | 4 aukštas | <Unnamed>
808169 | 4 aukštas | <Unnamed>
808807 | 3 aukštas | <Unnamed>
808980 | 3 aukštas | <Unnamed>
891158 | 3 aukštas | <Unnamed>

# IfcBuildingElementProxy: Masių spektometras:Masių spekometras, Masių spektometras:Masių spekometras:1235803
In: 5 aukštas
Type - Material: Default(grey)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Masių spekometras; sets with these values: 2

# IfcBuildingElementProxy: Mikrobange reguliuojama:Mikrobange reguliuojama (7)
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Mikrobange reguliuojama; sets with these values: 2
Pset_ProvisionForVoid - Depth: 270 mm
Name (Mikrobange reguliuojama:Mikrobange reguliuojama:...) | In | Width (mm) | Height (mm) | Material
564553 | 3 aukštas | 380 | 500
564892 | 3 aukštas | 500 | 380
564996 | 3 aukštas | 500 | 380 | <Unnamed>
732600 | Level 1 | 500 | 380 | <Unnamed>
733023 | Level 1 | 500 | 380 | <Unnamed>
792684 | Rūsys | 380 | 500 | <Unnamed>
866269 | 2 aukštas | 500 | 380 | <Unnamed>

# IfcBuildingElementProxy: Mikrobange reguliuojama:Mikrobange reguliuojama (LAB), Mikrobange reguliuojama:Mikrobange reguliuojama (LAB):1085189
In: 5 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Mikrobange reguliuojama (LAB); sets with these values: 2
Pset_ProvisionForVoid - Width: 500 mm; Height: 380 mm; Depth: 270 mm

# IfcBuildingElementProxy: Model Text:600mm Arial (104)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 150 mm
Name (Model Text:600mm Arial:...) | In | Width (mm) | Height (mm)
761047 | Level 1 | 97.1676 | 510.13
761064 | Level 1 | 97.1676 | 510.13
761168 | 2 aukštas | 97.1676 | 510.13
767010 | 2 aukštas | 97.1676 | 510.13
767018 | 2 aukštas | 97.1676 | 510.13
767026 | 2 aukštas | 97.1676 | 510.13
767034 | 2 aukštas | 97.1676 | 510.13
767042 | 2 aukštas | 97.1676 | 510.13
767052 | 2 aukštas | 97.1676 | 510.13
767060 | 2 aukštas | 97.1676 | 510.13
767070 | 2 aukštas | 97.1676 | 510.13
767082 | 2 aukštas | 97.1676 | 510.13
767096 | 2 aukštas | 97.1676 | 510.13
