Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcFurnishingElement: Stelažas reguliojamas:STLŽ-90/60 (413)
Name (Stelažas reguliojamas:STLŽ-90/60:...) | In | Material | Group
495895 | 5 aukštas | <Unnamed>
548027 | Level 1 | <Unnamed> | Model Group:Array Group 13:548178
548042 | Level 1 | <Unnamed> | Model Group:Array Group 12:548107
548110 | Level 1 | <Unnamed> | Model Group:Array Group 12:548111
548131 | Level 1 | <Unnamed> | Model Group:Array Group 12:548132
548137 | Level 1 | <Unnamed> | Model Group:Array Group 12:548138
548140 | Level 1 | <Unnamed> | Model Group:Array Group 12:548141
548143 | Level 1 | <Unnamed> | Model Group:Array Group 12:548144
548146 | Level 1 | <Unnamed> | Model Group:Array Group 12:548147
548149 | Level 1 | <Unnamed> | Model Group:Array Group 12:548150
548152 | Level 1 | <Unnamed> | Model Group:Array Group 12:548153
548155 | Level 1 | <Unnamed> | Model Group:Array Group 12:548156
548158 | Level 1 | <Unnamed> | Model Group:Array Group 12:548159
548161 | Level 1 | <Unnamed> | Model Group:Array Group 12:548162
548164 | Level 1 | <Unnamed> | Model Group:Array Group 12:548165
548170 | Level 1 | <Unnamed> | Model Group:Array Group 12:548171
548173 | Level 1 | <Unnamed> | Model Group:Array Group 12:548174
548176 | Level 1 | <Unnamed> | Model Group:Array Group 12:548177
548181 | Level 1 | <Unnamed> | Model Group:Array Group 13:548182
548201 | Level 1 | <Unnamed> | Model Group:Array Group 13:548202
548261 | Level 1 | <Unnamed> | Model Group:Array Group 13:548262
548263 | Level 1 | <Unnamed> | Model Group:Array Group 13:548264
548269 | Level 1 | <Unnamed> | Model Group:Array Group 13:548270
548271 | Level 1 | <Unnamed> | Model Group:Array Group 13:548272
548273 | Level 1 | <Unnamed> | Model Group:Array Group 13:548274
548309 | Level 1 | <Unnamed> | Model Group:Array Group 13:548311
548312 | Level 1 | <Unnamed> | Model Group:Array Group 13:548313
548318 | Level 1 | <Unnamed> | Model Group:Array Group 13:548319
548320 | Level 1 | <Unnamed> | Model Group:Array Group 13:548321
548322 | Level 1 | <Unnamed> | Model Group:Array Group 13:548323
548326 | Level 1 | <Unnamed> | Model Group:Array Group 13:548327
548328 | Level 1 | <Unnamed> | Model Group:Array Group 13:548329
548334 | Level 1 | <Unnamed> | Model Group:Array Group 13:548335
548336 | Level 1 | <Unnamed> | Model Group:Array Group 13:548337
548338 | Level 1 | <Unnamed> | Model Group:Array Group 13:548339
548358 | Level 1 | <Unnamed> | Model Group:Array Group 13:548360
548361 | Level 1 | <Unnamed> | Model Group:Array Group 13:548362
548367 | Level 1 | <Unnamed> | Model Group:Array Group 13:548368
548369 | Level 1 | <Unnamed> | Model Group:Array Group 13:548370
548371 | Level 1 | <Unnamed> | Model Group:Array Group 13:548372
548375 | Level 1 | <Unnamed> | Model Group:Array Group 13:548376
548377 | Level 1 | <Unnamed> | Model Group:Array Group 13:548378
548383 | Level 1 | <Unnamed> | Model Group:Array Group 13:548384
548385 | Level 1 | <Unnamed> | Model Group:Array Group 13:548386
548387 | Level 1 | <Unnamed> | Model Group:Array Group 13:548388
548401 | Level 1 | <Unnamed> | Model Group:Array Group 13:548403
548404 | Level 1 | <Unnamed> | Model Group:Array Group 13:548405
548410 | Level 1 | <Unnamed> | Model Group:Array Group 13:548411
548412 | Level 1 | <Unnamed> | Model Group:Array Group 13:548413
548414 | Level 1 | <Unnamed> | Model Group:Array Group 13:548415
548418 | Level 1 | <Unnamed> | Model Group:Array Group 13:548419
548420 | Level 1 | <Unnamed> | Model Group:Array Group 13:548421
548426 | Level 1 | <Unnamed> | Model Group:Array Group 13:548427
548428 | Level 1 | <Unnamed> | Model Group:Array Group 13:548429
548430 | Level 1 | <Unnamed> | Model Group:Array Group 13:548431
548448 | Level 1 | <Unnamed> | Model Group:Array Group 13:548450
548451 | Level 1 | <Unnamed> | Model Group:Array Group 13:548452
548457 | Level 1 | <Unnamed> | Model Group:Array Group 13:548458
548459 | Level 1 | <Unnamed> | Model Group:Array Group 13:548460
548461 | Level 1 | <Unnamed> | Model Group:Array Group 13:548462
548465 | Level 1 | <Unnamed> | Model Group:Array Group 13:548466
548467 | Level 1 | <Unnamed> | Model Group:Array Group 13:548468
548473 | Level 1 | <Unnamed> | Model Group:Array Group 13:548474
548475 | Level 1 | <Unnamed> | Model Group:Array Group 13:548476
548477 | Level 1 | <Unnamed> | Model Group:Array Group 13:548478
548493 | Level 1 | <Unnamed> | Model Group:Array Group 13:548495
548496 | Level 1 | <Unnamed> | Model Group:Array Group 13:548497
548502 | Level 1 | <Unnamed> | Model Group:Array Group 13:548503
548504 | Level 1 | <Unnamed> | Model Group:Array Group 13:548505
548506 | Level 1 | <Unnamed> | Model Group:Array Group 13:548507
548510 | Level 1 | <Unnamed> | Model Group:Array Group 13:548511
548512 | Level 1 | <Unnamed> | Model Group:Array Group 13:548513
548518 | Level 1 | <Unnamed> | Model Group:Array Group 13:548519
548520 | Level 1 | <Unnamed> | Model Group:Array Group 13:548521
548522 | Level 1 | <Unnamed> | Model Group:Array Group 13:548523
548536 | Level 1 | <Unnamed> | Model Group:Array Group 13:548538
548539 | Level 1 | <Unnamed> | Model Group:Array Group 13:548540
548545 | Level 1 | <Unnamed> | Model Group:Array Group 13:548546
548547 | Level 1 | <Unnamed> | Model Group:Array Group 13:548548
548549 | Level 1 | <Unnamed> | Model Group:Array Group 13:548550
548553 | Level 1 | <Unnamed> | Model Group:Array Group 13:548554
548555 | Level 1 | <Unnamed> | Model Group:Array Group 13:548556
548561 | Level 1 | <Unnamed> | Model Group:Array Group 13:548562
548563 | Level 1 | <Unnamed> | Model Group:Array Group 13:548564
548565 | Level 1 | <Unnamed> | Model Group:Array Group 13:548566
548577 | Level 1 | <Unnamed> | Model Group:Array Group 13:548579
548580 | Level 1 | <Unnamed> | Model Group:Array Group 13:548581
548586 | Level 1 | <Unnamed> | Model Group:Array Group 13:548587
548588 | Level 1 | <Unnamed> | Model Group:Array Group 13:548589
548590 | Level 1 | <Unnamed> | Model Group:Array Group 13:548591
548596 | Level 1 | <Unnamed> | Model Group:Array Group 13:548597
548602 | Level 1 | <Unnamed> | Model Group:Array Group 13:548603
548604 | Level 1 | <Unnamed> | Model Group:Array Group 13:548605
548606 | Level 1 | <Unnamed>
548632 | Level 1 | <Unnamed>
548635 | Level 1 | <Unnamed>
548638 | Level 1 | <Unnamed>
553619 | Rūsys | <Unnamed>
553620 | Rūsys | <Unnamed> | Model Group:Array Group 25:553621
553622 | Rūsys | <Unnamed> | Model Group:Array Group 25:553623
553624 | Rūsys | <Unnamed> | Model Group:Array Group 25:553625
553626 | Rūsys | <Unnamed> | Model Group:Array Group 25:553627
553628 | Rūsys | <Unnamed> | Model Group:Array Group 25:553629
553630 | Rūsys | <Unnamed> | Model Group:Array Group 25:553631
553632 | Rūsys | <Unnamed> | Model Group:Array Group 25:553633
553634 | Rūsys | <Unnamed> | Model Group:Array Group 25:553635
553636 | Rūsys | <Unnamed>
553637 | Rūsys | <Unnamed> | Model Group:Array Group 25:553638
554983 | 3 aukštas | <Unnamed>
554986 | 3 aukštas | <Unnamed>
555157 | 3 aukštas | <Unnamed>
555158 | 3 aukštas | <Unnamed>
555159 | 3 aukštas | <Unnamed>
557143 | Rūsys | <Unnamed>
557146 | Rūsys | <Unnamed>
557149 | Rūsys | <Unnamed>
557152 | Rūsys | <Unnamed>
557155 | Rūsys | <Unnamed>
562879 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:562880
565585 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:565586
566151 | 3 aukštas | <Unnamed>
569084 | 3 aukštas | <Unnamed>
569225 | 3 aukštas | <Unnamed>
571093 | 3 aukštas | <Unnamed>
571421 | 3 aukštas | <Unnamed>
634447 | 3 aukštas | <Unnamed>
634664 | 3 aukštas | <Unnamed>
634667 | 3 aukštas | <Unnamed>
634670 | 3 aukštas | <Unnamed>
727816 | 2 aukštas | <Unnamed>
728188 | 2 aukštas | <Unnamed>
728198 | 2 aukštas | <Unnamed>
734269 | Level 1 | <Unnamed> | Model Group:Array Group 13:734270
734283 | Level 1 | <Unnamed> | Model Group:Array Group 13:734284
734286 | Level 1 | <Unnamed> | Model Group:Array Group 13:734287
734289 | Level 1 | <Unnamed> | Model Group:Array Group 13:734290
734292 | Level 1 | <Unnamed> | Model Group:Array Group 13:734293
734295 | Level 1 | <Unnamed> | Model Group:Array Group 13:734296
734298 | Level 1 | <Unnamed> | Model Group:Array Group 13:734299
734341 | Level 1 | <Unnamed> | Model Group:Array Group 13:734342
734343 | Level 1 | <Unnamed> | Model Group:Array Group 13:734344
734345 | Level 1 | <Unnamed> | Model Group:Array Group 13:734346
734347 | Level 1 | <Unnamed> | Model Group:Array Group 13:734348
734349 | Level 1 | <Unnamed> | Model Group:Array Group 13:734350
734351 | Level 1 | <Unnamed> | Model Group:Array Group 13:734352
734353 | Level 1 | <Unnamed> | Model Group:Array Group 13:734354
734384 | Level 1 | <Unnamed> | Model Group:Array Group 13:734385
734386 | Level 1 | <Unnamed> | Model Group:Array Group 13:734387
734388 | Level 1 | <Unnamed> | Model Group:Array Group 13:734389
734390 | Level 1 | <Unnamed> | Model Group:Array Group 13:734391
734392 | Level 1 | <Unnamed> | Model Group:Array Group 13:734393
734394 | Level 1 | <Unnamed> | Model Group:Array Group 13:734395
734396 | Level 1 | <Unnamed> | Model Group:Array Group 13:734397
734413 | Level 1 | <Unnamed> | Model Group:Array Group 13:734414
734415 | Level 1 | <Unnamed> | Model Group:Array Group 13:734416
734417 | Level 1 | <Unnamed> | Model Group:Array Group 13:734418
734419 | Level 1 | <Unnamed> | Model Group:Array Group 13:734420
734421 | Level 1 | <Unnamed> | Model Group:Array Group 13:734422
734423 | Level 1 | <Unnamed> | Model Group:Array Group 13:734424
734425 | Level 1 | <Unnamed> | Model Group:Array Group 13:734426
734461 | Level 1 | <Unnamed> | Model Group:Array Group 13:734462
734463 | Level 1 | <Unnamed> | Model Group:Array Group 13:734464
734465 | Level 1 | <Unnamed> | Model Group:Array Group 13:734466
734467 | Level 1 | <Unnamed> | Model Group:Array Group 13:734468
734469 | Level 1 | <Unnamed> | Model Group:Array Group 13:734470
734471 | Level 1 | <Unnamed> | Model Group:Array Group 13:734472
734473 | Level 1 | <Unnamed> | Model Group:Array Group 13:734474
734486 | Level 1 | <Unnamed>
734488 | Level 1 | <Unnamed> | Model Group:Array Group 13:734489
734490 | Level 1 | <Unnamed> | Model Group:Array Group 13:734491
734492 | Level 1 | <Unnamed> | Model Group:Array Group 13:734493
734494 | Level 1 | <Unnamed> | Model Group:Array Group 13:734495
734496 | Level 1 | <Unnamed> | Model Group:Array Group 13:734497
734568 | Level 1 | <Unnamed>
734571 | Level 1 | <Unnamed>
734574 | Level 1 | <Unnamed>
734577 | Level 1 | <Unnamed>
734580 | Level 1 | <Unnamed>
734745 | Level 1 |  | Model Group:Array Group 13:734746
734747 | Level 1 | <Unnamed> | Model Group:Array Group 13:734748
734749 | Level 1 | <Unnamed> | Model Group:Array Group 13:734750
734751 | Level 1 | <Unnamed> | Model Group:Array Group 13:734752
734753 | Level 1 | <Unnamed> | Model Group:Array Group 13:734754
734755 | Level 1 | <Unnamed> | Model Group:Array Group 13:734756
734757 | Level 1 | <Unnamed> | Model Group:Array Group 13:734758
734759 | Level 1 | <Unnamed> | Model Group:Array Group 13:734760
734761 | Level 1 | <Unnamed> | Model Group:Array Group 13:734762
734763 | Level 1 | <Unnamed> | Model Group:Array Group 13:734764
734765 | Level 1 | <Unnamed> | Model Group:Array Group 13:734766
734767 | Level 1 | <Unnamed> | Model Group:Array Group 13:734768
734769 | Level 1 | <Unnamed> | Model Group:Array Group 13:734770
734771 | Level 1 | <Unnamed> | Model Group:Array Group 13:734772
734773 | Level 1 | <Unnamed> | Model Group:Array Group 13:734774
734775 | Level 1 | <Unnamed> | Model Group:Array Group 13:734776
734777 | Level 1 | <Unnamed> | Model Group:Array Group 13:734778
734779 | Level 1 | <Unnamed> | Model Group:Array Group 13:734780
734781 | Level 1 | <Unnamed> | Model Group:Array Group 13:734782
734783 | Level 1 | <Unnamed> | Model Group:Array Group 13:734784
734785 | Level 1 | <Unnamed> | Model Group:Array Group 13:734786
734787 | Level 1 | <Unnamed> | Model Group:Array Group 13:734788
734789 | Level 1 | <Unnamed> | Model Group:Array Group 13:734790
734791 | Level 1 | <Unnamed> | Model Group:Array Group 13:734792
734793 | Level 1 | <Unnamed> | Model Group:Array Group 13:734794
734795 | Level 1 | <Unnamed> | Model Group:Array Group 13:734796
734797 | Level 1 | <Unnamed> | Model Group:Array Group 13:734798
734799 | Level 1 | <Unnamed> | Model Group:Array Group 13:734800
734801 | Level 1 | <Unnamed> | Model Group:Array Group 13:734802
734803 | Level 1 | <Unnamed> | Model Group:Array Group 13:734804
734805 | Level 1 | <Unnamed> | Model Group:Array Group 13:734806
734807 | Level 1 | <Unnamed> | Model Group:Array Group 13:734808
734809 | Level 1 | <Unnamed> | Model Group:Array Group 13:734810
734811 | Level 1 | <Unnamed> | Model Group:Array Group 13:734812
734813 | Level 1 | <Unnamed> | Model Group:Array Group 13:734814
734815 | Level 1 | <Unnamed> | Model Group:Array Group 13:734816
734817 | Level 1 | <Unnamed>
734818 | Level 1 | <Unnamed> | Model Group:Array Group 13:734819
734820 | Level 1 | <Unnamed> | Model Group:Array Group 13:734821
734822 | Level 1 | <Unnamed> | Model Group:Array Group 13:734823
734824 | Level 1 | <Unnamed> | Model Group:Array Group 13:734825
734826 | Level 1 | <Unnamed> | Model Group:Array Group 13:734827
734830 | Level 1 | <Unnamed>
734831 | Level 1 | <Unnamed>
734832 | Level 1 | <Unnamed>
734833 | Level 1 | <Unnamed>
734834 | Level 1 | <Unnamed>
745389 | Level 1 | <Unnamed>
745466 | Level 1 | <Unnamed>
745671 | Level 1 | <Unnamed>
745683 | Level 1 | <Unnamed>
745699 | Level 1 | <Unnamed>
745749 | Level 1 | <Unnamed>
745750 | Level 1 | <Unnamed>
758635 | 4 aukštas | <Unnamed>
758638 | 4 aukštas | <Unnamed>
758641 | 4 aukštas | <Unnamed>
758644 | 4 aukštas | <Unnamed>
758647 | 4 aukštas | <Unnamed>
758650 | 4 aukštas | <Unnamed>
758743 | 4 aukštas | <Unnamed>
758746 | 4 aukštas | <Unnamed>
758749 | 4 aukštas | <Unnamed>
758752 | 4 aukštas | <Unnamed>
758758 | 4 aukštas | <Unnamed>
759229 | 4 aukštas | <Unnamed>
759232 | 4 aukštas | <Unnamed>
759235 | 4 aukštas | <Unnamed>
759238 | 4 aukštas | <Unnamed>
759264 | 4 aukštas | <Unnamed> | Model Group:Array Group 17:759265
759282 | 4 aukštas | <Unnamed> | Model Group:Array Group 17:759283
759285 | 4 aukštas | <Unnamed> | Model Group:Array Group 17:759286
759288 | 4 aukštas | <Unnamed>
759291 | 4 aukštas | <Unnamed>
759318 | 4 aukštas | <Unnamed> | Model Group:Array Group 17:759319
759320 | 4 aukštas | <Unnamed> | Model Group:Array Group 17:759321
759322 | 4 aukštas | <Unnamed> | Model Group:Array Group 17:759323
759343 | 4 aukštas | <Unnamed>
759361 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759383
759386 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759387
759408 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759409
759411 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759412
759414 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759415
759417 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759418
759420 | 4 aukštas | <Unnamed> | Model Group:Array Group 27:759421
759435 | 4 aukštas | <Unnamed>
759437 | 4 aukštas | <Unnamed>
759439 | 4 aukštas | <Unnamed>
759441 | 4 aukštas | <Unnamed>
759481 | 4 aukštas | <Unnamed>
759482 | 4 aukštas | <Unnamed>
759493 | 4 aukštas | <Unnamed>
759494 | 4 aukštas | <Unnamed>
759495 | 4 aukštas | <Unnamed>
759496 | 4 aukštas | <Unnamed>
759497 | 4 aukštas | <Unnamed>
772489 | 3 aukštas | <Unnamed>
772497 | 3 aukštas | <Unnamed>
782802 | 2 aukštas | <Unnamed>
782812 | 2 aukštas | <Unnamed>
793030 | Rūsys | <Unnamed> | Model Group:Array Group 28:793581
793584 | Rūsys | <Unnamed> | Model Group:Array Group 28:793585
793658 | Rūsys | <Unnamed> | Model Group:Array Group 28:793659
793661 | Rūsys | <Unnamed> | Model Group:Array Group 28:793662
793664 | Rūsys | <Unnamed> | Model Group:Array Group 28:793665
806360 | 2 aukštas | <Unnamed>
806363 | 2 aukštas | <Unnamed>
808636 | 4 aukštas | <Unnamed>
808717 | 4 aukštas | <Unnamed>
808720 | 4 aukštas | <Unnamed>
858220 | 2 aukštas | <Unnamed>
858275 | 2 aukštas | <Unnamed>
858284 | 2 aukštas | <Unnamed>
858287 | 2 aukštas | <Unnamed>
873114 | 2 aukštas | <Unnamed>
873287 | 2 aukštas | <Unnamed>
873290 | 2 aukštas | <Unnamed>
873293 | 2 aukštas | <Unnamed>
890933 | 3 aukštas | <Unnamed>
890934 | 3 aukštas | <Unnamed>
890935 | 3 aukštas | <Unnamed>
890945 | 3 aukštas | <Unnamed>
890946 | 3 aukštas | <Unnamed>
890947 | 3 aukštas | <Unnamed>
890956 | 3 aukštas | <Unnamed>
890957 | 3 aukštas | <Unnamed>
890974 | 3 aukštas | <Unnamed>
890977 | 3 aukštas | <Unnamed>
890980 | 3 aukštas | <Unnamed>
1073606 | 3 aukštas | <Unnamed>
1095501 | 5 aukštas | <Unnamed>
1095504 | 5 aukštas | <Unnamed>
1095507 | 5 aukštas | <Unnamed>
1095513 | 5 aukštas | <Unnamed>
1095516 | 5 aukštas | <Unnamed>
1098635 | 5 aukštas | <Unnamed>
1098752 | 5 aukštas | <Unnamed>
1100805 | 5 aukštas | <Unnamed>
1100806 | 5 aukštas | <Unnamed>
1100807 | 5 aukštas | <Unnamed>

# IfcFurnishingElement: Table Editable:NP/ST_120x70 V, Table Editable:NP/ST_120x70 V:692450
In: Level 1
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: NP/ST_120x70 V

# IfcFurnishingElement: Table Editable:NP/ST_200x70, Table Editable:NP/ST_200x70:795947
In: Rūsys
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: NP/ST_200x70

# IfcFurnishingElement: Table Editable:NP/ST_90x70, Table Editable:NP/ST_90x70:688291
In: Level 1
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: NP/ST_90x70

# IfcFurnishingElement: laboratorinė kėdė:laboratorinė kėdė (15)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: laboratorinė kėdė
Name (laboratorinė kėdė:laboratorinė kėdė:...) | In
495793 | 5 aukštas
495796 | 5 aukštas
495799 | 5 aukštas
495805 | 5 aukštas
495808 | 5 aukštas
495829 | 5 aukštas
600004 | 2 aukštas
859039 | 2 aukštas
1107272 | 5 aukštas
1107273 | 5 aukštas
1107274 | 5 aukštas
1107522 | 5 aukštas
1107523 | 5 aukštas
1107524 | 5 aukštas
1155428 | 5 aukštas

# IfcGroup: Model Group:Array Group 13 (157)
Name (Model Group:Array Group 13:...)
548178
548182
548202
548262 | Group: Model Group:Array Group 14:548275
548264 | Group: Model Group:Array Group 14:548275
548270 | Group: Model Group:Array Group 14:548275
548272 | Group: Model Group:Array Group 14:548275
548274 | Group: Model Group:Array Group 14:548275
548311 | Group: Model Group:Array Group 14:548324
548313 | Group: Model Group:Array Group 14:548324
548319 | Group: Model Group:Array Group 14:548324
548321 | Group: Model Group:Array Group 14:548324
548323 | Group: Model Group:Array Group 14:548324
548327 | Group: Model Group:Array Group 14:548340
548329 | Group: Model Group:Array Group 14:548340
548335 | Group: Model Group:Array Group 14:548340
548337 | Group: Model Group:Array Group 14:548340
548339 | Group: Model Group:Array Group 14:548340
548360 | Group: Model Group:Array Group 14:548373
548362 | Group: Model Group:Array Group 14:548373
548368 | Group: Model Group:Array Group 14:548373
548370 | Group: Model Group:Array Group 14:548373
548372 | Group: Model Group:Array Group 14:548373
548376 | Group: Model Group:Array Group 14:548389
548378 | Group: Model Group:Array Group 14:548389
548384 | Group: Model Group:Array Group 14:548389
548386 | Group: Model Group:Array Group 14:548389
548388 | Group: Model Group:Array Group 14:548389
548403 | Group: Model Group:Array Group 14:548416
548405 | Group: Model Group:Array Group 14:548416
548411 | Group: Model Group:Array Group 14:548416
548413 | Group: Model Group:Array Group 14:548416
548415 | Group: Model Group:Array Group 14:548416
548419 | Group: Model Group:Array Group 14:548432
548421 | Group: Model Group:Array Group 14:548432
548427 | Group: Model Group:Array Group 14:548432
548429 | Group: Model Group:Array Group 14:548432
548431 | Group: Model Group:Array Group 14:548432
548450 | Group: Model Group:Array Group 14:548463
548452 | Group: Model Group:Array Group 14:548463
548458 | Group: Model Group:Array Group 14:548463
548460 | Group: Model Group:Array Group 14:548463
548462 | Group: Model Group:Array Group 14:548463
548466 | Group: Model Group:Array Group 14:548479
548468 | Group: Model Group:Array Group 14:548479
548474 | Group: Model Group:Array Group 14:548479
548476 | Group: Model Group:Array Group 14:548479
548478 | Group: Model Group:Array Group 14:548479
548495 | Group: Model Group:Array Group 14:548508
548497 | Group: Model Group:Array Group 14:548508
548503 | Group: Model Group:Array Group 14:548508
548505 | Group: Model Group:Array Group 14:548508
548507 | Group: Model Group:Array Group 14:548508
548511 | Group: Model Group:Array Group 14:548524
548513 | Group: Model Group:Array Group 14:548524
548519 | Group: Model Group:Array Group 14:548524
548521 | Group: Model Group:Array Group 14:548524
548523 | Group: Model Group:Array Group 14:548524
548538 | Group: Model Group:Array Group 14:548551
548540 | Group: Model Group:Array Group 14:548551
548546 | Group: Model Group:Array Group 14:548551
548548 | Group: Model Group:Array Group 14:548551
548550 | Group: Model Group:Array Group 14:548551
548554 | Group: Model Group:Array Group 14:548567
548556 | Group: Model Group:Array Group 14:548567
548562 | Group: Model Group:Array Group 14:548567
548564 | Group: Model Group:Array Group 14:548567
548566 | Group: Model Group:Array Group 14:548567
548579 | Group: Model Group:Array Group 14:548592
548581 | Group: Model Group:Array Group 14:548592
548587 | Group: Model Group:Array Group 14:548592
548589 | Group: Model Group:Array Group 14:548592
548591 | Group: Model Group:Array Group 14:548592
548597
548603
548605
734270
734284
734287
734290
734293
734296
734299
734342
734344
734346
734348
734350
734352
734354
734385
734387
734389
734391
734393
734395
734397
734414
734416
734418
734420
734422
734424
734426
734462
734464
734466
734468
734470
734472
734474
734489
734491
734493
734495
734497
734746
734748
734750
734752
734754
734756
734758
734760
734762
734764
734766
734768
734770
734772
734774
734776
734778
734780
734782
734784
734786
734788
734790
734792
734794
734796
734798
734800
734802
734804
734806
734808
734810
734812
734814
734816
734819
734821
734823
734825
734827

# IfcGroup: Model Group:Array Group 15 (28)
Name (Model Group:Array Group 15:...) | Group
549554 | Model Group:Array Group 16:733445
733351 | Model Group:Array Group 16:733445
733382 | Model Group:Array Group 16:733445
733385 | Model Group:Array Group 16:733445
733388 | Model Group:Array Group 16:733445
733391 | Model Group:Array Group 16:733445
733394 | Model Group:Array Group 16:733445
733449 | Model Group:Array Group 16:733466
733451 | Model Group:Array Group 16:733466
733457 | Model Group:Array Group 16:733466
733459 | Model Group:Array Group 16:733466
733461 | Model Group:Array Group 16:733466
733463 | Model Group:Array Group 16:733466
733465 | Model Group:Array Group 16:733466
733596 | Model Group:Array Group 16:733613
733598 | Model Group:Array Group 16:733613
733604 | Model Group:Array Group 16:733613
733606 | Model Group:Array Group 16:733613
733608 | Model Group:Array Group 16:733613
733610 | Model Group:Array Group 16:733613
733612 | Model Group:Array Group 16:733613
733616 | Model Group:Array Group 16:733633
733618 | Model Group:Array Group 16:733633
733624 | Model Group:Array Group 16:733633
733626 | Model Group:Array Group 16:733633
733628 | Model Group:Array Group 16:733633
733630 | Model Group:Array Group 16:733633
733632 | Model Group:Array Group 16:733633

# IfcGroup: Model Group:Array Group 18 (12)
Name (Model Group:Array Group 18:...) | Group
723265 | Model Group:Array Group 26:723293
723269 | Model Group:Array Group 26:723293
723289 | Model Group:Array Group 26:723293
723302 | Model Group:Array Group 26:723311
723304 | Model Group:Array Group 26:723311
723310 | Model Group:Array Group 26:723311
723348 | Model Group:Array Group 26:723357
723350 | Model Group:Array Group 26:723357
723356 | Model Group:Array Group 26:723357
723370 | Model Group:Array Group 26:723379
723372 | Model Group:Array Group 26:723379
723378 | Model Group:Array Group 26:723379

# IfcGroup: Model Group:Array Group 19 (42)
Name (Model Group:Array Group 19:...)
550307 | Group: Model Group:Array Group 20:550354
550311 | Group: Model Group:Array Group 20:550354
550326 | Group: Model Group:Array Group 20:550354
550329 | Group: Model Group:Array Group 20:550354
550332 | Group: Model Group:Array Group 20:550354
550335 | Group: Model Group:Array Group 20:550354
550338 | Group: Model Group:Array Group 20:550354
550341 | Group: Model Group:Array Group 20:550354
550344 | Group: Model Group:Array Group 20:550354
550362
550364
550370
550372
550374
550376
550378
550380
550382
550403
550405
550411
550413
550415
550417
550419
550421
550423
1079396
1079398
1079400
1079402
1079404
1079465
1079467
1079469
1079471
1079473
1079482
1079484
1079486
1079488
1079490

# IfcGroup: Model Group:Array Group 7 (140)
Name (Model Group:Array Group 7:...) | Group
435454
435458
435469
435472
435475
435478
435481
435484
435487
435490
435528
435530
435532
435534
435536
435538
435540
435542
435544
435546
436499 | Model Group:Array Group 9:436544
436501 | Model Group:Array Group 9:436544
436503 | Model Group:Array Group 9:436544
436505 | Model Group:Array Group 9:436544
436511 | Model Group:Array Group 9:436544
436513 | Model Group:Array Group 9:436544
436515 | Model Group:Array Group 9:436544
436517 | Model Group:Array Group 9:436544
436519 | Model Group:Array Group 9:436544
436521 | Model Group:Array Group 9:436544
436523 | Model Group:Array Group 9:436544
436525 | Model Group:Array Group 9:436544
436531 | Model Group:Array Group 9:436544
436533 | Model Group:Array Group 9:436544
436535 | Model Group:Array Group 9:436544
436537 | Model Group:Array Group 9:436544
436552 | Model Group:Array Group 9:436583
436554 | Model Group:Array Group 9:436583
436556 | Model Group:Array Group 9:436583
436558 | Model Group:Array Group 9:436583
436560 | Model Group:Array Group 9:436583
436562 | Model Group:Array Group 9:436583
436564 | Model Group:Array Group 9:436583
436566 | Model Group:Array Group 9:436583
436568 | Model Group:Array Group 9:436583
436570 | Model Group:Array Group 9:436583
436572 | Model Group:Array Group 9:436583
436574 | Model Group:Array Group 9:436583
436576 | Model Group:Array Group 9:436583
436578 | Model Group:Array Group 9:436583
436580 | Model Group:Array Group 9:436583
436582 | Model Group:Array Group 9:436583
436597 | Model Group:Array Group 9:436628
436599 | Model Group:Array Group 9:436628
436601 | Model Group:Array Group 9:436628
436603 | Model Group:Array Group 9:436628
436605 | Model Group:Array Group 9:436628
436607 | Model Group:Array Group 9:436628
436609 | Model Group:Array Group 9:436628
436611 | Model Group:Array Group 9:436628
436613 | Model Group:Array Group 9:436628
436615 | Model Group:Array Group 9:436628
436617 | Model Group:Array Group 9:436628
436619 | Model Group:Array Group 9:436628
436621 | Model Group:Array Group 9:436628
436623 | Model Group:Array Group 9:436628
436625 | Model Group:Array Group 9:436628
436627 | Model Group:Array Group 9:436628
436631 | Model Group:Array Group 9:436662
436633 | Model Group:Array Group 9:436662
436635 | Model Group:Array Group 9:436662
436637 | Model Group:Array Group 9:436662
436639 | Model Group:Array Group 9:436662
436641 | Model Group:Array Group 9:436662
436643 | Model Group:Array Group 9:436662
436645 | Model Group:Array Group 9:436662
436647 | Model Group:Array Group 9:436662
436649 | Model Group:Array Group 9:436662
436651 | Model Group:Array Group 9:436662
436653 | Model Group:Array Group 9:436662
436655 | Model Group:Array Group 9:436662
436657 | Model Group:Array Group 9:436662
436659 | Model Group:Array Group 9:436662
436661 | Model Group:Array Group 9:436662
436665 | Model Group:Array Group 9:436696
436667 | Model Group:Array Group 9:436696
436669 | Model Group:Array Group 9:436696
436671 | Model Group:Array Group 9:436696
436673 | Model Group:Array Group 9:436696
436675 | Model Group:Array Group 9:436696
436677 | Model Group:Array Group 9:436696
436679 | Model Group:Array Group 9:436696
436681 | Model Group:Array Group 9:436696
436683 | Model Group:Array Group 9:436696
436685 | Model Group:Array Group 9:436696
436687 | Model Group:Array Group 9:436696
436689 | Model Group:Array Group 9:436696
436691 | Model Group:Array Group 9:436696
436693 | Model Group:Array Group 9:436696
436695 | Model Group:Array Group 9:436696
436699 | Model Group:Array Group 9:436730
436701 | Model Group:Array Group 9:436730
436703 | Model Group:Array Group 9:436730
436705 | Model Group:Array Group 9:436730
436707 | Model Group:Array Group 9:436730
436709 | Model Group:Array Group 9:436730
436711 | Model Group:Array Group 9:436730
436713 | Model Group:Array Group 9:436730
436715 | Model Group:Array Group 9:436730
436717 | Model Group:Array Group 9:436730
436719 | Model Group:Array Group 9:436730
436721 | Model Group:Array Group 9:436730
436723 | Model Group:Array Group 9:436730
436725 | Model Group:Array Group 9:436730
436727 | Model Group:Array Group 9:436730
436729 | Model Group:Array Group 9:436730
436733
436735
436737
436739
436741
436743
436745
436747
436749
436751
436753
436755
436757
436759
436761
436763
1393382
1393384
1393386
1393388
1393390
1393392
1393394
1393396
