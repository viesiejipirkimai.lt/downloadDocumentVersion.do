Properties of the parts of a building model (IFC2X3), part 3 of 5

# IfcDistributionPort (1641)
Name | FlowDirection
Port_1159966 | SOURCEANDSINK
Port_1160002 | SOURCEANDSINK
Port_1160024 | SOURCEANDSINK
Port_1160028 | SOURCEANDSINK
Port_1160032 | SOURCEANDSINK
Port_1160060 | SOURCEANDSINK
Port_1160095 | SOURCEANDSINK
Port_1160122 | SOURCEANDSINK
Port_1180209 | SOURCEANDSINK
Port_1180287 | SOURCEANDSINK
4 x Port_1180405 | SOURCEANDSINK
Port_1180406 | SOURCEANDSINK
Port_1197622 | SOURCEANDSINK
2 x Port_1197622 | SINK
2 x Port_1197622 | SOURCE
Port_1197754 | SOURCEANDSINK
Port_1197762 | SOURCEANDSINK
Port_1197785 | SOURCEANDSINK
Port_1197837 | SOURCEANDSINK
Port_1197902 | SOURCEANDSINK
Port_1198060 | SOURCEANDSINK
Port_1199761 | SOURCEANDSINK
Port_1199855 | SOURCEANDSINK
Port_1199910 | SOURCEANDSINK
Port_1200106 | SOURCEANDSINK
Port_1200142 | SOURCEANDSINK
Port_1200168 | SOURCEANDSINK
Port_1200242 | SOURCEANDSINK
Port_1200246 | SOURCEANDSINK
Port_1200250 | SOURCEANDSINK
Port_1202198 | SOURCEANDSINK
Port_1202224 | SOURCEANDSINK
Port_1202234 | SOURCEANDSINK
Port_1202271 | SOURCEANDSINK
Port_1202281 | SOURCEANDSINK
Port_1202291 | SOURCEANDSINK
Port_1202491 | SOURCEANDSINK
Port_1202538 | SOURCEANDSINK
Port_1202598 | SOURCEANDSINK
Port_1209237 | SOURCEANDSINK
Port_1209238 | SOURCEANDSINK
Port_1209502 | SOURCEANDSINK
Port_1209664 | SOURCEANDSINK
Port_1209665 | SOURCEANDSINK
Port_1210517 | SOURCEANDSINK
Port_1210518 | SOURCEANDSINK
Port_1211107 | SOURCEANDSINK
Port_1211108 | SOURCEANDSINK
Port_1211521 | SOURCEANDSINK
Port_1211680 | SOURCEANDSINK
Port_1211681 | SOURCEANDSINK
Port_1211682 | SOURCEANDSINK
Port_1211684 | SOURCEANDSINK
Port_1212085 | SOURCEANDSINK
Port_1212268 | SOURCEANDSINK
Port_1212321 | SOURCEANDSINK
Port_1212453 | SOURCEANDSINK
Port_1212518 | SOURCEANDSINK
Port_1212528 | SOURCEANDSINK
Port_1213956 | SOURCEANDSINK
Port_1214007 | SOURCEANDSINK
Port_1214012 | SOURCEANDSINK
Port_1214196 | SOURCEANDSINK
Port_1214281 | SOURCEANDSINK
Port_1214289 | SOURCEANDSINK
Port_1214624 | SOURCEANDSINK
Port_1214625 | SOURCEANDSINK
Port_1214800 | SOURCEANDSINK
Port_1232572 | SOURCEANDSINK
Port_1232573 | SOURCEANDSINK
Port_1232599 | SOURCEANDSINK
Port_1232713 | SOURCEANDSINK
Port_1232714 | SOURCEANDSINK
4 x Port_1232941 | SOURCEANDSINK
Port_1232942 | SOURCEANDSINK
Port_1232968 | SOURCEANDSINK
Port_1233090 | SOURCEANDSINK
Port_1234442 | SOURCEANDSINK
Port_1235803 | SOURCEANDSINK
Port_1237190 | SOURCEANDSINK
Port_1237455 | SOURCEANDSINK
Port_1237463 | SOURCEANDSINK
Port_1256361 | SOURCEANDSINK
Port_1256717 | SOURCEANDSINK
Port_1258392 | SOURCEANDSINK
Port_1258554 | SOURCEANDSINK
Port_1258693 | SOURCEANDSINK
3 x Port_1258890 | SOURCEANDSINK
Port_1261577 | SOURCE
Port_1261706 | SOURCE
Port_1261719 | SOURCE
Port_1341558 | SOURCEANDSINK
Port_1342383 | SOURCEANDSINK
Port_1343364 | SOURCEANDSINK
Port_1343374 | SOURCEANDSINK
Port_1343416 | SOURCEANDSINK
Port_1343617 | SOURCEANDSINK
4 x Port_1343651 | SOURCEANDSINK
Port_1343652 | SOURCEANDSINK
Port_1343702 | SOURCEANDSINK
Port_1343736 | SOURCEANDSINK
3 x Port_1344304 | SOURCEANDSINK
Port_1344888 | SOURCEANDSINK
Port_1345007 | SOURCEANDSINK
Port_1345062 | SOURCEANDSINK
Port_1345316 | SOURCEANDSINK
Port_1348640 | SOURCEANDSINK
Port_1354587 | SOURCEANDSINK
Port_1357657 | SOURCEANDSINK
Port_1357700 | SOURCEANDSINK
Port_1357713 | SOURCEANDSINK
Port_1381831 | SOURCEANDSINK
Port_1381917 | SOURCEANDSINK
Port_1382148 | SOURCEANDSINK
2 x Port_1383031 | SOURCEANDSINK
Port_1393181 | SOURCEANDSINK
Port_1393270 | SOURCEANDSINK

# IfcFlowFitting: CO2:CO2 (6)
In: 5 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: CO2; sets with these values: 2
Name (CO2:CO2:...)
1261577
1261706
1261719
1357657
1357700
1357713

# IfcFlowFitting: O2:O2 (31)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: O2; sets with these values: 2
Name (O2:O2:...) | In
811513 | 2 aukštas
811922 | 2 aukštas
811947 | 2 aukštas
811975 | 2 aukštas
811992 | 2 aukštas
812009 | 2 aukštas
812026 | 2 aukštas
812087 | 2 aukštas
812096 | 2 aukštas
812109 | 2 aukštas
812118 | 2 aukštas
812131 | 2 aukštas
812144 | 2 aukštas
812155 | 2 aukštas
812164 | 2 aukštas
812173 | 2 aukštas
812182 | 2 aukštas
812279 | 2 aukštas
812290 | 2 aukštas
812301 | 2 aukštas
812312 | 2 aukštas
812339 | 2 aukštas
812352 | 2 aukštas
814169 | 2 aukštas
814178 | 2 aukštas
814271 | 4 aukštas
814317 | 4 aukštas
814451 | 4 aukštas
814641 | 4 aukštas
861462 | 2 aukštas
1158344 | 4 aukštas

# IfcFlowFitting: SO:SO (7)
In: 2 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: SO; sets with these values: 2
Name (SO:SO:...)
786987
811920
811945
811973
811990
812007
861460

# IfcFlowFitting: VAC:VAC (7)
In: 2 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: VAC; sets with these values: 2
Name (VAC:VAC:...)
811565
811924
811949
811977
811994
812011
861464

# IfcFlowTerminal: 2xLAN:2xLAN (5)
In: 4 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 2xLAN; sets with these values: 2
Name (2xLAN:2xLAN:...)
1027433
1027472
1027485
1027537
1027548

# IfcFlowTerminal: M_Sink Vanity-Square:500x400 (3)
In: 2 aukštas
Type - Material: Porcelain, Linen, Steel, Polished
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: 500x400; sets with these values: 2
Name (M_Sink Vanity-Square:500x400:...)
785832
786333
786444

# IfcFlowTerminal: M_Sink Vanity-Square:600x500 (261)
Type - Material: Porcelain, Linen, Steel, Polished
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: 600x500; sets with these values: 2
Name (M_Sink Vanity-Square:600x500:...) | In
385712 | 3 aukštas
397816 | 2 aukštas
413868 | 3 aukštas
413972 | 3 aukštas
420370 | 3 aukštas
433845 | 3 aukštas
434757 | 3 aukštas
440519 | 4 aukštas
440768 | 4 aukštas
505983 | 3 aukštas
505992 | 3 aukštas
505995 | 3 aukštas
505998 | 3 aukštas
506005 | 3 aukštas
506008 | 3 aukštas
506014 | 3 aukštas
506017 | 3 aukštas
506020 | 3 aukštas
506023 | 3 aukštas
506029 | 3 aukštas
506032 | 3 aukštas
506056 | 3 aukštas
506068 | 3 aukštas
506077 | 3 aukštas
506080 | 3 aukštas
506133 | 3 aukštas
506139 | 3 aukštas
506142 | 3 aukštas
506148 | 3 aukštas
506151 | 3 aukštas
506167 | 2 aukštas
506185 | 2 aukštas
506212 | 2 aukštas
506215 | 2 aukštas
506218 | 2 aukštas
506221 | 2 aukštas
506224 | 2 aukštas
506227 | 2 aukštas
506230 | 2 aukštas
506233 | 2 aukštas
506236 | 2 aukštas
506239 | 2 aukštas
506242 | 2 aukštas
506245 | 2 aukštas
506248 | 2 aukštas
506251 | 2 aukštas
506294 | 2 aukštas
506300 | 2 aukštas
506306 | 2 aukštas
506309 | 2 aukštas
506312 | 2 aukštas
506315 | 2 aukštas
506318 | 2 aukštas
506321 | 2 aukštas
506330 | 2 aukštas
506333 | 2 aukštas
506336 | 2 aukštas
506339 | 2 aukštas
506386 | 2 aukštas
506389 | 2 aukštas
506392 | 2 aukštas
506395 | 2 aukštas
506398 | 2 aukštas
506401 | 2 aukštas
506404 | 2 aukštas
506407 | 2 aukštas
506410 | 2 aukštas
506413 | 2 aukštas
506416 | 2 aukštas
506419 | 2 aukštas
506477 | 2 aukštas
506480 | 2 aukštas
506489 | 2 aukštas
506492 | 2 aukštas
506495 | 2 aukštas
506504 | 2 aukštas
506507 | 2 aukštas
507031 | 2 aukštas
507050 | 2 aukštas
507313 | 2 aukštas
507316 | 2 aukštas
507319 | 2 aukštas
507338 | 2 aukštas
507341 | 2 aukštas
507344 | 2 aukštas
507347 | 2 aukštas
507350 | 2 aukštas
507353 | 2 aukštas
507356 | 2 aukštas
507359 | 2 aukštas
507390 | 2 aukštas
507393 | 2 aukštas
507396 | 2 aukštas
507650 | 2 aukštas
507779 | 2 aukštas
508080 | 2 aukštas
508127 | 2 aukštas
508653 | 4 aukštas
508679 | 4 aukštas
508682 | 4 aukštas
508685 | 4 aukštas
508688 | 4 aukštas
508691 | 4 aukštas
508694 | 4 aukštas
508700 | 4 aukštas
508712 | 4 aukštas
508717 | 4 aukštas
508726 | 4 aukštas
508729 | 4 aukštas
508732 | 4 aukštas
508774 | 4 aukštas
508777 | 4 aukštas
508780 | 4 aukštas
508783 | 4 aukštas
508786 | 4 aukštas
508789 | 4 aukštas
508792 | 4 aukštas
508801 | 4 aukštas
508804 | 4 aukštas
508807 | 4 aukštas
508810 | 4 aukštas
508813 | 4 aukštas
508816 | 4 aukštas
508822 | 4 aukštas
508825 | 4 aukštas
508828 | 4 aukštas
508831 | 4 aukštas
508834 | 4 aukštas
508837 | 4 aukštas
508840 | 4 aukštas
508843 | 4 aukštas
508846 | 4 aukštas
508849 | 4 aukštas
508852 | 4 aukštas
508855 | 4 aukštas
508858 | 4 aukštas
508946 | 2 aukštas
549856 | Level 1
549859 | Level 1
549862 | Level 1
554965 | 3 aukštas
562841 | 3 aukštas
563631 | 3 aukštas
563722 | 3 aukštas
564551 | 3 aukštas
564890 | 3 aukštas
564994 | 3 aukštas
565521 | 3 aukštas
567465 | 3 aukštas
626253 | 3 aukštas
626284 | 3 aukštas
626306 | 3 aukštas
626410 | 3 aukštas
654233 | 5 aukštas
692741 | Level 1
696232 | Level 1
699729 | 2 aukštas
699735 | 2 aukštas
699738 | 2 aukštas
699741 | 2 aukštas
699744 | 2 aukštas
699747 | 2 aukštas
699768 | 4 aukštas
712499 | 2 aukštas
712505 | 2 aukštas
713037 | 3 aukštas
713254 | 3 aukštas
716077 | 2 aukštas
716179 | 2 aukštas
717124 | Rūsys
717127 | Rūsys
717145 | Rūsys
717148 | Rūsys
717151 | Rūsys
717154 | Rūsys
717157 | Rūsys
723233 | Level 1 | Group: Model Group:Array Group 18:723265
723268 | Level 1 | Group: Model Group:Array Group 18:723269
723288 | Level 1 | Group: Model Group:Array Group 18:723289
723301 | Level 1 | Group: Model Group:Array Group 18:723302
723303 | Level 1 | Group: Model Group:Array Group 18:723304
723309 | Level 1 | Group: Model Group:Array Group 18:723310
723347 | Level 1 | Group: Model Group:Array Group 18:723348
723349 | Level 1 | Group: Model Group:Array Group 18:723350
723355 | Level 1 | Group: Model Group:Array Group 18:723356
723369 | Level 1 | Group: Model Group:Array Group 18:723370
723371 | Level 1 | Group: Model Group:Array Group 18:723372
723377 | Level 1 | Group: Model Group:Array Group 18:723378
732598 | Level 1
733021 | Level 1
733665 | Level 1
734594 | Level 1
734835 | Level 1
743913 | Level 1
747128 | 4 aukštas
747131 | 4 aukštas
747134 | 4 aukštas
747137 | 4 aukštas
747140 | 4 aukštas
747143 | 4 aukštas
747146 | 4 aukštas
747557 | 4 aukštas
747747 | 4 aukštas
758776 | 4 aukštas
758994 | 4 aukštas
758997 | 4 aukštas
759000 | 4 aukštas
759003 | 4 aukštas
770923 | 2 aukštas
771095 | 2 aukštas
772095 | 3 aukštas
772204 | 3 aukštas
772275 | 3 aukštas
772332 | 3 aukštas
772423 | 3 aukštas
772585 | 3 aukštas
773065 | 3 aukštas
773194 | 3 aukštas
773349 | 3 aukštas
773928 | 3 aukštas
774004 | 3 aukštas
774014 | 3 aukštas
774119 | 3 aukštas
774210 | 3 aukštas
774220 | 3 aukštas
774236 | 3 aukštas
775007 | 4 aukštas
776687 | 2 aukštas
776688 | 2 aukštas
781201 | 2 aukštas
781209 | 2 aukštas
781386 | 2 aukštas
787475 | Level 1
787548 | Level 1
792682 | Rūsys
793029 | Rūsys
795423 | Rūsys
796045 | Rūsys
796432 | Rūsys
796630 | Rūsys
798337 | 2 aukštas
805602 | 2 aukštas
807724 | 4 aukštas
810770 | Rūsys
820667 | 4 aukštas
820942 | 4 aukštas
820943 | 4 aukštas
820944 | 4 aukštas
820952 | 4 aukštas
820953 | 4 aukštas
820954 | 4 aukštas
829866 | 2 aukštas
862472 | 2 aukštas
895543 | 4 aukštas
895546 | 4 aukštas
895599 | 4 aukštas
895600 | 4 aukštas
895610 | 4 aukštas
895611 | 4 aukštas
1074975 | 3 aukštas
1085187 | 5 aukštas

# IfcFlowTerminal: Maišytuvas:Maišytuvas (4)
In: 5 aukštas
Type - Classification: 945200-20 (Uniformat); Material: Stainless Steel AISI 304
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tramontina
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: Stainless Steel AISI 304, Nylon, molybdenum disulphide
Pset_DistributionFlowElementCommon - Reference: Maišytuvas; sets with these values: 2
Name (Maišytuvas:Maišytuvas:...)
494743
494811
495842
1344305

# IfcFlowTerminal: RJ45:1xRJ45 (3)
In: 3 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 1xRJ45; sets with these values: 2
Name (RJ45:1xRJ45:...)
568685
1073584
1076530

# IfcFlowTerminal: RJ45:2xRJ45 (249)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 2xRJ45; sets with these values: 2
Name (RJ45:2xRJ45:...) | In
565461 | 3 aukštas
609862 | 3 aukštas
609873 | 3 aukštas
626260 | 3 aukštas
626262 | 3 aukštas
626291 | 3 aukštas
626293 | 3 aukštas
626313 | 3 aukštas
626315 | 3 aukštas
626417 | 3 aukštas
626419 | 3 aukštas
628746 | 3 aukštas
628866 | 3 aukštas
628870 | 3 aukštas
631514 | 3 aukštas
631666 | 3 aukštas
651424 | 3 aukštas
758311 | 4 aukštas
865774 | 2 aukštas
869538 | 2 aukštas
948416 | 2 aukštas
954902 | 2 aukštas
955306 | 2 aukštas
959559 | 2 aukštas
977168 | 2 aukštas
977198 | 2 aukštas
977380 | 2 aukštas
977383 | 2 aukštas
979473 | 2 aukštas
979626 | 2 aukštas
1005212 | 2 aukštas
1005364 | 2 aukštas
1005524 | 2 aukštas
1005531 | 2 aukštas
1005583 | 2 aukštas
1005590 | 2 aukštas
1005663 | 2 aukštas
1005669 | 2 aukštas
1014566 | 3 aukštas
1026427 | 3 aukštas
1026483 | 3 aukštas
1026487 | 3 aukštas
1026619 | 3 aukštas
1026623 | 3 aukštas
1026627 | 3 aukštas
1026631 | 3 aukštas
1026635 | 3 aukštas
1026639 | 3 aukštas
1026791 | 3 aukštas
1026800 | 3 aukštas
1027058 | 4 aukštas
1027060 | 4 aukštas
1027062 | 4 aukštas
1027064 | 4 aukštas
1027066 | 4 aukštas
1027068 | 4 aukštas
1027070 | 4 aukštas
1027072 | 4 aukštas
1027074 | 4 aukštas
1027076 | 4 aukštas
1027082 | 4 aukštas
1027088 | 4 aukštas
1027090 | 4 aukštas
1027092 | 4 aukštas
1027096 | 4 aukštas
1027098 | 4 aukštas
1027100 | 4 aukštas
1028067 | 3 aukštas
1028671 | 4 aukštas
1043431 | Level 1
1043435 | Level 1
1044651 | 4 aukštas
1044660 | 4 aukštas
1044663 | 4 aukštas
1045589 | Level 1
1045694 | Level 1
1045704 | Level 1
1045706 | Level 1
1045736 | Level 1
1045738 | Level 1
1045748 | Level 1
1045750 | Level 1
1045813 | 4 aukštas
1045815 | 4 aukštas
1045873 | 4 aukštas
1045910 | 4 aukštas
1047891 | Level 1
1047893 | Level 1
1049075 | Level 1
1052429 | Level 1
1052436 | Level 1
1052438 | Level 1
1052440 | Level 1
1052442 | Level 1
1052499 | Level 1
1052567 | Rūsys
1052578 | Rūsys
1059084 | 2 aukštas
1059120 | 2 aukštas
1059131 | 2 aukštas
1059144 | 2 aukštas
1059163 | 2 aukštas
1059188 | 2 aukštas
1059207 | 2 aukštas
1059231 | 2 aukštas
1059244 | 2 aukštas
1059257 | 2 aukštas
1059607 | 2 aukštas
1059609 | 2 aukštas
1059611 | 2 aukštas
1059613 | 2 aukštas
1059615 | 2 aukštas
1059617 | 2 aukštas
1059619 | 2 aukštas
1059621 | 2 aukštas
1059623 | 2 aukštas
1059625 | 2 aukštas
1061572 | 2 aukštas
1061577 | 2 aukštas
1061614 | 2 aukštas
1061618 | 2 aukštas
1061641 | 2 aukštas
1061674 | 2 aukštas
1061700 | 2 aukštas
1061718 | 2 aukštas
1061720 | 2 aukštas
1062011 | 2 aukštas
1062013 | 2 aukštas
1062015 | 2 aukštas
1062017 | 2 aukštas
1062097 | 2 aukštas
1062142 | 2 aukštas
1062146 | 2 aukštas
1062148 | 2 aukštas
1062158 | 2 aukštas
1062248 | 2 aukštas
1062250 | 2 aukštas
1062279 | 2 aukštas
1062295 | 2 aukštas
1062299 | 2 aukštas
1062301 | 2 aukštas
1069918 | 2 aukštas
1071082 | 2 aukštas
1071084 | 2 aukštas
1071086 | 2 aukštas
1071089 | 2 aukštas
1071091 | 2 aukštas
1073621 | 3 aukštas
1075167 | 3 aukštas
1076221 | 3 aukštas
1079057 | 3 aukštas
1079078 | 3 aukštas
1086328 | 5 aukštas
1086330 | 5 aukštas
1086332 | 5 aukštas
1086334 | 5 aukštas
1086336 | 5 aukštas
1086338 | 5 aukštas
1086340 | 5 aukštas
1086342 | 5 aukštas
1086344 | 5 aukštas
1086346 | 5 aukštas
1086348 | 5 aukštas
1086350 | 5 aukštas
1086414 | 5 aukštas
1086449 | 5 aukštas
1086466 | 5 aukštas
1086469 | 5 aukštas
1086477 | 5 aukštas
1086480 | 5 aukštas
1096045 | 5 aukštas
1096112 | 5 aukštas
1100429 | 5 aukštas
1100442 | 5 aukštas
1100647 | 5 aukštas
1100756 | 5 aukštas
1107289 | 5 aukštas
1107321 | 5 aukštas
1107535 | 5 aukštas
1107541 | 5 aukštas
1117163 | Level 1
1154393 | 5 aukštas
1154479 | 5 aukštas
1154793 | 5 aukštas
1155045 | 5 aukštas
1155139 | 5 aukštas
1155210 | 5 aukštas
1155357 | 5 aukštas
1155741 | 5 aukštas
1155785 | 5 aukštas
1155823 | 5 aukštas
1155857 | 5 aukštas
1155948 | 5 aukštas
1155956 | 5 aukštas
1156187 | 5 aukštas
1156293 | 5 aukštas
1156382 | 5 aukštas
1156501 | 5 aukštas
1156566 | 5 aukštas
1156627 | 5 aukštas
1156759 | 5 aukštas
1158206 | 4 aukštas
1158216 | 4 aukštas
1158235 | 4 aukštas
1158242 | 4 aukštas
1158261 | 4 aukštas
1158264 | 4 aukštas
1158285 | 4 aukštas
1158288 | 4 aukštas
1158300 | 4 aukštas
1158307 | 4 aukštas
1158314 | 4 aukštas
1158321 | 4 aukštas
1159741 | 4 aukštas
1159966 | 4 aukštas
1160002 | 4 aukštas
1160024 | 4 aukštas
1160028 | 4 aukštas
1160032 | 4 aukštas
1160060 | 4 aukštas
1160095 | 4 aukštas
1160122 | 4 aukštas
1199761 | 2 aukštas
1199855 | 2 aukštas
1199910 | 2 aukštas
1200106 | 2 aukštas
1200142 | 2 aukštas
1200168 | 2 aukštas
1200242 | 2 aukštas
1200246 | 2 aukštas
1200250 | 2 aukštas
1202198 | 2 aukštas
1202224 | 2 aukštas
1202234 | 2 aukštas
1202271 | 2 aukštas
1202281 | 2 aukštas
1202291 | 2 aukštas
1202491 | 2 aukštas
1202538 | 2 aukštas
1202598 | 2 aukštas
1209238 | Rūsys
1209502 | Rūsys
1209665 | Rūsys
1210518 | Rūsys
1211108 | Rūsys
1258554 | 5 aukštas
1341558 | 2 aukštas
1345316 | 5 aukštas
1382148 | 5 aukštas

# IfcFlowTerminal: RJ45:3xRJ45 (18)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 3xRJ45; sets with these values: 2
Name (RJ45:3xRJ45:...) | In
557748 | 3 aukštas
557791 | 3 aukštas
557824 | 3 aukštas
651044 | 3 aukštas
651776 | 3 aukštas
651796 | 3 aukštas
1026179 | 3 aukštas
1026183 | 3 aukštas
1026187 | 3 aukštas
1026872 | 3 aukštas
1026876 | 3 aukštas
1044490 | 4 aukštas
1044492 | 4 aukštas
1061025 | 2 aukštas
1068973 | 2 aukštas
1070273 | 2 aukštas
1070327 | 2 aukštas
1393270 | 2 aukštas

# IfcFlowTerminal: RJ45:4xRJ45 (5)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 4xRJ45; sets with these values: 2
Name (RJ45:4xRJ45:...) | In
1045851 | 4 aukštas
1095486 | 5 aukštas
1095490 | 5 aukštas
1095494 | 5 aukštas
1154575 | 5 aukštas

# IfcFlowTerminal: Sanitary_Bidets_Sanindusa_Sanibold-back-to-wall-bidet:Viduaras (18)
Type - Material: Metalas, <Unnamed>
Type - Pset_ElementShading - Color: white
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: Sanibold; Manufacturer: Sanindusa; ProductionYear: 2017
Type - Pset_ProductRequirements - Name: Bidet_Sanibold; Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Viduaras; sets with these values: 2
Name (Sanitary_Bidets_Sanindusa_Sanibold-back-to-wall-bidet:Viduaras:...) | In
374766 | 3 aukštas
434729 | 3 aukštas
436248 | 2 aukštas
437230 | 2 aukštas
438111 | 2 aukštas
440516 | 4 aukštas
440764 | 4 aukštas
495737 | 5 aukštas
506358 | 2 aukštas
554962 | 3 aukštas
724965 | 2 aukštas
759011 | 4 aukštas
769316 | 2 aukštas
777103 | 2 aukštas
777147 | 2 aukštas
793026 | Rūsys
807526 | 4 aukštas
1103762 | 5 aukštas

# IfcFlowTerminal: Trapas:Taškinis trapas 100x100 (36)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Taškinis trapas 100x100; sets with these values: 2
Name (Trapas:Taškinis trapas 100x100:...) | In
412570 | 3 aukštas
434683 | 3 aukštas
434703 | 3 aukštas
436250 | 2 aukštas
437231 | 2 aukštas
437383 | 2 aukštas
438175 | 2 aukštas
440133 | 4 aukštas
440765 | 4 aukštas
495741 | 5 aukštas
506378 | 2 aukštas
555004 | 3 aukštas
698618 | Level 1
698687 | Level 1
716227 | Rūsys
759021 | 4 aukštas
791486 | Rūsys
791496 | Rūsys
791522 | Rūsys
791562 | Rūsys
791567 | Rūsys
793025 | Rūsys
802474 | Rūsys
802484 | Rūsys
808436 | 4 aukštas
810663 | Rūsys
810707 | Rūsys
811111 | Rūsys
811227 | Rūsys
811228 | Rūsys
811271 | 2 aukštas
811281 | 2 aukštas
811291 | 2 aukštas
811299 | 2 aukštas
1103765 | 5 aukštas
1381831 | 5 aukštas

# IfcFlowTerminal: Trapas:Trapas 100x1200 (3)
In: 2 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Trapas 100x1200; sets with these values: 2
Name (Trapas:Trapas 100x1200:...)
785713
785986
786179

# IfcFurnishingElement: Apžiūros kušetė:Apžiūros kušetė (18)
In: 2 aukštas
Type - Material: Black Leather (2), Steel - Galvenized (6)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Sidhill
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Apžiūros kušetė
Name (Apžiūros kušetė:Apžiūros kušetė:...) | Material
397805
436404 | Black Leather, Steel - Galvenized
436856 | Black Leather, Steel - Galvenized
436891
436905 | Black Leather, Steel - Galvenized
436929 | Black Leather, Steel - Galvenized
436941 | Black Leather, Steel - Galvenized
436951 | Black Leather, Steel - Galvenized
436964 | Black Leather, Steel - Galvenized
437020 | Black Leather, Steel - Galvenized
437033 | Black Leather, Steel - Galvenized
437036 | Black Leather, Steel - Galvenized
437509 | Black Leather, Steel - Galvenized
437565 | Black Leather, Steel - Galvenized
437916 | Black Leather, Steel - Galvenized
507432 | Black Leather, Steel - Galvenized
812201 | Black Leather, Steel - Galvenized
859036 | Black Leather, Steel - Galvenized

# IfcFurnishingElement: Cabinet Universal Max 2 Doors:SP 150x60 su durelėm (2)
In: 2 aukštas
Type - Material: <Unnamed> (11)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: SP 150x60 su durelėm
Name (Cabinet Universal Max 2 Doors:SP 150x60 su durelėm:...)
830571
861749

# IfcFurnishingElement: Cabinet Universal Max 2 Doors:SP_057/6, Cabinet Universal Max 2 Doors:SP_057/6:1069092
In: 2 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: SP_057/6

# IfcFurnishingElement: Cabinet Universal Max 2 Doors:SP_12/6 (36)
Type - Material: <Unnamed> (11)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: SP_12/6
Name (Cabinet Universal Max 2 Doors:SP_12/6:...) | In | Material
435252 | 2 aukštas
436370 | 2 aukštas
437442 | 2 aukštas | <Unnamed>
437445 | 2 aukštas | <Unnamed>
437449 | 2 aukštas | <Unnamed>
437455 | 2 aukštas | <Unnamed>
437949 | 2 aukštas | <Unnamed>
437968 | 2 aukštas | <Unnamed>
437978 | 2 aukštas | <Unnamed>
437990 | 2 aukštas | <Unnamed>
440853 | 4 aukštas | <Unnamed>
554584 | 3 aukštas | <Unnamed>
555114 | 3 aukštas | <Unnamed>
555117 | 3 aukštas | <Unnamed>
555120 | 3 aukštas | <Unnamed>
560688 | 4 aukštas | <Unnamed>
560691 | 4 aukštas | <Unnamed>
567913 | 3 aukštas | <Unnamed>
634171 | 3 aukštas | <Unnamed>
634300 | 3 aukštas | <Unnamed>
758101 | 4 aukštas | <Unnamed>
758104 | 4 aukštas | <Unnamed>
758107 | 4 aukštas | <Unnamed>
758567 | 4 aukštas | <Unnamed>
758629 | 4 aukštas | <Unnamed>
758863 | 4 aukštas | <Unnamed>
758978 | 4 aukštas | <Unnamed>
772571 | 3 aukštas | <Unnamed>
776532 | 4 aukštas | <Unnamed>
820532 | 4 aukštas | <Unnamed>
858539 | 2 aukštas | <Unnamed>
872229 | 2 aukštas | <Unnamed>
872230 | 2 aukštas | <Unnamed>
1062348 | 2 aukštas | <Unnamed>
1062423 | 2 aukštas | <Unnamed>
1062497 | 2 aukštas | <Unnamed>

# IfcFurnishingElement: Cabinet Universal Max 2 Doors:SP_6/6, Cabinet Universal Max 2 Doors:SP_6/6:1068717
In: 2 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: SP_6/6

# IfcFurnishingElement: Cabinet Universal Max 2 Doors:Spintelė su stalčiais 1000/600, Cabinet Universal Max 2 Doors:Spintelė su stalčiais 1000/600:566505
In: 3 aukštas
Type - Material: <Unnamed> (31)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Spintelė su stalčiais 1000/600

# IfcFurnishingElement: Cabinet Universal Max 2 Doors:Spintelė su stalčiais 1800/600, Cabinet Universal Max 2 Doors:Spintelė su stalčiais 1800/600:860917
In: 2 aukštas
Type - Material: <Unnamed> (31)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Spintelė su stalčiais 1800/600

# IfcFurnishingElement: Cadeira universitária linha 43 cód 4316.6:Cadeira linha universitária 43 cód 4316.6 (70)
Type - Material: Metálico CZNB (22), <Unnamed> (3), Laminado cor CZCL, Plástico cor VEBP (2)
Type - Pset_FurnitureTypeCommon - Description: Cadeira universitária linha 43 / Cátedra universitaria línea 43 / University Chair line 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Metadil
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Cadeira linha universitária 43 cód 4316.6
Name (Cadeira universitária linha 43 cód 4316.6:Cadeira linha universitária 43 cód 4316.6:...) | In | Group | Material
549526 | Level 1 | Model Group:Array Group 15:549554
550294 | 3 aukštas | Model Group:Array Group 19:550307 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550310 | 3 aukštas | Model Group:Array Group 19:550311 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550325 | 3 aukštas | Model Group:Array Group 19:550326 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550328 | 3 aukštas | Model Group:Array Group 19:550329 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550331 | 3 aukštas | Model Group:Array Group 19:550332 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550334 | 3 aukštas | Model Group:Array Group 19:550335 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550337 | 3 aukštas | Model Group:Array Group 19:550338 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550340 | 3 aukštas | Model Group:Array Group 19:550341 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550343 | 3 aukštas | Model Group:Array Group 19:550344 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550361 | 3 aukštas | Model Group:Array Group 19:550362 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550363 | 3 aukštas | Model Group:Array Group 19:550364 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550369 | 3 aukštas | Model Group:Array Group 19:550370 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550371 | 3 aukštas | Model Group:Array Group 19:550372 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550373 | 3 aukštas | Model Group:Array Group 19:550374 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550375 | 3 aukštas | Model Group:Array Group 19:550376 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550377 | 3 aukštas | Model Group:Array Group 19:550378 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550379 | 3 aukštas | Model Group:Array Group 19:550380 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550381 | 3 aukštas | Model Group:Array Group 19:550382 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550402 | 3 aukštas | Model Group:Array Group 19:550403 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550404 | 3 aukštas | Model Group:Array Group 19:550405 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550410 | 3 aukštas | Model Group:Array Group 19:550411 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550412 | 3 aukštas | Model Group:Array Group 19:550413 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550414 | 3 aukštas | Model Group:Array Group 19:550415 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550416 | 3 aukštas | Model Group:Array Group 19:550417 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550418 | 3 aukštas | Model Group:Array Group 19:550419 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550420 | 3 aukštas | Model Group:Array Group 19:550421 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
550422 | 3 aukštas | Model Group:Array Group 19:550423 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733350 | Level 1 | Model Group:Array Group 15:733351 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733381 | Level 1 | Model Group:Array Group 15:733382 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733384 | Level 1 | Model Group:Array Group 15:733385 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733387 | Level 1 | Model Group:Array Group 15:733388 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733390 | Level 1 | Model Group:Array Group 15:733391 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733393 | Level 1 | Model Group:Array Group 15:733394 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733448 | Level 1 | Model Group:Array Group 15:733449 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733450 | Level 1 | Model Group:Array Group 15:733451 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733456 | Level 1 | Model Group:Array Group 15:733457 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733458 | Level 1 | Model Group:Array Group 15:733459 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733460 | Level 1 | Model Group:Array Group 15:733461 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733462 | Level 1 | Model Group:Array Group 15:733463 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733464 | Level 1 | Model Group:Array Group 15:733465 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733595 | Level 1 | Model Group:Array Group 15:733596 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733597 | Level 1 | Model Group:Array Group 15:733598 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733603 | Level 1 | Model Group:Array Group 15:733604 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733605 | Level 1 | Model Group:Array Group 15:733606 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733607 | Level 1 | Model Group:Array Group 15:733608 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733609 | Level 1 | Model Group:Array Group 15:733610 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733611 | Level 1 | Model Group:Array Group 15:733612 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733615 | Level 1 | Model Group:Array Group 15:733616 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733617 | Level 1 | Model Group:Array Group 15:733618 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733623 | Level 1 | Model Group:Array Group 15:733624 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733625 | Level 1 | Model Group:Array Group 15:733626 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733627 | Level 1 | Model Group:Array Group 15:733628 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733629 | Level 1 | Model Group:Array Group 15:733630 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
733631 | Level 1 | Model Group:Array Group 15:733632 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079395 | 5 aukštas | Model Group:Array Group 19:1079396 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079397 | 5 aukštas | Model Group:Array Group 19:1079398 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079399 | 5 aukštas | Model Group:Array Group 19:1079400 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079401 | 5 aukštas | Model Group:Array Group 19:1079402 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079403 | 5 aukštas | Model Group:Array Group 19:1079404 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079464 | 5 aukštas | Model Group:Array Group 19:1079465 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079466 | 5 aukštas | Model Group:Array Group 19:1079467 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079468 | 5 aukštas | Model Group:Array Group 19:1079469 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079470 | 5 aukštas | Model Group:Array Group 19:1079471 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079472 | 5 aukštas | Model Group:Array Group 19:1079473 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079481 | 5 aukštas | Model Group:Array Group 19:1079482 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079483 | 5 aukštas | Model Group:Array Group 19:1079484 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079485 | 5 aukštas | Model Group:Array Group 19:1079486 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079487 | 5 aukštas | Model Group:Array Group 19:1079488 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP
1079489 | 5 aukštas | Model Group:Array Group 19:1079490 | Metálico CZNB, <Unnamed>, Laminado cor CZCL, Plástico cor VEBP

# IfcFurnishingElement: Chair-Task (Arms):Chair-Task (Arms) (8)
In: 4 aukštas
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Chair-Task (Arms)
Name (Chair-Task (Arms):Chair-Task (Arms):...) | Material
1046953
1046956 | Textile - Slate Blue, Plastic, Opaque Black
1046959 | Textile - Slate Blue, Plastic, Opaque Black
1046962 | Textile - Slate Blue, Plastic, Opaque Black
1046965 | Textile - Slate Blue, Plastic, Opaque Black
1046993
1046994 | Textile - Slate Blue, Plastic, Opaque Black
1046995 | Textile - Slate Blue, Plastic, Opaque Black

# IfcFurnishingElement: Computerized Table Set:1000x600 Ofiso stalas (7)
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14), Glass, <Unnamed> (12), Mattegrey (2), keys (107)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1000x600 Ofiso stalas
Name (Computerized Table Set:1000x600 Ofiso stalas:...) | In
890588 | Level 1
890593 | Level 1
890611 | Level 1 | Material: Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
895708 | 4 aukštas | Material: Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
895711 | 4 aukštas
895714 | 4 aukštas | Material: Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1079596 | 5 aukštas

# IfcFurnishingElement: Computerized Table Set:1500x600 Ofiso stalas (10)
In: 3 aukštas
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14), Glass, <Unnamed> (24), Mattegrey (2), keys (107)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1500x600 Ofiso stalas
Name (Computerized Table Set:1500x600 Ofiso stalas:...) | Material
434378
573542 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626252
626256 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626283 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626287 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626305 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626309 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626409 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
626413 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys

# IfcFurnishingElement: Computerized Table Set:1500x750 Ofiso stalas (3)
In: 5 aukštas
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14), Glass, <Unnamed> (24), Mattegrey (2), keys (107)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1500x750 Ofiso stalas
Name (Computerized Table Set:1500x750 Ofiso stalas:...) | Material
1095970
1107281 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1107529 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys

# IfcFurnishingElement: Computerized Table Set:1600x600 Ofiso stalas 2 (125)
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14), Glass, <Unnamed> (24), Mattegrey (2), keys (107)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1600x600 Ofiso stalas 2
Name (Computerized Table Set:1600x600 Ofiso stalas 2:...) | In | Material
396775 | 2 aukštas
413891 | 3 aukštas
413946 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433698 | 3 aukštas
433775 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433781 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433912 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433915 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433921 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433924 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433933 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433936 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
433939 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
435349 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
435352 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
435667 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
435670 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
435983 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436472 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436879 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436892 | 2 aukštas
436906 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436918 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436930 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436942 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436952 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436965 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
436984 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437008 | 2 aukštas
437019 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437032 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437035 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437064 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437172 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437175 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437178 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437181 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437494 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437581 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437587 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437859 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
437931 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440569 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440575 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440578 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440581 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440584 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440587 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440590 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440593 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440596 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440635 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440859 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440865 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440868 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440874 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440880 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440892 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440893 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
440894 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481270 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481273 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481276 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481279 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481282 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481285 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481288 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481291 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481294 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481297 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
481303 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
549541 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
549766 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
550250 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
550253 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
550432 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
554642 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
555434 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
564887 | 3 aukštas
564937 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731481 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731484 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731487 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731499 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731500 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731515 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
731516 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
744139 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
746885 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
746980 | Level 1 | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
747723 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
777995 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
778050 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
778660 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
778779 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
782243 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
791583 | Rūsys | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
791681 | Rūsys | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
829855 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
829856 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
859802 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
862470 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
862471 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
892018 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
893892 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1045871 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1079076 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1079362 | 5 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158204 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158214 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158233 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158240 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158259 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158262 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158283 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158286 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158298 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158305 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158312 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1158319 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1159739 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1209236 | Rūsys | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1209663 | Rūsys | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1210516 | Rūsys | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1211106 | Rūsys | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys

# IfcFurnishingElement: Computerized Table Set:1600x600 Ofiso stalas 3, Computerized Table Set:1600x600 Ofiso stalas 3:1079498
In: 5 aukštas
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14), Glass, <Unnamed> (24), Mattegrey (2), keys (107)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1600x600 Ofiso stalas 3

# IfcFurnishingElement: Corner Cabinet:600x600 (2)
In: 2 aukštas
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 600x600
Name (Corner Cabinet:600x600:...)
1068544
1068653

# IfcFurnishingElement: Darbo kėdė su loptopu:Type_1 (46)
Type - Material: Textile - Slate Blue (3), Plastic, Opaque Black (14), Glass, <Unnamed> (3), Mattegrey (2), keys (107)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Type_1
Name (Darbo kėdė su loptopu:Type_1:...) | In | Material
1003568 | 2 aukštas
1003694 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1005519 | 2 aukštas
1005521 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1005578 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1005580 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1005658 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1005660 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1014946 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1014983 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1014986 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1024779 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1024981 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1026349 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1026355 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1027672 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1027675 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1027678 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1027693 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1027701 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1044500 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1044513 | 4 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059275 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059302 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059305 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059308 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059311 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059314 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059317 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059320 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059323 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059326 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059626 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059627 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059628 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059629 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059630 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059631 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059632 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059633 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059634 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1059635 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1070348 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1070351 | 2 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1076946 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys
1086177 | 3 aukštas | Textile - Slate Blue, Plastic, Opaque Black, Glass, <Unnamed>, Mattegrey, keys

# IfcFurnishingElement: Ginekologinė kėdė:Ginekologinė kėdė, Ginekologinė kėdė:Ginekologinė kėdė:599858
In: 2 aukštas
Type - Material: металл (нерж.сталь)(1) (2), металл (нерж.сталь) (10), пластик (4), <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Ginekologinė kėdė

# IfcFurnishingElement: Konferencijų stalas:Stalas 3200, Konferencijų stalas:Stalas 3200:1046923
In: 4 aukštas
Type - Material: <Unnamed> (24)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas 3200

# IfcFurnishingElement: Medicininė širma:Medicininė širma, Medicininė širma:Medicininė širma:402203
In: 2 aukštas
Type - Material: <Unnamed> (39)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Medicininė širma

# IfcFurnishingElement: Minkštasuolis:Sofa 2200 (31)
Type - Classification: E2020200 Furniture & Accessories (Uniformat); Material: Leather - Black (6), Metal - Chrome (2)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Sofa 2200
Name (Minkštasuolis:Sofa 2200:...) | In | Material
609524 | 3 aukštas
626257 | 3 aukštas
626288 | 3 aukštas | Leather - Black, Metal - Chrome
626414 | 3 aukštas | Leather - Black, Metal - Chrome
626446 | 3 aukštas | Leather - Black, Metal - Chrome
626664 | 3 aukštas | Leather - Black, Metal - Chrome
626783 | 3 aukštas | Leather - Black, Metal - Chrome
626978 | 3 aukštas | Leather - Black, Metal - Chrome
627115 | 3 aukštas | Leather - Black, Metal - Chrome
627230 | 3 aukštas | Leather - Black, Metal - Chrome
627451 | 3 aukštas | Leather - Black, Metal - Chrome
634708 | 3 aukštas | Leather - Black, Metal - Chrome
634883 | 3 aukštas | Leather - Black, Metal - Chrome
723578 | 2 aukštas | Leather - Black, Metal - Chrome
732508 | Level 1 | Leather - Black, Metal - Chrome
732878 | Level 1 | Leather - Black, Metal - Chrome
733103 | Level 1 | Leather - Black, Metal - Chrome
775053 | 4 aukštas | Leather - Black, Metal - Chrome
775071 | 4 aukštas | Leather - Black, Metal - Chrome
776335 | 4 aukštas | Leather - Black, Metal - Chrome
792934 | Rūsys | Leather - Black, Metal - Chrome
862231 | 2 aukštas | Leather - Black, Metal - Chrome
862475 | 2 aukštas | Leather - Black, Metal - Chrome
863239 | 2 aukštas | Leather - Black, Metal - Chrome
863415 | 2 aukštas | Leather - Black, Metal - Chrome
866436 | 2 aukštas | Leather - Black, Metal - Chrome
866639 | 2 aukštas | Leather - Black, Metal - Chrome
1073943 | 3 aukštas | Leather - Black, Metal - Chrome
1074300 | 3 aukštas | Leather - Black, Metal - Chrome
1103166 | 5 aukštas | Leather - Black, Metal - Chrome
1103167 | 5 aukštas | Leather - Black, Metal - Chrome

# IfcFurnishingElement: Multifunkcinis medicininis vežimėlis:Multifunkcinis medicininis vežimėlis (2)
In: 2 aukštas
Type - Material: <Unnamed> (33)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Multifunkcinis medicininis vežimėlis
Name (Multifunkcinis medicininis vežimėlis:Multifunkcinis medicininis vežimėlis:...)
406488
436410 | Material: <Unnamed>

# IfcFurnishingElement: Pakabinama spintelė max 2 door:900x370x730, Pakabinama spintelė max 2 door:900x370x730:550883
In: 3 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 900x370x730

# IfcFurnishingElement: Paprastas stalas:1400x600 (2)
In: 2 aukštas
Type - Material: <Unnamed> (9)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1400x600
Name (Paprastas stalas:1400x600:...)
977051
977343 | Material: <Unnamed>

# IfcFurnishingElement: Paprastas stalas:1700x600 (2)
In: 5 aukštas
Type - Material: <Unnamed> (9)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1700x600
Name (Paprastas stalas:1700x600:...)
1097944
1098576 | Material: <Unnamed>

# IfcFurnishingElement: Paprastas stalas:3200x600 (4)
In: 2 aukštas
Type - Material: <Unnamed> (9)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 3200x600
Name (Paprastas stalas:3200x600:...)
1003574
1005520
1005579 | Material: <Unnamed>
1005659 | Material: <Unnamed>

# IfcFurnishingElement: Parametric wardrobe1:1200x600 (7)
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1200x600
Name (Parametric wardrobe1:1200x600:...) | In | Material
494581 | 5 aukštas
554730 | 3 aukštas | <Unnamed>
554762 | 3 aukštas | <Unnamed>
554772 | 3 aukštas | <Unnamed>
566530 | 3 aukštas | <Unnamed>
566533 | 3 aukštas | <Unnamed>
568274 | 3 aukštas | <Unnamed>

# IfcFurnishingElement: Parametric wardrobe:1200x400 Spinta (32)
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1200x400 Spinta
Name (Parametric wardrobe:1200x400 Spinta:...) | In | Material
434932 | 3 aukštas
434938 | 3 aukštas | <Unnamed>
435358 | 2 aukštas | <Unnamed>
435361 | 2 aukštas | <Unnamed>
437433 | 2 aukštas | <Unnamed>
437436 | 2 aukštas | <Unnamed>
440602 | 4 aukštas | <Unnamed>
440608 | 4 aukštas | <Unnamed>
440614 | 4 aukštas | <Unnamed>
440620 | 4 aukštas | <Unnamed>
440626 | 4 aukštas | <Unnamed>
440902 | 4 aukštas | <Unnamed>
440905 | 4 aukštas | <Unnamed>
440942 | 4 aukštas | <Unnamed>
440943 | 4 aukštas | <Unnamed>
481318 | 5 aukštas
481319 | 5 aukštas | <Unnamed>
481334 | 5 aukštas | <Unnamed>
481335 | 5 aukštas | <Unnamed>
481336 | 5 aukštas | <Unnamed>
481337 | 5 aukštas | <Unnamed>
481345 | 5 aukštas | <Unnamed>
481346 | 5 aukštas | <Unnamed>
481347 | 5 aukštas | <Unnamed>
481348 | 5 aukštas | <Unnamed>
481368 | 5 aukštas | <Unnamed>
481369 | 5 aukštas | <Unnamed>
549799 | Level 1 | <Unnamed>
549802 | Level 1 | <Unnamed>
549808 | Level 1 | <Unnamed>
549811 | Level 1 | <Unnamed>
744637 | Level 1 | <Unnamed>

# IfcFurnishingElement: Parametric wardrobe:600x1200 Spinta (2)
In: 2 aukštas
Type - Material: <Unnamed> (7)
