Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcBuildingElementProxy: Model Text:600mm Arial (104)
Name (Model Text:600mm Arial:...) | In | Width (mm) | Height (mm)
767383 | 2 aukštas | 97.1676 | 510.13
767391 | 2 aukštas | 97.1676 | 510.13
767399 | 2 aukštas | 97.1676 | 510.13
767407 | 2 aukštas | 97.1676 | 510.13
767415 | 2 aukštas | 97.1676 | 510.13
767423 | 2 aukštas | 97.1676 | 510.13
767431 | 2 aukštas | 97.1676 | 510.13
767447 | 2 aukštas | 97.1676 | 510.13
767455 | 2 aukštas | 97.1676 | 510.13
775793 | 4 aukštas | 97.1676 | 510.13
775861 | 4 aukštas | 97.1676 | 510.13
775880 | 4 aukštas | 97.1676 | 510.13
775897 | 4 aukštas | 97.1676 | 510.13
775905 | 4 aukštas | 97.1676 | 510.13
775913 | 4 aukštas | 97.1676 | 510.13
775925 | 4 aukštas | 97.1676 | 510.13
775944 | 4 aukštas | 97.1676 | 510.13
775952 | 4 aukštas | 97.1676 | 510.13
775960 | 4 aukštas | 97.1676 | 510.13
775968 | 4 aukštas | 97.1676 | 510.13
775976 | 4 aukštas | 97.1676 | 510.13
775984 | 4 aukštas | 97.1676 | 510.13
775992 | 4 aukštas | 97.1676 | 510.13
776007 | 4 aukštas | 97.1676 | 510.13
776015 | 4 aukštas | 97.1676 | 510.13
776023 | 4 aukštas | 97.1676 | 510.13
776031 | 4 aukštas | 97.1676 | 510.13
776039 | 4 aukštas | 97.1676 | 510.13
776070 | 4 aukštas | 97.1676 | 510.13
776078 | 4 aukštas | 97.1676 | 510.13
776088 | 4 aukštas | 97.1676 | 510.13
776096 | 4 aukštas | 97.1676 | 510.13
776111 | 4 aukštas | 97.1676 | 510.13
776183 | 4 aukštas | 97.1676 | 510.13
776191 | 4 aukštas | 97.1676 | 510.13
776199 | 4 aukštas | 97.1676 | 510.13
776205 | 4 aukštas | 97.1676 | 510.13
776215 | 4 aukštas | 97.1676 | 510.13
776223 | 4 aukštas | 97.1676 | 510.13
776781 | 2 aukštas | 97.1676 | 510.13
776789 | 2 aukštas | 97.1676 | 510.13
776797 | 2 aukštas | 97.1676 | 510.13
776805 | 2 aukštas | 97.1676 | 510.13
776813 | 2 aukštas | 97.1676 | 510.13
776821 | 2 aukštas | 97.1676 | 510.13
776829 | 2 aukštas | 97.1676 | 510.13
776859 | 2 aukštas | 97.1676 | 510.13
776869 | 2 aukštas | 97.1676 | 510.13
776877 | 2 aukštas | 97.1676 | 510.13
776885 | 2 aukštas | 97.1676 | 510.13
776893 | 2 aukštas | 97.1676 | 510.13
776901 | 2 aukštas | 97.1676 | 510.13
777175 | 2 aukštas | 97.1676 | 510.13
777183 | 2 aukštas | 97.1676 | 510.13
777191 | 2 aukštas | 97.1676 | 510.13
777199 | 2 aukštas | 97.1676 | 510.13
777207 | 2 aukštas | 97.1676 | 510.13
777215 | 2 aukštas | 97.1676 | 510.13
777223 | 2 aukštas | 97.1676 | 510.13
777231 | 2 aukštas | 97.1676 | 510.13
777239 | 2 aukštas | 97.1676 | 510.13
777247 | 2 aukštas | 97.1676 | 510.13
777262 | 2 aukštas | 97.1676 | 510.13
777270 | 2 aukštas | 97.1676 | 510.13
777278 | 2 aukštas | 97.1676 | 510.13
777286 | 2 aukštas | 97.1676 | 510.13
777334 | 2 aukštas | 97.1676 | 510.13
777342 | 2 aukštas | 97.1676 | 510.13
777350 | 2 aukštas | 97.1676 | 510.13
777358 | 2 aukštas | 97.1676 | 510.13
786592 | 3 aukštas | 97.1676 | 510.13
786614 | 3 aukštas | 97.1676 | 510.13
786622 | 3 aukštas | 97.1676 | 510.13
786628 | 3 aukštas | 97.1676 | 510.13
786642 | 3 aukštas | 97.1676 | 510.13
786650 | 3 aukštas | 97.1676 | 510.13
786660 | 3 aukštas | 97.1676 | 510.13
786668 | 3 aukštas | 97.1676 | 510.13
786678 | 3 aukštas | 97.1676 | 510.13
786686 | 3 aukštas | 97.1676 | 510.13
786698 | 3 aukštas | 97.1676 | 510.13
786706 | 3 aukštas | 97.1676 | 510.13
786716 | 3 aukštas | 97.1676 | 510.13
786724 | 3 aukštas | 97.1676 | 510.13
786734 | 3 aukštas | 97.1676 | 510.13
786744 | 3 aukštas | 97.1676 | 510.13
786752 | 3 aukštas | 97.1676 | 510.13
786760 | 3 aukštas | 97.1676 | 510.13
786860 | Rūsys
896740 | 2 aukštas | 97.1676 | 510.13
1158362 | 4 aukštas | 97.1676 | 510.13

# IfcBuildingElementProxy: Oro ištraukimas iš spintelių:Oro ištraukimas (2)
In: 4 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Oro ištraukimas; sets with these values: 2
Pset_ProvisionForVoid - Depth: 50 mm
Name (Oro ištraukimas iš spintelių:Oro ištraukimas:...)
1153944
1153945

# IfcBuildingElementProxy: Oro ištraukimas iš spintelių:Oro ištraukimas (LAB) (3)
In: 5 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Oro ištraukimas (LAB); sets with these values: 2
Pset_ProvisionForVoid - Depth: 50 mm
Name (Oro ištraukimas iš spintelių:Oro ištraukimas (LAB):...)
1180406
1232942
1343652

# IfcBuildingElementProxy: Prekystalio baldas_prie sienos:Baro baldas_prie sienos 1500, Prekystalio baldas_prie sienos:Baro baldas_prie sienos 1500:787451
In: Level 1
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Baro baldas_prie sienos 1500; sets with these values: 2
Pset_ProvisionForVoid - Width: 1500 mm; Height: 600 mm; Depth: 860 mm

# IfcBuildingElementProxy: Prekystalio baldas_prie sienos:Baro baldas_prie sienos 2000, Prekystalio baldas_prie sienos:Baro baldas_prie sienos 2000:740209
In: Level 1
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Baro baldas_prie sienos 2000; sets with these values: 2
Pset_ProvisionForVoid - Width: 2000 mm; Height: 600 mm; Depth: 860 mm

# IfcBuildingElementProxy: Prielovinis blokas vertikalus:Prielovinis blokas vertikalus (18)
In: 2 aukštas
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Prielovinis blokas vertikalus; sets with these values: 2
Pset_ProvisionForVoid - Width: 101.31 mm; Height: 420 mm; Depth: 1461.21 mm
Name (Prielovinis blokas vertikalus:Prielovinis blokas vertikalus:...) | Material
764742
764750 | <Unnamed>
764758 | <Unnamed>
764766 | <Unnamed>
764780 | <Unnamed>
764790 | <Unnamed>
764800 | <Unnamed>
764808 | <Unnamed>
764814 | <Unnamed>
764824 | <Unnamed>
764832 | <Unnamed>
764840 | <Unnamed>
764846 | <Unnamed>
765767 | <Unnamed>
765886 | <Unnamed>
765951 | <Unnamed>
767114 | <Unnamed>
767299 | <Unnamed>

# IfcBuildingElementProxy: Prielovinis blokas:Prielovinis blokas (67)
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Prielovinis blokas; sets with these values: 2
Pset_ProvisionForVoid - Depth: 400 mm
Name (Prielovinis blokas:Prielovinis blokas:...) | In | Width (mm) | Height (mm) | Material
562454 | 4 aukštas | 101.31 | 2000
638447 | 2 aukštas | 101.31 | 2000 | <Unnamed>
638470 | 2 aukštas | 101.31 | 2000 | <Unnamed>
638515 | 2 aukštas | 101.31 | 2000 | <Unnamed>
638794 | 2 aukštas | 101.31 | 2000 | <Unnamed>
638804 | 2 aukštas | 101.31 | 2000 | <Unnamed>
638832 | 2 aukštas | 101.31 | 2000 | <Unnamed>
716085 | 2 aukštas | 101.31 | 2000 | <Unnamed>
716090 | 2 aukštas | 101.31 | 2000 | <Unnamed>
747209 | 4 aukštas | 101.31 | 2000 | <Unnamed>
766390 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766398 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766410 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766422 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766432 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766440 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766448 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766460 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766611 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766754 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766762 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766770 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766780 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766788 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766796 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766804 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766843 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766855 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766863 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766871 | 2 aukštas | 101.31 | 2000 | <Unnamed>
766893 | 2 aukštas | 2000 | 101.31
766922 | 2 aukštas | 2000 | 101.31 | <Unnamed>
766934 | 2 aukštas | 2000 | 101.31 | <Unnamed>
766948 | 2 aukštas | 2000 | 101.31 | <Unnamed>
766956 | 2 aukštas | 2000 | 101.31 | <Unnamed>
767263 | 2 aukštas | 101.31 | 2000 | <Unnamed>
767316 | 2 aukštas | 101.31 | 2000 | <Unnamed>
767326 | 2 aukštas | 101.31 | 2000 | <Unnamed>
767336 | 2 aukštas | 101.31 | 2000 | <Unnamed>
767346 | 2 aukštas | 101.31 | 2000 | <Unnamed>
774908 | 4 aukštas | 2000 | 101.31 | <Unnamed>
774922 | 4 aukštas | 101.31 | 2000 | <Unnamed>
774933 | 4 aukštas | 101.31 | 2000 | <Unnamed>
774934 | 4 aukštas | 2000 | 101.31 | <Unnamed>
774942 | 4 aukštas | 101.31 | 2000 | <Unnamed>
774943 | 4 aukštas | 2000 | 101.31 | <Unnamed>
774951 | 4 aukštas | 101.31 | 2000 | <Unnamed>
774952 | 4 aukštas | 2000 | 101.31 | <Unnamed>
774978 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775178 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775354 | 4 aukštas | 2000 | 101.31 | <Unnamed>
775420 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775421 | 4 aukštas | 2000 | 101.31 | <Unnamed>
775431 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775432 | 4 aukštas | 2000 | 101.31 | <Unnamed>
775455 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775491 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775646 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775666 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775719 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775729 | 4 aukštas | 2000 | 101.31 | <Unnamed>
775753 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775754 | 4 aukštas | 2000 | 101.31 | <Unnamed>
775764 | 4 aukštas | 101.31 | 2000 | <Unnamed>
775765 | 4 aukštas | 2000 | 101.31 | <Unnamed>
775779 | 4 aukštas | 101.31 | 2000 | <Unnamed>
777680 | 2 aukštas | 101.31 | 2000 | <Unnamed>

# IfcBuildingElementProxy: Printeris:Printeris, Printeris:Printeris:1258392
In: 5 aukštas
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Printeris; sets with these values: 2
Pset_ProvisionForVoid - Width: 575 mm; Height: 658 mm; Depth: 100 mm

# IfcBuildingElementProxy: Rentgeno aparatas:Rentgeno aparatas (2)
In: 2 aukštas
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Rentgeno aparatas; sets with these values: 2
Pset_ProvisionForVoid - Depth: 900 mm
Name (Rentgeno aparatas:Rentgeno aparatas:...) | Width (mm) | Height (mm)
785566 | 2399.45 | 750
785608 | 750 | 2399.45

# IfcBuildingElementProxy: Stalas su plautuve nerudijančio plieno:ST.PL-160/70, Stalas su plautuve nerudijančio plieno:ST.PL-160/70:434650
In: 3 aukštas
Type - Material: <Unnamed> (11)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: ST.PL-160/70; sets with these values: 2

# IfcBuildingElementProxy: Stalas su plautuve nerudijančio plieno:ST.PL-80/70 (13)
Type - Material: <Unnamed> (11)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: ST.PL-80/70; sets with these values: 2
Name (Stalas su plautuve nerudijančio plieno:ST.PL-80/70:...) | In | Material
418417 | 3 aukštas
434731 | 3 aukštas
436252 | 2 aukštas | <Unnamed>
437233 | 2 aukštas | <Unnamed>
438021 | 2 aukštas | <Unnamed>
440518 | 4 aukštas | <Unnamed>
440767 | 4 aukštas | <Unnamed>
495739 | 5 aukštas | <Unnamed>
506360 | 2 aukštas | <Unnamed>
554964 | 3 aukštas | <Unnamed>
793028 | Rūsys | <Unnamed>
807792 | 4 aukštas | <Unnamed>
1103764 | 5 aukštas | <Unnamed>

# IfcBuildingElementProxy: Table with Sink Editable:ST.PL 120/70 V (2)
In: Level 1
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: ST.PL 120/70 V; sets with these values: 2
Name (Table with Sink Editable:ST.PL 120/70 V:...)
688449
689188

# IfcBuildingElementProxy: Table with Sink Editable:ST.PL 150/70 (4)
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: ST.PL 150/70; sets with these values: 2
Name (Table with Sink Editable:ST.PL 150/70:...) | In
483832 | 5 aukštas
716192 | Rūsys | Material: <Unnamed>
757701 | Rūsys | Material: <Unnamed>
795422 | Rūsys

# IfcBuildingElementProxy: Traukos spinta 1200x900 (be kriauklės):1500Lx863W (LAB), Traukos spinta 1200x900 (be kriauklės):1500Lx863W (LAB):1232941
In: 5 aukštas
Type - Material: Pulls (3), <Unnamed> (18), plastic wheels (4), Stainless Steel (12), Glass, Default (4)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Height: 1590 mm
Pset_BuildingElementProxyCommon - Reference: 1500Lx863W (LAB); sets with these values: 2

# IfcBuildingElementProxy: Traukos spinta 1200x900:1500Lx863W (2)
In: 4 aukštas
Type - Material: <Unnamed>, Glass, Natural Acrylic Stone_Himacs_CS325R_S201 Naugat Cream
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Height: 1590 mm
Material: Natural Acrylic Stone_Himacs_CS325R_S201 Naugat Cream, Steel_Himacs_CS325R_Polished, <Unnamed>, Swanneck Tap Body, Pulls, plastic wheels, Stainless Steel, Glass, Default
Pset_BuildingElementProxyCommon - Reference: 1500Lx863W; sets with these values: 2
Name (Traukos spinta 1200x900:1500Lx863W:...)
560584
560623

# IfcBuildingElementProxy: Traukos spinta 1200x900:1500Lx863W (LAB) (2)
In: 5 aukštas
Type - Material: <Unnamed>, Glass, Natural Acrylic Stone_Himacs_CS325R_S201 Naugat Cream
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Height: 1590 mm
Material: Natural Acrylic Stone_Himacs_CS325R_S201 Naugat Cream, Steel_Himacs_CS325R_Polished, <Unnamed>, Swanneck Tap Body, Pulls, plastic wheels, Stainless Steel, Glass, Default
Pset_BuildingElementProxyCommon - Reference: 1500Lx863W (LAB); sets with these values: 2
Name (Traukos spinta 1200x900:1500Lx863W (LAB):...)
1180405
1343651

# IfcBuildingElementProxy: Vent_Hood_Built_In_Lighting_18390:Vent_Hood_Built_In_Lighting_18390 V, Vent_Hood_Built_In_Lighting_18390:Vent_Hood_Built_In_Lighting_18390 V:670680
In: Level 1
Type - Material: <Unnamed> (21)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Vent_Hood_Built_In_Lighting_18390 V; sets with these values: 2

# IfcBuildingElementProxy: Ventiliacinis gaubtas reguliuojamas:Ventiliacijos gaubtas (LAB), Ventiliacinis gaubtas reguliuojamas:Ventiliacijos gaubtas (LAB):1383031
In: 5 aukštas
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Ventiliacijos gaubtas (LAB); sets with these values: 2
Pset_ProvisionForVoid - Width: 1200 mm; Height: 1600 mm; Depth: 500 mm

# IfcBuildingElementProxy: Virykle 4 lank:El. viryklė 800x730x908 V, Virykle 4 lank:El. viryklė 800x730x908 V:680757
In: Level 1
Type - Material: Fisher & Paykel - Steel, Chrome Plated (19), Fisher & Paykel - Stainless Steel (18), Fisher & Paykel - Glass, Black, Fisher & Paykel - Aluminium, Fisher & Paykel - White Bezel (6), Fisher & Paykel - Aluminium, Dark (6), Fisher & Paykel - Grey (5), Fisher & Paykel - Black (3), <Unnamed> (4)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Fisher & Paykel Appliances
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: El. viryklė 800x730x908 V; sets with these values: 2

# IfcBuildingElementProxy: gyvatukas:shower_mixer_3390 (13)
Type - Material: HTR - Chrome (22)
Type - Pset_ProductRequirements - Category: Plumbing Equipment
Pset_BuildingElementProxyCommon - Reference: shower_mixer_3390; sets with these values: 2
Name (gyvatukas:shower_mixer_3390:...) | In | Material
413523 | 3 aukštas
434730 | 3 aukštas
436251 | 2 aukštas | HTR - Chrome
437232 | 2 aukštas | HTR - Chrome
437384 | 2 aukštas | HTR - Chrome
440517 | 4 aukštas | HTR - Chrome
440766 | 4 aukštas | HTR - Chrome
495738 | 5 aukštas | HTR - Chrome
506359 | 2 aukštas | HTR - Chrome
554963 | 3 aukštas | HTR - Chrome
759223 | 4 aukštas | HTR - Chrome
793027 | Rūsys | HTR - Chrome
1103763 | 5 aukštas | HTR - Chrome

# IfcBuildingElementProxy: kavos aparatas x2:kavos aparatas x2, kavos aparatas x2:kavos aparatas x2:729273
In: Level 1
Type - Material: Steel mesh (5), STEEL (4), ABS Plastic Black (2), rubber legs (12), chrome (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: kavos aparatas x2; sets with these values: 2
Pset_ProvisionForVoid - Width: 19.05 mm; Height: 40 mm; Depth: 501.78 mm

# IfcBuildingElementProxy: konsolė prie lovos 1:konsolė prie lovos (6)
In: 2 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: konsolė prie lovos; sets with these values: 2
Pset_ProvisionForVoid - Depth: 176 mm
Name (konsolė prie lovos 1:konsolė prie lovos:...) | Material
648894
649062 | <Unnamed>
649076 | <Unnamed>
649190 | <Unnamed>
776689 | <Unnamed>
776690 | <Unnamed>

# IfcBuildingElementProxy: konsolė prie lovos:konsolė prie lovos (24)
In: 3 aukštas
Type - Material: <Unnamed> (13)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: konsolė prie lovos; sets with these values: 2
Pset_ProvisionForVoid - Depth: 176 mm
Name (konsolė prie lovos:konsolė prie lovos:...) | Material
649259
649313 | <Unnamed>
649612 | <Unnamed>
649801 | <Unnamed>
652550
699323 | <Unnamed>
772024 | <Unnamed>
772055 | <Unnamed>
772059 | <Unnamed>
772154 | <Unnamed>
772461 | <Unnamed>
772806 | <Unnamed>
772807 | <Unnamed>
772808 | <Unnamed>
772845 | <Unnamed>
772846 | <Unnamed>
772847 | <Unnamed>
772909 | <Unnamed>
772910 | <Unnamed>
772911 | <Unnamed>
773930 | <Unnamed>
774006 | <Unnamed>
774016 | <Unnamed>
774079 | <Unnamed>

# IfcBuildingElementProxy: medicininė lempa:medicininė lempa (20)
In: 2 aukštas
Type - Material: Glass, <Unnamed> (12)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: medicininė lempa; sets with these values: 2
Name (medicininė lempa:medicininė lempa:...) | Material
757794
767523 | Glass, <Unnamed>
767803 | Glass, <Unnamed>
767866 | Glass, <Unnamed>
767974 | Glass, <Unnamed>
768171 | Glass, <Unnamed>
768278 | Glass, <Unnamed>
768420 | Glass, <Unnamed>
768489 | Glass, <Unnamed>
768579 | Glass, <Unnamed>
768648 | Glass, <Unnamed>
768653 | Glass, <Unnamed>
768658 | Glass, <Unnamed>
768676 | Glass, <Unnamed>
768696 | Glass, <Unnamed>
768847 | Glass, <Unnamed>
768852 | Glass, <Unnamed>
768857 | Glass, <Unnamed>
776697 | Glass, <Unnamed>
776698 | Glass, <Unnamed>

# IfcBuildingElementProxy: Šaldymo kameros agregatas:Šaldymo kameros agregatas, Šaldymo kameros agregatas:Šaldymo kameros agregatas:802432
In: Rūsys
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldymo kameros agregatas; sets with these values: 2
Pset_ProvisionForVoid - Width: 446 mm; Height: 1035 mm; Depth: 590 mm

# IfcBuildingElementProxy: Šaldytuvas didelis:Šaldiklis (2)
In: Rūsys
Type - Material: <Unnamed> (19)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldiklis; sets with these values: 2
Name (Šaldytuvas didelis:Šaldiklis:...)
791614
791658 | Material: <Unnamed>

# IfcBuildingElementProxy: Šaldytuvas didelis:Šaldytuvas +4C/-20C (LAB) (12)
In: 5 aukštas
Type - Material: <Unnamed> (19)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldytuvas +4C/-20C (LAB); sets with these values: 2
Name (Šaldytuvas didelis:Šaldytuvas +4C/-20C (LAB):...) | Material
1079637
1079642 | <Unnamed>
1080025 | <Unnamed>
1085188 | <Unnamed>
1097596 | <Unnamed>
1197754 | <Unnamed>
1197762 | <Unnamed>
1232572 | <Unnamed>
1232573 | <Unnamed>
1232968 | <Unnamed>
1256717 | <Unnamed>
1343702 | <Unnamed>

# IfcBuildingElementProxy: Šaldytuvas didelis:Šaldytuvas didelis (14)
Type - Material: <Unnamed> (19)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldytuvas didelis; sets with these values: 2
Name (Šaldytuvas didelis:Šaldytuvas didelis:...) | In | Material
554600 | 3 aukštas
555128 | 3 aukštas | <Unnamed>
564552 | 3 aukštas
564891 | 3 aukštas | <Unnamed>
564995 | 3 aukštas | <Unnamed>
566503 | 3 aukštas | <Unnamed>
569110 | 3 aukštas | <Unnamed>
732599 | Level 1 | <Unnamed>
733022 | Level 1 | <Unnamed>
745279 | Level 1 | <Unnamed>
775008 | 4 aukštas | <Unnamed>
776233 | 4 aukštas | <Unnamed>
792683 | Rūsys | <Unnamed>
866268 | 2 aukštas | <Unnamed>

# IfcBuildingElementProxy: Šaldytuvas_šaldiklis -150 laipsnių:Šaldiklis (LAB) (2)
In: 5 aukštas
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldiklis (LAB); sets with these values: 2
Pset_ProvisionForVoid - Width: 1690 mm; Height: 735 mm; Depth: 100 mm
Name (Šaldytuvas_šaldiklis -150 laipsnių:Šaldiklis (LAB):...)
1105163
1211684 | Material: <Unnamed>

# IfcBuildingElementProxy: Šaldytuvas_šaldiklis reguliuojamas:Šaldiklis -80C (LAB) (8)
In: 5 aukštas
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldiklis -80C (LAB); sets with these values: 2
Pset_ProvisionForVoid - Width: 960 mm; Height: 970 mm; Depth: 100 mm
Name (Šaldytuvas_šaldiklis reguliuojamas:Šaldiklis -80C (LAB):...) | Material
1086496
1087933 | <Unnamed>
1087943 | <Unnamed>
1087951 | <Unnamed>
1211521 | <Unnamed>
1211680 | <Unnamed>
1211681 | <Unnamed>
1211682 | <Unnamed>

# IfcBuildingElementProxy: Šaldytuvas_šaldiklis reguliuojamas:Šaldytuvas V, Šaldytuvas_šaldiklis reguliuojamas:Šaldytuvas V:886590
In: Level 1
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Šaldytuvas V; sets with these values: 2
Pset_ProvisionForVoid - Width: 560 mm; Height: 570 mm; Depth: 100 mm

# IfcDistributionPort (1641)
Description: Flow
Name | FlowDirection
Port_374766 | SOURCE
Port_376847 | SOURCEANDSINK
Port_412570 | SOURCEANDSINK
3 x Port_418417 | SOURCEANDSINK
3 x Port_427648 | SOURCEANDSINK
Port_433957 | SOURCEANDSINK
Port_434009 | SOURCEANDSINK
Port_434019 | SOURCEANDSINK
Port_434392 | SOURCEANDSINK
3 x Port_434650 | SOURCEANDSINK
Port_434683 | SOURCEANDSINK
Port_434703 | SOURCEANDSINK
Port_434729 | SOURCE
3 x Port_434731 | SOURCEANDSINK
3 x Port_435279 | SOURCEANDSINK
Port_435610 | SOURCEANDSINK
Port_435637 | SOURCEANDSINK
Port_435678 | SOURCEANDSINK
Port_435683 | SOURCEANDSINK
Port_435688 | SOURCEANDSINK
Port_435693 | SOURCEANDSINK
Port_435698 | SOURCEANDSINK
Port_435703 | SOURCEANDSINK
Port_435708 | SOURCEANDSINK
Port_435713 | SOURCEANDSINK
Port_435718 | SOURCEANDSINK
Port_435723 | SOURCEANDSINK
Port_435728 | SOURCEANDSINK
Port_435733 | SOURCEANDSINK
Port_435738 | SOURCEANDSINK
Port_435743 | SOURCEANDSINK
Port_435748 | SOURCEANDSINK
Port_435753 | SOURCEANDSINK
Port_435758 | SOURCEANDSINK
Port_435763 | SOURCEANDSINK
Port_435970 | SOURCEANDSINK
Port_435975 | SOURCEANDSINK
Port_436248 | SOURCE
Port_436250 | SOURCEANDSINK
3 x Port_436252 | SOURCEANDSINK
3 x Port_436371 | SOURCEANDSINK
Port_437107 | SOURCEANDSINK
Port_437119 | SOURCEANDSINK
Port_437133 | SOURCEANDSINK
Port_437162 | SOURCEANDSINK
Port_437230 | SOURCE
Port_437231 | SOURCEANDSINK
3 x Port_437233 | SOURCEANDSINK
Port_437383 | SOURCEANDSINK
3 x Port_437950 | SOURCEANDSINK
3 x Port_438021 | SOURCEANDSINK
Port_438111 | SOURCE
Port_438175 | SOURCEANDSINK
Port_438578 | SOURCEANDSINK
Port_439001 | SOURCEANDSINK
Port_439223 | SOURCEANDSINK
Port_439235 | SOURCEANDSINK
Port_439249 | SOURCEANDSINK
Port_439491 | SOURCEANDSINK
Port_439505 | SOURCEANDSINK
Port_439519 | SOURCEANDSINK
Port_439531 | SOURCEANDSINK
Port_439694 | SOURCEANDSINK
Port_439704 | SOURCEANDSINK
Port_439720 | SOURCEANDSINK
Port_439732 | SOURCEANDSINK
Port_439744 | SOURCEANDSINK
Port_439754 | SOURCEANDSINK
Port_439778 | SOURCEANDSINK
Port_439780 | SOURCEANDSINK
Port_439782 | SOURCEANDSINK
Port_439784 | SOURCEANDSINK
Port_439786 | SOURCEANDSINK
Port_439788 | SOURCEANDSINK
Port_439807 | SOURCEANDSINK
Port_439809 | SOURCEANDSINK
Port_439811 | SOURCEANDSINK
Port_439888 | SOURCEANDSINK
Port_439890 | SOURCEANDSINK
Port_439892 | SOURCEANDSINK
Port_439894 | SOURCEANDSINK
Port_440060 | SOURCEANDSINK
Port_440062 | SOURCEANDSINK
Port_440064 | SOURCEANDSINK
Port_440066 | SOURCEANDSINK
Port_440133 | SOURCEANDSINK
Port_440144 | SOURCEANDSINK
Port_440149 | SOURCEANDSINK
Port_440174 | SOURCEANDSINK
Port_440175 | SOURCEANDSINK
Port_440193 | SOURCEANDSINK
Port_440194 | SOURCEANDSINK
Port_440219 | SOURCEANDSINK
Port_440238 | SOURCEANDSINK
Port_440266 | SOURCEANDSINK
Port_440267 | SOURCEANDSINK
Port_440279 | SOURCEANDSINK
Port_440280 | SOURCEANDSINK
Port_440292 | SOURCEANDSINK
Port_440293 | SOURCEANDSINK
Port_440349 | SOURCEANDSINK
Port_440360 | SOURCEANDSINK
Port_440402 | SOURCEANDSINK
Port_440421 | SOURCEANDSINK
Port_440438 | SOURCEANDSINK
Port_440447 | SOURCEANDSINK
Port_440468 | SOURCEANDSINK
Port_440479 | SOURCEANDSINK
Port_440498 | SOURCEANDSINK
Port_440516 | SOURCE
3 x Port_440518 | SOURCEANDSINK
Port_440716 | SOURCEANDSINK
Port_440747 | SOURCEANDSINK
Port_440764 | SOURCE
Port_440765 | SOURCEANDSINK
3 x Port_440767 | SOURCEANDSINK
Port_440809 | SOURCEANDSINK
Port_440820 | SOURCEANDSINK
3 x Port_440841 | SOURCEANDSINK
3 x Port_483832 | SOURCEANDSINK
3 x Port_494742 | SOURCEANDSINK
3 x Port_494810 | SOURCEANDSINK
Port_495737 | SOURCE
3 x Port_495739 | SOURCEANDSINK
Port_495741 | SOURCEANDSINK
3 x Port_495841 | SOURCEANDSINK
Port_506358 | SOURCE
3 x Port_506360 | SOURCEANDSINK
Port_506378 | SOURCEANDSINK
Port_552955 | SOURCEANDSINK
Port_554600 | SOURCEANDSINK
Port_554962 | SOURCE
3 x Port_554964 | SOURCEANDSINK
Port_555004 | SOURCEANDSINK
Port_555128 | SOURCEANDSINK
Port_557511 | SOURCEANDSINK
Port_557566 | SOURCEANDSINK
Port_557590 | SOURCEANDSINK
Port_557703 | SOURCEANDSINK
Port_557748 | SOURCEANDSINK
Port_557789 | SOURCEANDSINK
Port_557791 | SOURCEANDSINK
Port_557822 | SOURCEANDSINK
Port_557824 | SOURCEANDSINK
4 x Port_560584 | SOURCEANDSINK
4 x Port_560623 | SOURCEANDSINK
3 x Port_560643 | SOURCEANDSINK
Port_562454 | SOURCEANDSINK
3 x Port_564550 | SOURCEANDSINK
Port_564552 | SOURCEANDSINK
Port_564553 | SOURCEANDSINK
3 x Port_564889 | SOURCEANDSINK
Port_564891 | SOURCEANDSINK
Port_564892 | SOURCEANDSINK
3 x Port_564993 | SOURCEANDSINK
Port_564995 | SOURCEANDSINK
Port_564996 | SOURCEANDSINK
Port_565459 | SOURCEANDSINK
Port_565461 | SOURCEANDSINK
Port_566311 | SOURCEANDSINK
Port_566346 | SOURCEANDSINK
Port_566362 | SOURCEANDSINK
Port_566367 | SOURCEANDSINK
Port_566372 | SOURCEANDSINK
Port_566503 | SOURCEANDSINK
3 x Port_566504 | SOURCEANDSINK
Port_566965 | SOURCEANDSINK
Port_568685 | SOURCEANDSINK
Port_569110 | SOURCEANDSINK
Port_569235 | SOURCEANDSINK
Port_599770 | SOURCEANDSINK
Port_599799 | SOURCEANDSINK
Port_600003 | SOURCEANDSINK
Port_609861 | SOURCEANDSINK
Port_609862 | SOURCEANDSINK
Port_609872 | SOURCEANDSINK
Port_609873 | SOURCEANDSINK
Port_609987 | SOURCEANDSINK
Port_626259 | SOURCEANDSINK
Port_626260 | SOURCEANDSINK
Port_626261 | SOURCEANDSINK
Port_626262 | SOURCEANDSINK
Port_626263 | SOURCEANDSINK
Port_626290 | SOURCEANDSINK
Port_626291 | SOURCEANDSINK
Port_626292 | SOURCEANDSINK
Port_626293 | SOURCEANDSINK
Port_626294 | SOURCEANDSINK
Port_626312 | SOURCEANDSINK
Port_626313 | SOURCEANDSINK
Port_626314 | SOURCEANDSINK
Port_626315 | SOURCEANDSINK
Port_626316 | SOURCEANDSINK
Port_626416 | SOURCEANDSINK
Port_626417 | SOURCEANDSINK
Port_626418 | SOURCEANDSINK
Port_626419 | SOURCEANDSINK
Port_626420 | SOURCEANDSINK
Port_628303 | SOURCEANDSINK
Port_628550 | SOURCEANDSINK
Port_628555 | SOURCEANDSINK
Port_628746 | SOURCEANDSINK
Port_628866 | SOURCEANDSINK
Port_628870 | SOURCEANDSINK
Port_629069 | SOURCEANDSINK
Port_629214 | SOURCEANDSINK
Port_629277 | SOURCEANDSINK
Port_629418 | SOURCEANDSINK
Port_629597 | SOURCEANDSINK
Port_629880 | SOURCEANDSINK
Port_630029 | SOURCEANDSINK
Port_630166 | SOURCEANDSINK
Port_630522 | SOURCEANDSINK
Port_630782 | SOURCEANDSINK
Port_630787 | SOURCEANDSINK
Port_631514 | SOURCEANDSINK
Port_631666 | SOURCEANDSINK
Port_631975 | SOURCEANDSINK
Port_632085 | SOURCEANDSINK
Port_632212 | SOURCEANDSINK
4 x Port_633310 | SOURCEANDSINK
4 x Port_633686 | SOURCEANDSINK
4 x Port_633821 | SOURCEANDSINK
Port_633999 | SOURCEANDSINK
Port_635364 | SOURCEANDSINK
Port_635487 | SOURCEANDSINK
Port_635492 | SOURCEANDSINK
Port_635497 | SOURCEANDSINK
Port_635502 | SOURCEANDSINK
Port_635595 | SOURCEANDSINK
Port_635760 | SOURCEANDSINK
Port_635907 | SOURCEANDSINK
Port_635941 | SOURCEANDSINK
Port_636534 | SOURCEANDSINK
Port_637107 | SOURCEANDSINK
Port_637186 | SOURCEANDSINK
Port_637399 | SOURCEANDSINK
Port_637668 | SOURCEANDSINK
Port_638443 | SOURCEANDSINK
Port_638447 | SOURCEANDSINK
Port_638449 | SOURCEANDSINK
Port_638450 | SOURCEANDSINK
Port_638470 | SOURCEANDSINK
Port_638492 | SOURCEANDSINK
Port_638497 | SOURCEANDSINK
Port_638515 | SOURCEANDSINK
Port_638565 | SOURCEANDSINK
Port_638570 | SOURCEANDSINK
4 x Port_638620 | SOURCEANDSINK
4 x Port_638708 | SOURCEANDSINK
Port_638794 | SOURCEANDSINK
Port_638804 | SOURCEANDSINK
Port_638832 | SOURCEANDSINK
Port_648894 | SOURCEANDSINK
Port_649062 | SOURCEANDSINK
Port_649076 | SOURCEANDSINK
Port_649190 | SOURCEANDSINK
Port_649259 | SOURCEANDSINK
Port_649313 | SOURCEANDSINK
Port_649612 | SOURCEANDSINK
Port_649801 | SOURCEANDSINK
Port_649991 | SOURCEANDSINK
Port_651044 | SOURCEANDSINK
Port_651195 | SOURCEANDSINK
Port_651424 | SOURCEANDSINK
Port_651775 | SOURCEANDSINK
Port_651776 | SOURCEANDSINK
Port_651795 | SOURCEANDSINK
Port_651796 | SOURCEANDSINK
Port_652548 | SOURCEANDSINK
Port_652550 | SOURCEANDSINK
3 x Port_656075 | SOURCEANDSINK
3 x Port_658708 | SOURCEANDSINK
Port_662318 | SOURCEANDSINK
2 x Port_670680 | SOURCEANDSINK
Port_672570 | SOURCEANDSINK
2 x Port_673734 | SOURCEANDSINK
Port_680757 | SINK
Port_680757 | SOURCEANDSINK
Port_688230 | SOURCEANDSINK
3 x Port_688449 | SOURCEANDSINK
3 x Port_689009 | SOURCEANDSINK
3 x Port_689188 | SOURCEANDSINK
Port_692272 | SOURCEANDSINK
4 x Port_698357 | SOURCEANDSINK
Port_698418 | SOURCEANDSINK
Port_698618 | SOURCEANDSINK
Port_698687 | SOURCEANDSINK
Port_699323 | SOURCEANDSINK
3 x Port_702288 | SOURCEANDSINK
Port_716085 | SOURCEANDSINK
Port_716090 | SOURCEANDSINK
3 x Port_716192 | SOURCEANDSINK
Port_716227 | SOURCEANDSINK
Port_718099 | SOURCEANDSINK
Port_719014 | SOURCEANDSINK
4 x Port_724949 | SOURCEANDSINK
Port_724965 | SOURCE
4 x Port_726483 | SOURCEANDSINK
3 x Port_726715 | SOURCEANDSINK
3 x Port_729273 | SOURCEANDSINK
3 x Port_732597 | SOURCEANDSINK
Port_732599 | SOURCEANDSINK
Port_732600 | SOURCEANDSINK
Port_732601 | SOURCEANDSINK
3 x Port_733020 | SOURCEANDSINK
Port_733022 | SOURCEANDSINK
Port_733023 | SOURCEANDSINK
Port_733024 | SOURCEANDSINK
2 x Port_736814 | SOURCEANDSINK
Port_745279 | SOURCEANDSINK
Port_747209 | SOURCEANDSINK
3 x Port_757701 | SOURCEANDSINK
Port_757794 | SOURCEANDSINK
Port_758012 | SOURCEANDSINK
Port_758311 | SOURCEANDSINK
Port_758312 | SOURCEANDSINK
Port_758325 | SOURCEANDSINK
Port_758351 | SOURCEANDSINK
Port_758455 | SOURCEANDSINK
Port_759011 | SOURCE
Port_759021 | SOURCEANDSINK
4 x Port_759037 | SOURCEANDSINK
Port_764742 | SOURCEANDSINK
Port_764750 | SOURCEANDSINK
Port_764758 | SOURCEANDSINK
Port_764766 | SOURCEANDSINK
Port_764780 | SOURCEANDSINK
Port_764790 | SOURCEANDSINK
Port_764800 | SOURCEANDSINK
Port_764808 | SOURCEANDSINK
Port_764814 | SOURCEANDSINK
Port_764824 | SOURCEANDSINK
Port_764832 | SOURCEANDSINK
Port_764840 | SOURCEANDSINK
Port_764846 | SOURCEANDSINK
Port_765767 | SOURCEANDSINK
Port_765886 | SOURCEANDSINK
Port_765951 | SOURCEANDSINK
Port_766390 | SOURCEANDSINK
Port_766398 | SOURCEANDSINK
Port_766410 | SOURCEANDSINK
Port_766422 | SOURCEANDSINK
Port_766432 | SOURCEANDSINK
Port_766440 | SOURCEANDSINK
Port_766448 | SOURCEANDSINK
Port_766460 | SOURCEANDSINK
Port_766611 | SOURCEANDSINK
Port_766754 | SOURCEANDSINK
Port_766762 | SOURCEANDSINK
Port_766770 | SOURCEANDSINK
Port_766780 | SOURCEANDSINK
Port_766788 | SOURCEANDSINK
Port_766796 | SOURCEANDSINK
Port_766804 | SOURCEANDSINK
Port_766843 | SOURCEANDSINK
Port_766855 | SOURCEANDSINK
Port_766863 | SOURCEANDSINK
Port_766871 | SOURCEANDSINK
Port_766893 | SOURCEANDSINK
Port_766922 | SOURCEANDSINK
Port_766934 | SOURCEANDSINK
Port_766948 | SOURCEANDSINK
Port_766956 | SOURCEANDSINK
Port_767114 | SOURCEANDSINK
Port_767263 | SOURCEANDSINK
Port_767299 | SOURCEANDSINK
Port_767316 | SOURCEANDSINK
Port_767326 | SOURCEANDSINK
Port_767336 | SOURCEANDSINK
Port_767346 | SOURCEANDSINK
Port_767523 | SOURCEANDSINK
Port_767803 | SOURCEANDSINK
Port_767866 | SOURCEANDSINK
Port_767974 | SOURCEANDSINK
Port_768171 | SOURCEANDSINK
Port_768278 | SOURCEANDSINK
Port_768420 | SOURCEANDSINK
Port_768489 | SOURCEANDSINK
Port_768579 | SOURCEANDSINK
Port_768648 | SOURCEANDSINK
Port_768653 | SOURCEANDSINK
Port_768658 | SOURCEANDSINK
Port_768676 | SOURCEANDSINK
Port_768696 | SOURCEANDSINK
Port_768847 | SOURCEANDSINK
Port_768852 | SOURCEANDSINK
Port_768857 | SOURCEANDSINK
4 x Port_769315 | SOURCEANDSINK
Port_769316 | SOURCE
Port_772023 | SOURCEANDSINK
Port_772024 | SOURCEANDSINK
Port_772052 | SOURCEANDSINK
Port_772055 | SOURCEANDSINK
Port_772058 | SOURCEANDSINK
Port_772059 | SOURCEANDSINK
Port_772153 | SOURCEANDSINK
Port_772154 | SOURCEANDSINK
Port_772460 | SOURCEANDSINK
Port_772461 | SOURCEANDSINK
Port_772801 | SOURCEANDSINK
Port_772802 | SOURCEANDSINK
Port_772803 | SOURCEANDSINK
Port_772804 | SOURCEANDSINK
Port_772805 | SOURCEANDSINK
Port_772806 | SOURCEANDSINK
Port_772807 | SOURCEANDSINK
Port_772808 | SOURCEANDSINK
Port_772840 | SOURCEANDSINK
Port_772841 | SOURCEANDSINK
Port_772842 | SOURCEANDSINK
Port_772843 | SOURCEANDSINK
Port_772844 | SOURCEANDSINK
Port_772845 | SOURCEANDSINK
Port_772846 | SOURCEANDSINK
Port_772847 | SOURCEANDSINK
Port_772904 | SOURCEANDSINK
Port_772905 | SOURCEANDSINK
Port_772906 | SOURCEANDSINK
Port_772907 | SOURCEANDSINK
Port_772908 | SOURCEANDSINK
Port_772909 | SOURCEANDSINK
Port_772910 | SOURCEANDSINK
Port_772911 | SOURCEANDSINK
Port_773929 | SOURCEANDSINK
Port_773930 | SOURCEANDSINK
Port_774005 | SOURCEANDSINK
Port_774006 | SOURCEANDSINK
Port_774015 | SOURCEANDSINK
Port_774016 | SOURCEANDSINK
Port_774078 | SOURCEANDSINK
Port_774079 | SOURCEANDSINK
Port_774908 | SOURCEANDSINK
Port_774922 | SOURCEANDSINK
Port_774933 | SOURCEANDSINK
Port_774934 | SOURCEANDSINK
Port_774942 | SOURCEANDSINK
Port_774943 | SOURCEANDSINK
Port_774951 | SOURCEANDSINK
Port_774952 | SOURCEANDSINK
Port_774978 | SOURCEANDSINK
3 x Port_775006 | SOURCEANDSINK
Port_775008 | SOURCEANDSINK
Port_775012 | SOURCEANDSINK
Port_775178 | SOURCEANDSINK
Port_775354 | SOURCEANDSINK
Port_775420 | SOURCEANDSINK
Port_775421 | SOURCEANDSINK
Port_775431 | SOURCEANDSINK
Port_775432 | SOURCEANDSINK
Port_775455 | SOURCEANDSINK
Port_775491 | SOURCEANDSINK
Port_775646 | SOURCEANDSINK
Port_775666 | SOURCEANDSINK
Port_775719 | SOURCEANDSINK
Port_775729 | SOURCEANDSINK
Port_775753 | SOURCEANDSINK
Port_775754 | SOURCEANDSINK
Port_775764 | SOURCEANDSINK
Port_775765 | SOURCEANDSINK
Port_775779 | SOURCEANDSINK
Port_776233 | SOURCEANDSINK
3 x Port_776531 | SOURCEANDSINK
Port_776685 | SOURCEANDSINK
Port_776686 | SOURCEANDSINK
Port_776689 | SOURCEANDSINK
Port_776690 | SOURCEANDSINK
Port_776697 | SOURCEANDSINK
Port_776698 | SOURCEANDSINK
4 x Port_777102 | SOURCEANDSINK
Port_777103 | SOURCE
4 x Port_777146 | SOURCEANDSINK
Port_777147 | SOURCE
Port_777632 | SOURCEANDSINK
Port_777680 | SOURCEANDSINK
Port_783889 | SOURCEANDSINK
Port_784769 | SOURCEANDSINK
Port_785566 | SOURCEANDSINK
Port_785608 | SOURCEANDSINK
Port_785713 | SOURCEANDSINK
Port_785986 | SOURCEANDSINK
Port_786179 | SOURCEANDSINK
Port_786987 | SOURCE
Port_788434 | SOURCEANDSINK
Port_791486 | SOURCEANDSINK
Port_791496 | SOURCEANDSINK
Port_791522 | SOURCEANDSINK
Port_791562 | SOURCEANDSINK
Port_791567 | SOURCEANDSINK
Port_791614 | SOURCEANDSINK
Port_791658 | SOURCEANDSINK
3 x Port_792681 | SOURCEANDSINK
Port_792683 | SOURCEANDSINK
Port_792684 | SOURCEANDSINK
Port_792685 | SOURCEANDSINK
Port_793025 | SOURCEANDSINK
Port_793026 | SOURCE
3 x Port_793028 | SOURCEANDSINK
Port_793920 | SOURCEANDSINK
Port_794018 | SOURCEANDSINK
3 x Port_795422 | SOURCEANDSINK
3 x Port_801409 | SOURCEANDSINK
3 x Port_801506 | SOURCEANDSINK
Port_802432 | SOURCEANDSINK
Port_802474 | SOURCEANDSINK
Port_802484 | SOURCEANDSINK
2 x Port_804883 | SOURCEANDSINK
2 x Port_805252 | SOURCEANDSINK
2 x Port_805337 | SOURCEANDSINK
3 x Port_805876 | SOURCEANDSINK
2 x Port_806189 | SOURCEANDSINK
2 x Port_806539 | SOURCEANDSINK
2 x Port_806861 | SOURCEANDSINK
3 x Port_806908 | SOURCEANDSINK
2 x Port_807279 | SOURCEANDSINK
2 x Port_807496 | SOURCEANDSINK
Port_807526 | SOURCE
3 x Port_807792 | SOURCEANDSINK
4 x Port_807848 | SOURCEANDSINK
3 x Port_808008 | SOURCEANDSINK
3 x Port_808169 | SOURCEANDSINK
Port_808436 | SOURCEANDSINK
2 x Port_808753 | SOURCEANDSINK
3 x Port_808807 | SOURCEANDSINK
3 x Port_808980 | SOURCEANDSINK
2 x Port_809175 | SOURCEANDSINK
Port_809360 | SOURCEANDSINK
Port_810663 | SOURCEANDSINK
Port_810707 | SOURCEANDSINK
Port_811111 | SOURCEANDSINK
Port_811227 | SOURCEANDSINK
Port_811228 | SOURCEANDSINK
Port_811271 | SOURCEANDSINK
Port_811281 | SOURCEANDSINK
Port_811291 | SOURCEANDSINK
Port_811299 | SOURCEANDSINK
2 x Port_811329 | SOURCEANDSINK
Port_811513 | SOURCEANDSINK
Port_811565 | SOURCEANDSINK
Port_811920 | SOURCE
Port_811922 | SOURCEANDSINK
Port_811924 | SOURCEANDSINK
Port_811945 | SOURCE
Port_811947 | SOURCEANDSINK
Port_811949 | SOURCEANDSINK
Port_811973 | SOURCE
Port_811975 | SOURCEANDSINK
Port_811977 | SOURCEANDSINK
Port_811990 | SOURCE
Port_811992 | SOURCEANDSINK
Port_811994 | SOURCEANDSINK
Port_812007 | SOURCE
Port_812009 | SOURCEANDSINK
Port_812011 | SOURCEANDSINK
Port_812026 | SOURCEANDSINK
Port_812087 | SOURCEANDSINK
Port_812096 | SOURCEANDSINK
Port_812109 | SOURCEANDSINK
Port_812118 | SOURCEANDSINK
Port_812131 | SOURCEANDSINK
Port_812144 | SOURCEANDSINK
Port_812155 | SOURCEANDSINK
Port_812164 | SOURCEANDSINK
Port_812173 | SOURCEANDSINK
Port_812182 | SOURCEANDSINK
Port_812279 | SOURCEANDSINK
Port_812290 | SOURCEANDSINK
Port_812301 | SOURCEANDSINK
Port_812312 | SOURCEANDSINK
Port_812339 | SOURCEANDSINK
Port_812352 | SOURCEANDSINK
Port_814169 | SOURCEANDSINK
Port_814178 | SOURCEANDSINK
Port_814271 | SOURCEANDSINK
Port_814317 | SOURCEANDSINK
Port_814451 | SOURCEANDSINK
Port_814641 | SOURCEANDSINK
3 x Port_815746 | SOURCEANDSINK
Port_816759 | SOURCEANDSINK
3 x Port_830428 | SOURCEANDSINK
3 x Port_858697 | SOURCEANDSINK
Port_858968 | SOURCEANDSINK
Port_859038 | SOURCEANDSINK
3 x Port_860618 | SOURCEANDSINK
Port_861460 | SOURCE
Port_861462 | SOURCEANDSINK
Port_861464 | SOURCEANDSINK
3 x Port_861748 | SOURCEANDSINK
Port_864135 | SOURCEANDSINK
Port_865499 | SOURCEANDSINK
Port_865773 | SOURCEANDSINK
Port_865774 | SOURCEANDSINK
Port_865848 | SOURCEANDSINK
3 x Port_866267 | SOURCEANDSINK
Port_866268 | SOURCEANDSINK
Port_866269 | SOURCEANDSINK
Port_866270 | SOURCEANDSINK
Port_867218 | SOURCEANDSINK
Port_867305 | SOURCEANDSINK
Port_867546 | SOURCEANDSINK
Port_867758 | SOURCEANDSINK
Port_867921 | SOURCEANDSINK
Port_868457 | SOURCEANDSINK
Port_868578 | SOURCEANDSINK
Port_868784 | SOURCEANDSINK
Port_868871 | SOURCEANDSINK
Port_869069 | SOURCEANDSINK
Port_869119 | SOURCEANDSINK
Port_869190 | SOURCEANDSINK
Port_869333 | SOURCEANDSINK
Port_869537 | SOURCEANDSINK
Port_869538 | SOURCEANDSINK
Port_869660 | SOURCEANDSINK
Port_869720 | SOURCEANDSINK
Port_869798 | SOURCEANDSINK
Port_869931 | SOURCEANDSINK
Port_870044 | SOURCEANDSINK
Port_870197 | SOURCEANDSINK
Port_870256 | SOURCEANDSINK
Port_870315 | SOURCEANDSINK
Port_870510 | SOURCEANDSINK
Port_870833 | SOURCEANDSINK
Port_870992 | SOURCEANDSINK
Port_871149 | SOURCEANDSINK
Port_871250 | SOURCEANDSINK
Port_871397 | SOURCEANDSINK
Port_871592 | SOURCEANDSINK
Port_871745 | SOURCEANDSINK
Port_871862 | SOURCEANDSINK
Port_871923 | SOURCEANDSINK
Port_872041 | SOURCEANDSINK
Port_872078 | SOURCEANDSINK
Port_872083 | SOURCEANDSINK
Port_872260 | SOURCEANDSINK
Port_872417 | SOURCEANDSINK
Port_872596 | SOURCEANDSINK
Port_872805 | SOURCEANDSINK
Port_886054 | SOURCEANDSINK
Port_886590 | SOURCEANDSINK
Port_886958 | SOURCEANDSINK
Port_887265 | SOURCEANDSINK
Port_887408 | SOURCEANDSINK
2 x Port_887795 | SOURCEANDSINK
Port_888019 | SOURCEANDSINK
Port_888330 | SOURCEANDSINK
Port_888822 | SOURCEANDSINK
Port_889000 | SOURCEANDSINK
Port_889216 | SOURCEANDSINK
Port_889325 | SOURCEANDSINK
Port_889460 | SOURCEANDSINK
Port_889648 | SOURCEANDSINK
Port_889931 | SOURCEANDSINK
Port_889970 | SOURCEANDSINK
Port_890131 | SOURCEANDSINK
Port_890224 | SOURCEANDSINK
Port_890736 | SOURCEANDSINK
Port_890827 | SOURCEANDSINK
2 x Port_890849 | SOURCEANDSINK
Port_890876 | SOURCEANDSINK
Port_890900 | SOURCEANDSINK
Port_890905 | SOURCEANDSINK
Port_890910 | SOURCEANDSINK
Port_891007 | SOURCEANDSINK
Port_891034 | SOURCEANDSINK
Port_891039 | SOURCEANDSINK
Port_891044 | SOURCEANDSINK
3 x Port_891158 | SOURCEANDSINK
Port_891366 | SOURCEANDSINK
Port_891427 | SOURCEANDSINK
Port_891445 | SOURCEANDSINK
Port_891597 | SOURCEANDSINK
Port_891655 | SOURCEANDSINK
Port_891718 | SOURCEANDSINK
Port_891823 | SOURCEANDSINK
Port_892028 | SOURCEANDSINK
Port_892280 | SOURCEANDSINK
Port_892480 | SOURCEANDSINK
Port_892745 | SOURCEANDSINK
Port_892864 | SOURCEANDSINK
Port_893003 | SOURCEANDSINK
Port_893293 | SOURCEANDSINK
Port_893298 | SOURCEANDSINK
Port_893303 | SOURCEANDSINK
Port_893420 | SOURCEANDSINK
Port_893612 | SOURCEANDSINK
Port_893645 | SOURCEANDSINK
Port_893688 | SOURCEANDSINK
Port_894067 | SOURCEANDSINK
Port_894226 | SOURCEANDSINK
Port_894344 | SOURCEANDSINK
Port_895631 | SOURCEANDSINK
Port_895656 | SOURCEANDSINK
Port_895661 | SOURCEANDSINK
Port_895666 | SOURCEANDSINK
Port_895758 | SOURCEANDSINK
Port_895847 | SOURCEANDSINK
Port_895852 | SOURCEANDSINK
Port_895966 | SOURCEANDSINK
Port_896065 | SOURCEANDSINK
Port_896391 | SOURCEANDSINK
Port_896758 | SOURCEANDSINK
Port_901696 | SOURCEANDSINK
Port_902056 | SOURCEANDSINK
Port_902223 | SOURCEANDSINK
Port_902443 | SOURCEANDSINK
Port_948415 | SOURCEANDSINK
Port_948416 | SOURCEANDSINK
Port_954901 | SOURCEANDSINK
Port_954902 | SOURCEANDSINK
Port_955305 | SOURCEANDSINK
Port_955306 | SOURCEANDSINK
Port_959558 | SOURCEANDSINK
Port_959559 | SOURCEANDSINK
Port_977167 | SOURCEANDSINK
Port_977168 | SOURCEANDSINK
Port_977197 | SOURCEANDSINK
Port_977198 | SOURCEANDSINK
Port_977379 | SOURCEANDSINK
Port_977380 | SOURCEANDSINK
Port_977382 | SOURCEANDSINK
Port_977383 | SOURCEANDSINK
Port_977502 | SOURCEANDSINK
Port_977585 | SOURCEANDSINK
Port_979473 | SOURCEANDSINK
Port_979626 | SOURCEANDSINK
Port_979883 | SOURCEANDSINK
Port_980093 | SOURCEANDSINK
Port_980229 | SOURCEANDSINK
Port_1005158 | SOURCEANDSINK
Port_1005191 | SOURCEANDSINK
Port_1005212 | SOURCEANDSINK
Port_1005240 | SOURCEANDSINK
Port_1005363 | SOURCEANDSINK
Port_1005364 | SOURCEANDSINK
Port_1005522 | SOURCEANDSINK
Port_1005523 | SOURCEANDSINK
Port_1005524 | SOURCEANDSINK
Port_1005525 | SOURCEANDSINK
Port_1005530 | SOURCEANDSINK
Port_1005531 | SOURCEANDSINK
Port_1005581 | SOURCEANDSINK
Port_1005582 | SOURCEANDSINK
Port_1005583 | SOURCEANDSINK
Port_1005584 | SOURCEANDSINK
Port_1005589 | SOURCEANDSINK
Port_1005590 | SOURCEANDSINK
Port_1005661 | SOURCEANDSINK
Port_1005662 | SOURCEANDSINK
Port_1005663 | SOURCEANDSINK
Port_1005664 | SOURCEANDSINK
Port_1005668 | SOURCEANDSINK
Port_1005669 | SOURCEANDSINK
Port_1014412 | SOURCEANDSINK
Port_1014427 | SOURCEANDSINK
Port_1014432 | SOURCEANDSINK
Port_1014565 | SOURCEANDSINK
Port_1014566 | SOURCEANDSINK
Port_1014672 | SOURCEANDSINK
Port_1014701 | SOURCEANDSINK
Port_1014748 | SOURCEANDSINK
Port_1014753 | SOURCEANDSINK
Port_1014774 | SOURCEANDSINK
Port_1014779 | SOURCEANDSINK
Port_1014784 | SOURCEANDSINK
Port_1026179 | SOURCEANDSINK
Port_1026183 | SOURCEANDSINK
Port_1026187 | SOURCEANDSINK
Port_1026427 | SOURCEANDSINK
Port_1026483 | SOURCEANDSINK
Port_1026487 | SOURCEANDSINK
Port_1026619 | SOURCEANDSINK
Port_1026623 | SOURCEANDSINK
Port_1026627 | SOURCEANDSINK
Port_1026631 | SOURCEANDSINK
Port_1026635 | SOURCEANDSINK
Port_1026639 | SOURCEANDSINK
Port_1026790 | SOURCEANDSINK
Port_1026791 | SOURCEANDSINK
Port_1026799 | SOURCEANDSINK
Port_1026800 | SOURCEANDSINK
Port_1026872 | SOURCEANDSINK
Port_1026876 | SOURCEANDSINK
Port_1026965 | SOURCEANDSINK
Port_1027057 | SOURCEANDSINK
Port_1027058 | SOURCEANDSINK
Port_1027059 | SOURCEANDSINK
Port_1027060 | SOURCEANDSINK
Port_1027061 | SOURCEANDSINK
Port_1027062 | SOURCEANDSINK
Port_1027063 | SOURCEANDSINK
Port_1027064 | SOURCEANDSINK
Port_1027065 | SOURCEANDSINK
Port_1027066 | SOURCEANDSINK
Port_1027067 | SOURCEANDSINK
Port_1027068 | SOURCEANDSINK
Port_1027069 | SOURCEANDSINK
Port_1027070 | SOURCEANDSINK
Port_1027071 | SOURCEANDSINK
Port_1027072 | SOURCEANDSINK
Port_1027073 | SOURCEANDSINK
Port_1027074 | SOURCEANDSINK
Port_1027075 | SOURCEANDSINK
Port_1027076 | SOURCEANDSINK
Port_1027081 | SOURCEANDSINK
Port_1027082 | SOURCEANDSINK
Port_1027087 | SOURCEANDSINK
Port_1027088 | SOURCEANDSINK
Port_1027089 | SOURCEANDSINK
Port_1027090 | SOURCEANDSINK
Port_1027091 | SOURCEANDSINK
Port_1027092 | SOURCEANDSINK
Port_1027095 | SOURCEANDSINK
Port_1027096 | SOURCEANDSINK
Port_1027097 | SOURCEANDSINK
Port_1027098 | SOURCEANDSINK
Port_1027099 | SOURCEANDSINK
Port_1027100 | SOURCEANDSINK
Port_1027432 | SOURCEANDSINK
Port_1027433 | SOURCEANDSINK
Port_1027471 | SOURCEANDSINK
Port_1027472 | SOURCEANDSINK
Port_1027484 | SOURCEANDSINK
Port_1027485 | SOURCEANDSINK
Port_1027536 | SOURCEANDSINK
Port_1027537 | SOURCEANDSINK
Port_1027547 | SOURCEANDSINK
Port_1027548 | SOURCEANDSINK
Port_1027896 | SOURCEANDSINK
Port_1028058 | SOURCEANDSINK
Port_1028067 | SOURCEANDSINK
Port_1028102 | SOURCEANDSINK
Port_1028263 | SOURCEANDSINK
Port_1028566 | SOURCEANDSINK
Port_1028670 | SOURCEANDSINK
Port_1028671 | SOURCEANDSINK
Port_1043430 | SOURCEANDSINK
Port_1043431 | SOURCEANDSINK
Port_1043434 | SOURCEANDSINK
Port_1043435 | SOURCEANDSINK
Port_1043436 | SOURCEANDSINK
Port_1043441 | SOURCEANDSINK
Port_1043548 | SOURCEANDSINK
Port_1043610 | SOURCEANDSINK
Port_1043685 | SOURCEANDSINK
Port_1043686 | SOURCEANDSINK
Port_1043736 | SOURCEANDSINK
Port_1043737 | SOURCEANDSINK
Port_1043740 | SOURCEANDSINK
Port_1043741 | SOURCEANDSINK
Port_1043797 | SOURCEANDSINK
Port_1043798 | SOURCEANDSINK
Port_1043801 | SOURCEANDSINK
Port_1043802 | SOURCEANDSINK
Port_1043830 | SOURCEANDSINK
Port_1043831 | SOURCEANDSINK
Port_1043936 | SOURCEANDSINK
Port_1043937 | SOURCEANDSINK
Port_1044001 | SOURCEANDSINK
Port_1044002 | SOURCEANDSINK
Port_1044006 | SOURCEANDSINK
Port_1044141 | SOURCEANDSINK
Port_1044180 | SOURCEANDSINK
Port_1044181 | SOURCEANDSINK
Port_1044184 | SOURCEANDSINK
Port_1044185 | SOURCEANDSINK
Port_1044195 | SOURCEANDSINK
Port_1044196 | SOURCEANDSINK
Port_1044199 | SOURCEANDSINK
Port_1044200 | SOURCEANDSINK
Port_1044219 | SOURCEANDSINK
Port_1044220 | SOURCEANDSINK
Port_1044239 | SOURCEANDSINK
Port_1044240 | SOURCEANDSINK
Port_1044285 | SOURCEANDSINK
Port_1044290 | SOURCEANDSINK
Port_1044305 | SOURCEANDSINK
Port_1044310 | SOURCEANDSINK
Port_1044315 | SOURCEANDSINK
Port_1044325 | SOURCEANDSINK
Port_1044362 | SOURCEANDSINK
Port_1044363 | SOURCEANDSINK
Port_1044364 | SOURCEANDSINK
Port_1044365 | SOURCEANDSINK
Port_1044377 | SOURCEANDSINK
Port_1044378 | SOURCEANDSINK
Port_1044379 | SOURCEANDSINK
Port_1044380 | SOURCEANDSINK
Port_1044489 | SOURCEANDSINK
Port_1044490 | SOURCEANDSINK
Port_1044491 | SOURCEANDSINK
Port_1044492 | SOURCEANDSINK
Port_1044650 | SOURCEANDSINK
Port_1044651 | SOURCEANDSINK
Port_1044659 | SOURCEANDSINK
Port_1044660 | SOURCEANDSINK
Port_1044662 | SOURCEANDSINK
Port_1044663 | SOURCEANDSINK
Port_1044846 | SOURCEANDSINK
Port_1045003 | SOURCEANDSINK
Port_1045191 | SOURCEANDSINK
Port_1045270 | SOURCEANDSINK
Port_1045408 | SOURCEANDSINK
Port_1045409 | SOURCEANDSINK
Port_1045469 | SOURCEANDSINK
Port_1045470 | SOURCEANDSINK
Port_1045588 | SOURCEANDSINK
Port_1045589 | SOURCEANDSINK
Port_1045693 | SOURCEANDSINK
Port_1045694 | SOURCEANDSINK
Port_1045703 | SOURCEANDSINK
Port_1045704 | SOURCEANDSINK
Port_1045705 | SOURCEANDSINK
Port_1045706 | SOURCEANDSINK
Port_1045735 | SOURCEANDSINK
Port_1045736 | SOURCEANDSINK
Port_1045737 | SOURCEANDSINK
Port_1045738 | SOURCEANDSINK
Port_1045747 | SOURCEANDSINK
Port_1045748 | SOURCEANDSINK
Port_1045749 | SOURCEANDSINK
Port_1045750 | SOURCEANDSINK
Port_1045812 | SOURCEANDSINK
Port_1045813 | SOURCEANDSINK
Port_1045814 | SOURCEANDSINK
Port_1045815 | SOURCEANDSINK
Port_1045826 | SOURCEANDSINK
Port_1045851 | SOURCEANDSINK
Port_1045872 | SOURCEANDSINK
Port_1045873 | SOURCEANDSINK
Port_1045909 | SOURCEANDSINK
Port_1045910 | SOURCEANDSINK
Port_1047890 | SOURCEANDSINK
Port_1047891 | SOURCEANDSINK
Port_1047892 | SOURCEANDSINK
Port_1047893 | SOURCEANDSINK
Port_1049003 | SOURCEANDSINK
Port_1049028 | SOURCEANDSINK
Port_1049033 | SOURCEANDSINK
Port_1049074 | SOURCEANDSINK
Port_1049075 | SOURCEANDSINK
Port_1049250 | SOURCEANDSINK
Port_1051918 | SOURCEANDSINK
Port_1051973 | SOURCEANDSINK
Port_1051978 | SOURCEANDSINK
Port_1051983 | SOURCEANDSINK
Port_1051988 | SOURCEANDSINK
Port_1051993 | SOURCEANDSINK
Port_1051998 | SOURCEANDSINK
Port_1052003 | SOURCEANDSINK
Port_1052022 | SOURCEANDSINK
Port_1052390 | SOURCEANDSINK
Port_1052429 | SOURCEANDSINK
Port_1052435 | SOURCEANDSINK
Port_1052436 | SOURCEANDSINK
Port_1052437 | SOURCEANDSINK
Port_1052438 | SOURCEANDSINK
Port_1052439 | SOURCEANDSINK
Port_1052440 | SOURCEANDSINK
Port_1052441 | SOURCEANDSINK
Port_1052442 | SOURCEANDSINK
Port_1052498 | SOURCEANDSINK
Port_1052499 | SOURCEANDSINK
Port_1052566 | SOURCEANDSINK
Port_1052567 | SOURCEANDSINK
Port_1052577 | SOURCEANDSINK
Port_1052578 | SOURCEANDSINK
Port_1052611 | SOURCEANDSINK
Port_1052804 | SOURCEANDSINK
Port_1052841 | SOURCEANDSINK
Port_1058992 | SOURCEANDSINK
Port_1059084 | SOURCEANDSINK
Port_1059119 | SOURCEANDSINK
Port_1059120 | SOURCEANDSINK
Port_1059130 | SOURCEANDSINK
Port_1059131 | SOURCEANDSINK
Port_1059143 | SOURCEANDSINK
Port_1059144 | SOURCEANDSINK
Port_1059162 | SOURCEANDSINK
Port_1059163 | SOURCEANDSINK
Port_1059187 | SOURCEANDSINK
Port_1059188 | SOURCEANDSINK
Port_1059198 | SOURCEANDSINK
Port_1059207 | SOURCEANDSINK
Port_1059230 | SOURCEANDSINK
Port_1059231 | SOURCEANDSINK
Port_1059243 | SOURCEANDSINK
Port_1059244 | SOURCEANDSINK
Port_1059256 | SOURCEANDSINK
Port_1059257 | SOURCEANDSINK
Port_1059606 | SOURCEANDSINK
Port_1059607 | SOURCEANDSINK
Port_1059608 | SOURCEANDSINK
Port_1059609 | SOURCEANDSINK
Port_1059610 | SOURCEANDSINK
Port_1059611 | SOURCEANDSINK
Port_1059612 | SOURCEANDSINK
Port_1059613 | SOURCEANDSINK
Port_1059614 | SOURCEANDSINK
Port_1059615 | SOURCEANDSINK
Port_1059616 | SOURCEANDSINK
Port_1059617 | SOURCEANDSINK
Port_1059618 | SOURCEANDSINK
Port_1059619 | SOURCEANDSINK
Port_1059620 | SOURCEANDSINK
Port_1059621 | SOURCEANDSINK
Port_1059622 | SOURCEANDSINK
Port_1059623 | SOURCEANDSINK
Port_1059624 | SOURCEANDSINK
Port_1059625 | SOURCEANDSINK
Port_1060095 | SOURCEANDSINK
Port_1060100 | SOURCEANDSINK
Port_1060114 | SOURCEANDSINK
Port_1060124 | SOURCEANDSINK
Port_1060156 | SOURCEANDSINK
Port_1060157 | SOURCEANDSINK
Port_1060167 | SOURCEANDSINK
Port_1060168 | SOURCEANDSINK
Port_1060178 | SOURCEANDSINK
Port_1060179 | SOURCEANDSINK
Port_1060228 | SOURCEANDSINK
Port_1060229 | SOURCEANDSINK
Port_1060249 | SOURCEANDSINK
Port_1060250 | SOURCEANDSINK
Port_1060264 | SOURCEANDSINK
Port_1060265 | SOURCEANDSINK
Port_1060275 | SOURCEANDSINK
Port_1060276 | SOURCEANDSINK
Port_1060295 | SOURCEANDSINK
Port_1060318 | SOURCEANDSINK
Port_1060566 | SOURCEANDSINK
Port_1060829 | SOURCEANDSINK
Port_1060899 | SOURCEANDSINK
Port_1061025 | SOURCEANDSINK
Port_1061163 | SOURCEANDSINK
Port_1061490 | SOURCEANDSINK
Port_1061571 | SOURCEANDSINK
Port_1061572 | SOURCEANDSINK
Port_1061576 | SOURCEANDSINK
Port_1061577 | SOURCEANDSINK
Port_1061601 | SOURCEANDSINK
Port_1061606 | SOURCEANDSINK
Port_1061613 | SOURCEANDSINK
Port_1061614 | SOURCEANDSINK
Port_1061617 | SOURCEANDSINK
Port_1061618 | SOURCEANDSINK
Port_1061640 | SOURCEANDSINK
Port_1061641 | SOURCEANDSINK
Port_1061653 | SOURCEANDSINK
Port_1061658 | SOURCEANDSINK
Port_1061673 | SOURCEANDSINK
Port_1061674 | SOURCEANDSINK
Port_1061699 | SOURCEANDSINK
Port_1061700 | SOURCEANDSINK
Port_1061717 | SOURCEANDSINK
Port_1061718 | SOURCEANDSINK
Port_1061719 | SOURCEANDSINK
Port_1061720 | SOURCEANDSINK
Port_1061733 | SOURCEANDSINK
Port_1061754 | SOURCEANDSINK
Port_1061759 | SOURCEANDSINK
Port_1061768 | SOURCEANDSINK
Port_1061984 | SOURCEANDSINK
Port_1061989 | SOURCEANDSINK
Port_1061994 | SOURCEANDSINK
Port_1062010 | SOURCEANDSINK
Port_1062011 | SOURCEANDSINK
Port_1062012 | SOURCEANDSINK
Port_1062013 | SOURCEANDSINK
Port_1062014 | SOURCEANDSINK
Port_1062015 | SOURCEANDSINK
Port_1062016 | SOURCEANDSINK
Port_1062017 | SOURCEANDSINK
Port_1062084 | SOURCEANDSINK
Port_1062085 | SOURCEANDSINK
Port_1062096 | SOURCEANDSINK
Port_1062097 | SOURCEANDSINK
Port_1062141 | SOURCEANDSINK
Port_1062142 | SOURCEANDSINK
Port_1062145 | SOURCEANDSINK
Port_1062146 | SOURCEANDSINK
Port_1062147 | SOURCEANDSINK
Port_1062148 | SOURCEANDSINK
Port_1062157 | SOURCEANDSINK
Port_1062158 | SOURCEANDSINK
Port_1062247 | SOURCEANDSINK
Port_1062248 | SOURCEANDSINK
Port_1062249 | SOURCEANDSINK
Port_1062250 | SOURCEANDSINK
Port_1062278 | SOURCEANDSINK
Port_1062279 | SOURCEANDSINK
Port_1062294 | SOURCEANDSINK
Port_1062295 | SOURCEANDSINK
Port_1062298 | SOURCEANDSINK
Port_1062299 | SOURCEANDSINK
Port_1062300 | SOURCEANDSINK
Port_1062301 | SOURCEANDSINK
Port_1068972 | SOURCEANDSINK
Port_1068973 | SOURCEANDSINK
Port_1069000 | SOURCEANDSINK
Port_1069026 | SOURCEANDSINK
Port_1069425 | SOURCEANDSINK
Port_1069791 | SOURCEANDSINK
Port_1069809 | SOURCEANDSINK
Port_1069918 | SOURCEANDSINK
Port_1070195 | SOURCEANDSINK
Port_1070264 | SOURCEANDSINK
Port_1070273 | SOURCEANDSINK
Port_1070327 | SOURCEANDSINK
Port_1070519 | SOURCEANDSINK
Port_1070520 | SOURCEANDSINK
Port_1070731 | SOURCEANDSINK
Port_1070732 | SOURCEANDSINK
Port_1070735 | SOURCEANDSINK
Port_1070736 | SOURCEANDSINK
Port_1070782 | SOURCEANDSINK
Port_1070783 | SOURCEANDSINK
Port_1070786 | SOURCEANDSINK
Port_1070787 | SOURCEANDSINK
Port_1070799 | SOURCEANDSINK
Port_1070800 | SOURCEANDSINK
Port_1070803 | SOURCEANDSINK
Port_1070804 | SOURCEANDSINK
Port_1070866 | SOURCEANDSINK
Port_1070867 | SOURCEANDSINK
Port_1070868 | SOURCEANDSINK
Port_1070878 | SOURCEANDSINK
Port_1070879 | SOURCEANDSINK
Port_1070880 | SOURCEANDSINK
Port_1070945 | SOURCEANDSINK
Port_1070946 | SOURCEANDSINK
Port_1070947 | SOURCEANDSINK
Port_1071012 | SOURCEANDSINK
Port_1071013 | SOURCEANDSINK
Port_1071014 | SOURCEANDSINK
Port_1071015 | SOURCEANDSINK
Port_1071016 | SOURCEANDSINK
Port_1071017 | SOURCEANDSINK
Port_1071081 | SOURCEANDSINK
Port_1071082 | SOURCEANDSINK
Port_1071083 | SOURCEANDSINK
Port_1071084 | SOURCEANDSINK
Port_1071085 | SOURCEANDSINK
Port_1071086 | SOURCEANDSINK
Port_1071088 | SOURCEANDSINK
Port_1071089 | SOURCEANDSINK
Port_1071090 | SOURCEANDSINK
Port_1071091 | SOURCEANDSINK
Port_1073569 | SOURCEANDSINK
Port_1073584 | SOURCEANDSINK
Port_1073621 | SOURCEANDSINK
Port_1073788 | SOURCEANDSINK
Port_1073823 | SOURCEANDSINK
Port_1075167 | SOURCEANDSINK
Port_1075461 | SOURCEANDSINK
Port_1076072 | SOURCEANDSINK
Port_1076221 | SOURCEANDSINK
Port_1076530 | SOURCEANDSINK
Port_1076994 | SOURCEANDSINK
Port_1078334 | SOURCEANDSINK
Port_1078388 | SOURCEANDSINK
Port_1078400 | SOURCEANDSINK
Port_1079056 | SOURCEANDSINK
Port_1079057 | SOURCEANDSINK
Port_1079077 | SOURCEANDSINK
Port_1079078 | SOURCEANDSINK
Port_1079637 | SOURCEANDSINK
Port_1079642 | SOURCEANDSINK
Port_1080025 | SOURCEANDSINK
3 x Port_1085186 | SOURCEANDSINK
Port_1085188 | SOURCEANDSINK
Port_1085189 | SOURCEANDSINK
Port_1085190 | SOURCEANDSINK
Port_1085775 | SOURCEANDSINK
Port_1086327 | SOURCEANDSINK
Port_1086328 | SOURCEANDSINK
Port_1086329 | SOURCEANDSINK
Port_1086330 | SOURCEANDSINK
Port_1086331 | SOURCEANDSINK
Port_1086332 | SOURCEANDSINK
Port_1086333 | SOURCEANDSINK
Port_1086334 | SOURCEANDSINK
Port_1086335 | SOURCEANDSINK
Port_1086336 | SOURCEANDSINK
Port_1086337 | SOURCEANDSINK
Port_1086338 | SOURCEANDSINK
Port_1086339 | SOURCEANDSINK
Port_1086340 | SOURCEANDSINK
Port_1086341 | SOURCEANDSINK
Port_1086342 | SOURCEANDSINK
Port_1086343 | SOURCEANDSINK
Port_1086344 | SOURCEANDSINK
Port_1086345 | SOURCEANDSINK
Port_1086346 | SOURCEANDSINK
Port_1086347 | SOURCEANDSINK
Port_1086348 | SOURCEANDSINK
Port_1086349 | SOURCEANDSINK
Port_1086350 | SOURCEANDSINK
Port_1086414 | SOURCEANDSINK
Port_1086423 | SOURCEANDSINK
Port_1086448 | SOURCEANDSINK
Port_1086449 | SOURCEANDSINK
Port_1086466 | SOURCEANDSINK
Port_1086467 | SOURCEANDSINK
Port_1086468 | SOURCEANDSINK
Port_1086469 | SOURCEANDSINK
Port_1086477 | SOURCEANDSINK
Port_1086478 | SOURCEANDSINK
Port_1086479 | SOURCEANDSINK
Port_1086480 | SOURCEANDSINK
Port_1086496 | SOURCEANDSINK
Port_1087933 | SOURCEANDSINK
Port_1087943 | SOURCEANDSINK
Port_1087951 | SOURCEANDSINK
Port_1095448 | SOURCEANDSINK
Port_1095453 | SOURCEANDSINK
Port_1095458 | SOURCEANDSINK
Port_1095463 | SOURCEANDSINK
Port_1095468 | SOURCEANDSINK
Port_1095473 | SOURCEANDSINK
Port_1095486 | SOURCEANDSINK
Port_1095490 | SOURCEANDSINK
Port_1095494 | SOURCEANDSINK
Port_1095795 | SOURCEANDSINK
Port_1095800 | SOURCEANDSINK
Port_1096045 | SOURCEANDSINK
Port_1096054 | SOURCEANDSINK
Port_1096088 | SOURCEANDSINK
Port_1096111 | SOURCEANDSINK
Port_1096112 | SOURCEANDSINK
Port_1097504 | SOURCEANDSINK
Port_1097596 | SOURCEANDSINK
Port_1097622 | SOURCEANDSINK
Port_1097711 | SOURCEANDSINK
Port_1097798 | SOURCEANDSINK
Port_1099175 | SOURCEANDSINK
Port_1099273 | SOURCEANDSINK
Port_1099546 | SOURCEANDSINK
Port_1099617 | SOURCEANDSINK
Port_1100428 | SOURCEANDSINK
Port_1100429 | SOURCEANDSINK
Port_1100430 | SOURCEANDSINK
Port_1100435 | SOURCEANDSINK
Port_1100442 | SOURCEANDSINK
Port_1100646 | SOURCEANDSINK
Port_1100647 | SOURCEANDSINK
Port_1100756 | SOURCEANDSINK
Port_1103436 | SOURCEANDSINK
Port_1103640 | SOURCEANDSINK
Port_1103724 | SOURCEANDSINK
Port_1103762 | SOURCE
3 x Port_1103764 | SOURCEANDSINK
Port_1103765 | SOURCEANDSINK
Port_1105163 | SOURCEANDSINK
Port_1107284 | SOURCEANDSINK
Port_1107288 | SOURCEANDSINK
Port_1107289 | SOURCEANDSINK
Port_1107320 | SOURCEANDSINK
Port_1107321 | SOURCEANDSINK
Port_1107530 | SOURCEANDSINK
Port_1107534 | SOURCEANDSINK
Port_1107535 | SOURCEANDSINK
Port_1107540 | SOURCEANDSINK
Port_1107541 | SOURCEANDSINK
Port_1113432 | SOURCEANDSINK
Port_1117162 | SOURCEANDSINK
Port_1117163 | SOURCEANDSINK
Port_1118695 | SOURCEANDSINK
Port_1153944 | SOURCEANDSINK
Port_1153945 | SOURCEANDSINK
Port_1154101 | SOURCEANDSINK
Port_1154317 | SOURCEANDSINK
Port_1154393 | SOURCEANDSINK
Port_1154479 | SOURCEANDSINK
Port_1154575 | SOURCEANDSINK
Port_1154610 | SOURCEANDSINK
Port_1154793 | SOURCEANDSINK
Port_1154900 | SOURCEANDSINK
Port_1155045 | SOURCEANDSINK
Port_1155139 | SOURCEANDSINK
Port_1155210 | SOURCEANDSINK
Port_1155357 | SOURCEANDSINK
Port_1155740 | SOURCEANDSINK
Port_1155741 | SOURCEANDSINK
Port_1155785 | SOURCEANDSINK
Port_1155823 | SOURCEANDSINK
Port_1155857 | SOURCEANDSINK
Port_1155948 | SOURCEANDSINK
Port_1155956 | SOURCEANDSINK
Port_1156044 | SOURCEANDSINK
Port_1156187 | SOURCEANDSINK
Port_1156293 | SOURCEANDSINK
Port_1156334 | SOURCEANDSINK
Port_1156382 | SOURCEANDSINK
Port_1156501 | SOURCEANDSINK
Port_1156566 | SOURCEANDSINK
Port_1156626 | SOURCEANDSINK
Port_1156627 | SOURCEANDSINK
Port_1156678 | SOURCEANDSINK
Port_1156758 | SOURCEANDSINK
Port_1156759 | SOURCEANDSINK
Port_1158205 | SOURCEANDSINK
Port_1158206 | SOURCEANDSINK
Port_1158215 | SOURCEANDSINK
Port_1158216 | SOURCEANDSINK
Port_1158234 | SOURCEANDSINK
Port_1158235 | SOURCEANDSINK
Port_1158241 | SOURCEANDSINK
Port_1158242 | SOURCEANDSINK
Port_1158260 | SOURCEANDSINK
Port_1158261 | SOURCEANDSINK
Port_1158263 | SOURCEANDSINK
Port_1158264 | SOURCEANDSINK
Port_1158284 | SOURCEANDSINK
Port_1158285 | SOURCEANDSINK
Port_1158287 | SOURCEANDSINK
Port_1158288 | SOURCEANDSINK
Port_1158299 | SOURCEANDSINK
Port_1158300 | SOURCEANDSINK
Port_1158306 | SOURCEANDSINK
Port_1158307 | SOURCEANDSINK
Port_1158313 | SOURCEANDSINK
Port_1158314 | SOURCEANDSINK
Port_1158320 | SOURCEANDSINK
Port_1158321 | SOURCEANDSINK
Port_1158344 | SOURCEANDSINK
Port_1159740 | SOURCEANDSINK
Port_1159741 | SOURCEANDSINK
