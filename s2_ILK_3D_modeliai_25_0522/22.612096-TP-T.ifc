Properties of the parts of a building model (IFC2X3), part 4 of 5

# IfcFurnishingElement: Parametric wardrobe:600x1200 Spinta (2)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 600x1200 Spinta
Name (Parametric wardrobe:600x1200 Spinta:...)
865210
901838 | Material: <Unnamed>

# IfcFurnishingElement: Parametric wardrobe:600x1400 Spinta, Parametric wardrobe:600x1400 Spinta:865447
In: 2 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 600x1400 Spinta

# IfcFurnishingElement: Parametric wardrobe:600x400 Spinta palatai (3)
In: 2 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 600x400 Spinta palatai
Name (Parametric wardrobe:600x400 Spinta palatai:...) | Material
638442
638462 | <Unnamed>
638578 | <Unnamed>

# IfcFurnishingElement: Parametric wardrobe:600x600 Spinta (5)
In: 3 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 600x600 Spinta
Name (Parametric wardrobe:600x600 Spinta:...) | Material
572377
626255
626286 | <Unnamed>
626308 | <Unnamed>
626412 | <Unnamed>

# IfcFurnishingElement: Parametric wardrobe:600x900 Spinta 2 (3)
In: 2 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 600x900 Spinta 2
Name (Parametric wardrobe:600x900 Spinta 2:...) | Material
867036
868392 | <Unnamed>
868395 | <Unnamed>

# IfcFurnishingElement: Parametric wardrobe:900x400 V, Parametric wardrobe:900x400 V:698705
In: Level 1
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 900x400 V

# IfcFurnishingElement: Persirengimo spintelė dviguba:400x500 (415)
Type - Material: <Unnamed> (12)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 400x500
Name (Persirengimo spintelė dviguba:400x500:...) | In | Group | Material
547047 | Level 1 | Model Group:Array Group 11:547076
547079 | Level 1 | Model Group:Array Group 11:547080 | <Unnamed>
547110 | Level 1 | Model Group:Array Group 11:547111 | <Unnamed>
547113 | Level 1 | Model Group:Array Group 11:547114 | <Unnamed>
547116 | Level 1 | Model Group:Array Group 11:547117 | <Unnamed>
547119 | Level 1 | Model Group:Array Group 11:547120 | <Unnamed>
547122 | Level 1 | Model Group:Array Group 11:547123 | <Unnamed>
547125 | Level 1 | Model Group:Array Group 11:547126 | <Unnamed>
547128 | Level 1 | Model Group:Array Group 11:547129 | <Unnamed>
547131 | Level 1 | Model Group:Array Group 11:547132 | <Unnamed>
547134 | Level 1 | Model Group:Array Group 11:547135 | <Unnamed>
547137 | Level 1 | Model Group:Array Group 11:547138 | <Unnamed>
547140 | Level 1 | Model Group:Array Group 11:547141 | <Unnamed>
547143 | Level 1 | Model Group:Array Group 11:547144 | <Unnamed>
547146 | Level 1 | Model Group:Array Group 11:547147 | <Unnamed>
547149 | Level 1 | Model Group:Array Group 11:547150 | <Unnamed>
547152 | Level 1 | Model Group:Array Group 11:547153 | <Unnamed>
547155 | Level 1 | Model Group:Array Group 11:547156 | <Unnamed>
547158 | Level 1 | Model Group:Array Group 11:547159 | <Unnamed>
547161 | Level 1 | Model Group:Array Group 11:547162 | <Unnamed>
547164 | Level 1 | Model Group:Array Group 11:547165
547166 | Level 1 | Model Group:Array Group 11:547167 | <Unnamed>
547168 | Level 1 | Model Group:Array Group 11:547169 | <Unnamed>
547170 | Level 1 | Model Group:Array Group 11:547171 | <Unnamed>
547172 | Level 1 | Model Group:Array Group 11:547173 | <Unnamed>
547174 | Level 1 | Model Group:Array Group 11:547175 | <Unnamed>
547176 | Level 1 | Model Group:Array Group 11:547177 | <Unnamed>
547178 | Level 1 | Model Group:Array Group 11:547179 | <Unnamed>
547180 | Level 1 | Model Group:Array Group 11:547181 | <Unnamed>
547182 | Level 1 | Model Group:Array Group 11:547183 | <Unnamed>
547184 | Level 1 | Model Group:Array Group 11:547185 | <Unnamed>
547186 | Level 1 | Model Group:Array Group 11:547187 | <Unnamed>
547188 | Level 1 | Model Group:Array Group 11:547189 | <Unnamed>
547190 | Level 1 | Model Group:Array Group 11:547191 | <Unnamed>
547192 | Level 1 | Model Group:Array Group 11:547193 | <Unnamed>
547194 | Level 1 | Model Group:Array Group 11:547195 | <Unnamed>
547196 | Level 1 | Model Group:Array Group 11:547197 | <Unnamed>
547198 | Level 1 | Model Group:Array Group 11:547199 | <Unnamed>
547200 | Level 1 | Model Group:Array Group 11:547201 | <Unnamed>
547202 | Level 1 | Model Group:Array Group 11:547203 | <Unnamed>
547212 | Level 1 | Model Group:Array Group 11:547213 | <Unnamed>
547214 | Level 1 | Model Group:Array Group 11:547215 | <Unnamed>
547216 | Level 1 | Model Group:Array Group 11:547217 | <Unnamed>
547218 | Level 1 | Model Group:Array Group 11:547219 | <Unnamed>
547220 | Level 1 | Model Group:Array Group 11:547221 | <Unnamed>
547222 | Level 1 | Model Group:Array Group 11:547223 | <Unnamed>
547224 | Level 1 | Model Group:Array Group 11:547225 | <Unnamed>
547226 | Level 1 | Model Group:Array Group 11:547227 | <Unnamed>
547228 | Level 1 | Model Group:Array Group 11:547229 | <Unnamed>
547230 | Level 1 | Model Group:Array Group 11:547231 | <Unnamed>
547232 | Level 1 | Model Group:Array Group 11:547233 | <Unnamed>
547234 | Level 1 | Model Group:Array Group 11:547235 | <Unnamed>
547236 | Level 1 | Model Group:Array Group 11:547237 | <Unnamed>
547238 | Level 1 | Model Group:Array Group 11:547239 | <Unnamed>
547240 | Level 1 | Model Group:Array Group 11:547241 | <Unnamed>
547242 | Level 1 | Model Group:Array Group 11:547243 | <Unnamed>
547244 | Level 1 | Model Group:Array Group 11:547245 | <Unnamed>
547246 | Level 1 | Model Group:Array Group 11:547247 | <Unnamed>
547248 | Level 1 | Model Group:Array Group 11:547249 | <Unnamed>
547250 | Level 1 | Model Group:Array Group 11:547251 | <Unnamed>
547253 | Level 1 | Model Group:Array Group 11:547254 | <Unnamed>
547255 | Level 1 | Model Group:Array Group 11:547256 | <Unnamed>
547257 | Level 1 | Model Group:Array Group 11:547258 | <Unnamed>
547259 | Level 1 | Model Group:Array Group 11:547260 | <Unnamed>
547261 | Level 1 | Model Group:Array Group 11:547262 | <Unnamed>
547263 | Level 1 | Model Group:Array Group 11:547264 | <Unnamed>
547265 | Level 1 | Model Group:Array Group 11:547266 | <Unnamed>
547267 | Level 1 | Model Group:Array Group 11:547268 | <Unnamed>
547269 | Level 1 | Model Group:Array Group 11:547270 | <Unnamed>
547271 | Level 1 | Model Group:Array Group 11:547272 | <Unnamed>
547273 | Level 1 | Model Group:Array Group 11:547274 | <Unnamed>
547275 | Level 1 | Model Group:Array Group 11:547276 | <Unnamed>
547277 | Level 1 | Model Group:Array Group 11:547278 | <Unnamed>
547279 | Level 1 | Model Group:Array Group 11:547280 | <Unnamed>
547281 | Level 1 | Model Group:Array Group 11:547282 | <Unnamed>
547283 | Level 1 | Model Group:Array Group 11:547284 | <Unnamed>
547285 | Level 1 | Model Group:Array Group 11:547286 | <Unnamed>
547287 | Level 1 | Model Group:Array Group 11:547288 | <Unnamed>
547493 | Level 1 | Model Group:Array Group 11:547494 | <Unnamed>
547495 | Level 1 | Model Group:Array Group 11:547496 | <Unnamed>
547497 | Level 1 | Model Group:Array Group 11:547498 | <Unnamed>
547499 | Level 1 | Model Group:Array Group 11:547500 | <Unnamed>
547501 | Level 1 | Model Group:Array Group 11:547502 | <Unnamed>
547503 | Level 1 | Model Group:Array Group 11:547504 | <Unnamed>
547505 | Level 1 | Model Group:Array Group 11:547506 | <Unnamed>
547507 | Level 1 | Model Group:Array Group 11:547508 | <Unnamed>
547509 | Level 1 | Model Group:Array Group 11:547510 | <Unnamed>
547517 | Level 1 | Model Group:Array Group 11:547518 | <Unnamed>
547519 | Level 1 | Model Group:Array Group 11:547520 | <Unnamed>
547521 | Level 1 | Model Group:Array Group 11:547522 | <Unnamed>
547523 | Level 1 | Model Group:Array Group 11:547524 | <Unnamed>
547525 | Level 1 | Model Group:Array Group 11:547526 | <Unnamed>
547527 | Level 1 | Model Group:Array Group 11:547528 | <Unnamed>
547529 | Level 1 | Model Group:Array Group 11:547530 | <Unnamed>
547531 | Level 1 | Model Group:Array Group 11:547532 | <Unnamed>
547533 | Level 1 | Model Group:Array Group 11:547534 | <Unnamed>
547535 | Level 1 | Model Group:Array Group 11:547536 | <Unnamed>
547537 | Level 1 | Model Group:Array Group 11:547538 | <Unnamed>
547539 | Level 1 | Model Group:Array Group 11:547540 | <Unnamed>
547541 | Level 1 | Model Group:Array Group 11:547542 | <Unnamed>
547543 | Level 1 | Model Group:Array Group 11:547544 | <Unnamed>
547545 | Level 1 | Model Group:Array Group 11:547546 | <Unnamed>
547547 | Level 1 | Model Group:Array Group 11:547548 | <Unnamed>
547549 | Level 1 | Model Group:Array Group 11:547550 | <Unnamed>
547551 | Level 1 | Model Group:Array Group 11:547552 | <Unnamed>
547553 | Level 1 | Model Group:Array Group 11:547554 | <Unnamed>
547555 | Level 1 | Model Group:Array Group 11:547556 | <Unnamed>
547557 | Level 1 | Model Group:Array Group 11:547558 | <Unnamed>
547559 | Level 1 | Model Group:Array Group 11:547560 | <Unnamed>
547561 | Level 1 | Model Group:Array Group 11:547562 | <Unnamed>
547563 | Level 1 | Model Group:Array Group 11:547564 | <Unnamed>
547565 | Level 1 | Model Group:Array Group 11:547566 | <Unnamed>
547567 | Level 1 | Model Group:Array Group 11:547568 | <Unnamed>
547569 | Level 1 | Model Group:Array Group 11:547570 | <Unnamed>
547571 | Level 1 | Model Group:Array Group 11:547572 | <Unnamed>
547573 | Level 1 | Model Group:Array Group 11:547574 | <Unnamed>
547575 | Level 1 | Model Group:Array Group 11:547576 | <Unnamed>
547577 | Level 1 | Model Group:Array Group 11:547578 | <Unnamed>
547579 | Level 1 | Model Group:Array Group 11:547580 | <Unnamed>
547581 | Level 1 | Model Group:Array Group 11:547582 | <Unnamed>
547583 | Level 1 | Model Group:Array Group 11:547584 | <Unnamed>
547585 | Level 1 | Model Group:Array Group 11:547586 | <Unnamed>
547587 | Level 1 | Model Group:Array Group 11:547588 | <Unnamed>
547589 | Level 1 | Model Group:Array Group 11:547590 | <Unnamed>
547591 | Level 1 | Model Group:Array Group 11:547592 | <Unnamed>
547593 | Level 1 | Model Group:Array Group 11:547594 | <Unnamed>
547595 | Level 1 | Model Group:Array Group 11:547596 | <Unnamed>
547597 | Level 1 | Model Group:Array Group 11:547598 | <Unnamed>
547599 | Level 1 | Model Group:Array Group 11:547600 | <Unnamed>
547601 | Level 1 | Model Group:Array Group 11:547602 | <Unnamed>
547603 | Level 1 | Model Group:Array Group 11:547604 | <Unnamed>
547605 | Level 1 | Model Group:Array Group 11:547606 | <Unnamed>
547607 | Level 1 | Model Group:Array Group 11:547608 | <Unnamed>
547609 | Level 1 | Model Group:Array Group 11:547610 | <Unnamed>
547611 | Level 1 | Model Group:Array Group 11:547612 | <Unnamed>
547613 | Level 1 | Model Group:Array Group 11:547614 | <Unnamed>
547615 | Level 1 | Model Group:Array Group 11:547616 | <Unnamed>
547617 | Level 1 | Model Group:Array Group 11:547618 | <Unnamed>
547619 | Level 1 | Model Group:Array Group 11:547620 | <Unnamed>
547621 | Level 1 | Model Group:Array Group 11:547622 | <Unnamed>
547623 | Level 1 | Model Group:Array Group 11:547624 | <Unnamed>
547625 | Level 1 | Model Group:Array Group 11:547626 | <Unnamed>
547627 | Level 1 | Model Group:Array Group 11:547628 | <Unnamed>
547629 | Level 1 | Model Group:Array Group 11:547630 | <Unnamed>
547631 | Level 1 | Model Group:Array Group 11:547632 | <Unnamed>
547633 | Level 1 | Model Group:Array Group 11:547634 | <Unnamed>
547635 | Level 1 | Model Group:Array Group 11:547636 | <Unnamed>
547637 | Level 1 | Model Group:Array Group 11:547638 | <Unnamed>
547639 | Level 1 | Model Group:Array Group 11:547640 | <Unnamed>
547641 | Level 1 | Model Group:Array Group 11:547642 | <Unnamed>
547643 | Level 1 | Model Group:Array Group 11:547644 | <Unnamed>
547645 | Level 1 | Model Group:Array Group 11:547646 | <Unnamed>
547647 | Level 1 | Model Group:Array Group 11:547648 | <Unnamed>
547649 | Level 1 | Model Group:Array Group 11:547650 | <Unnamed>
547651 | Level 1 | Model Group:Array Group 11:547652 | <Unnamed>
547684 | Level 1 | Model Group:Array Group 11:547685 | <Unnamed>
547686 | Level 1 | Model Group:Array Group 11:547687 | <Unnamed>
547688 | Level 1 | Model Group:Array Group 11:547689 | <Unnamed>
547690 | Level 1 | Model Group:Array Group 11:547691 | <Unnamed>
547692 | Level 1 | Model Group:Array Group 11:547693 | <Unnamed>
547694 | Level 1 | Model Group:Array Group 11:547695 | <Unnamed>
547696 | Level 1 | Model Group:Array Group 11:547697 | <Unnamed>
547698 | Level 1 | Model Group:Array Group 11:547699 | <Unnamed>
547700 | Level 1 | Model Group:Array Group 11:547701 | <Unnamed>
547702 | Level 1 | Model Group:Array Group 11:547703 | <Unnamed>
547704 | Level 1 | Model Group:Array Group 11:547705 | <Unnamed>
547706 | Level 1 | Model Group:Array Group 11:547707 | <Unnamed>
547708 | Level 1 | Model Group:Array Group 11:547709 | <Unnamed>
547710 | Level 1 | Model Group:Array Group 11:547711 | <Unnamed>
547712 | Level 1 | Model Group:Array Group 11:547713 | <Unnamed>
547714 | Level 1 | Model Group:Array Group 11:547715 | <Unnamed>
547716 | Level 1 | Model Group:Array Group 11:547717 | <Unnamed>
547718 | Level 1 | Model Group:Array Group 11:547719 | <Unnamed>
547720 | Level 1 | Model Group:Array Group 11:547721 | <Unnamed>
547722 | Level 1 | Model Group:Array Group 11:547723 | <Unnamed>
547724 | Level 1 | Model Group:Array Group 11:547725 | <Unnamed>
547726 | Level 1 | Model Group:Array Group 11:547727 | <Unnamed>
547728 | Level 1 | Model Group:Array Group 11:547729 | <Unnamed>
547730 | Level 1 | Model Group:Array Group 11:547731 | <Unnamed>
547732 | Level 1 | Model Group:Array Group 11:547733 | <Unnamed>
547734 | Level 1 | Model Group:Array Group 11:547735 | <Unnamed>
547736 | Level 1 | Model Group:Array Group 11:547737 | <Unnamed>
547738 | Level 1 | Model Group:Array Group 11:547739 | <Unnamed>
547740 | Level 1 | Model Group:Array Group 11:547741 | <Unnamed>
547742 | Level 1 | Model Group:Array Group 11:547743 | <Unnamed>
547744 | Level 1 | Model Group:Array Group 11:547745 | <Unnamed>
547746 | Level 1 | Model Group:Array Group 11:547747 | <Unnamed>
547748 | Level 1 | Model Group:Array Group 11:547749 | <Unnamed>
547750 | Level 1 | Model Group:Array Group 11:547751 | <Unnamed>
547752 | Level 1 | Model Group:Array Group 11:547753 | <Unnamed>
547754 | Level 1 | Model Group:Array Group 11:547755 | <Unnamed>
547756 | Level 1 | Model Group:Array Group 11:547757 | <Unnamed>
547758 | Level 1 | Model Group:Array Group 11:547759 | <Unnamed>
547760 | Level 1 | Model Group:Array Group 11:547761 | <Unnamed>
547762 | Level 1 | Model Group:Array Group 11:547763 | <Unnamed>
547764 | Level 1 | Model Group:Array Group 11:547765 | <Unnamed>
547766 | Level 1 | Model Group:Array Group 11:547767 | <Unnamed>
547768 | Level 1 | Model Group:Array Group 11:547769 | <Unnamed>
547770 | Level 1 | Model Group:Array Group 11:547771 | <Unnamed>
547772 | Level 1 | Model Group:Array Group 11:547773 | <Unnamed>
547774 | Level 1 | Model Group:Array Group 11:547775 | <Unnamed>
547776 | Level 1 | Model Group:Array Group 11:547777 | <Unnamed>
547778 | Level 1 | Model Group:Array Group 11:547779 | <Unnamed>
547780 | Level 1 | Model Group:Array Group 11:547781 | <Unnamed>
547782 | Level 1 | Model Group:Array Group 11:547783 | <Unnamed>
547784 | Level 1 | Model Group:Array Group 11:547785 | <Unnamed>
547786 | Level 1 | Model Group:Array Group 11:547787 | <Unnamed>
547788 | Level 1 | Model Group:Array Group 11:547789 | <Unnamed>
547790 | Level 1 | Model Group:Array Group 11:547791 | <Unnamed>
547792 | Level 1 | Model Group:Array Group 11:547793 | <Unnamed>
547794 | Level 1 | Model Group:Array Group 11:547795 | <Unnamed>
547796 | Level 1 | Model Group:Array Group 11:547797 | <Unnamed>
547798 | Level 1 | Model Group:Array Group 11:547799 | <Unnamed>
547800 | Level 1 | Model Group:Array Group 11:547801 | <Unnamed>
547802 | Level 1 | Model Group:Array Group 11:547803 | <Unnamed>
547804 | Level 1 | Model Group:Array Group 11:547805 | <Unnamed>
547806 | Level 1 | Model Group:Array Group 11:547807 | <Unnamed>
547808 | Level 1 | Model Group:Array Group 11:547809 | <Unnamed>
547810 | Level 1 | Model Group:Array Group 11:547811 | <Unnamed>
547812 | Level 1 | Model Group:Array Group 11:547813 | <Unnamed>
547814 | Level 1 | Model Group:Array Group 11:547815 | <Unnamed>
547816 | Level 1 | Model Group:Array Group 11:547817 | <Unnamed>
547818 | Level 1 | Model Group:Array Group 11:547819 | <Unnamed>
547820 | Level 1 | Model Group:Array Group 11:547821 | <Unnamed>
547822 | Level 1 | Model Group:Array Group 11:547823 | <Unnamed>
547824 | Level 1 | Model Group:Array Group 11:547825 | <Unnamed>
547826 | Level 1 | Model Group:Array Group 11:547827 | <Unnamed>
547828 | Level 1 | Model Group:Array Group 11:547829 | <Unnamed>
547830 | Level 1 | Model Group:Array Group 11:547831 | <Unnamed>
547832 | Level 1 | Model Group:Array Group 11:547833 | <Unnamed>
547834 | Level 1 | Model Group:Array Group 11:547835 | <Unnamed>
547836 | Level 1 | Model Group:Array Group 11:547837 | <Unnamed>
547853 | Level 1 | Model Group:Array Group 11:547854 | <Unnamed>
547855 | Level 1 | Model Group:Array Group 11:547856 | <Unnamed>
547857 | Level 1 | Model Group:Array Group 11:547858 | <Unnamed>
547859 | Level 1 | Model Group:Array Group 11:547860 | <Unnamed>
547861 | Level 1 | Model Group:Array Group 11:547862 | <Unnamed>
547863 | Level 1 | Model Group:Array Group 11:547864 | <Unnamed>
547865 | Level 1 | Model Group:Array Group 11:547866 | <Unnamed>
547867 | Level 1 | Model Group:Array Group 11:547868 | <Unnamed>
547869 | Level 1 | Model Group:Array Group 11:547870 | <Unnamed>
547871 | Level 1 | Model Group:Array Group 11:547872 | <Unnamed>
547873 | Level 1 | Model Group:Array Group 11:547874 | <Unnamed>
547875 | Level 1 | Model Group:Array Group 11:547876 | <Unnamed>
547877 | Level 1 | Model Group:Array Group 11:547878 | <Unnamed>
547879 | Level 1 | Model Group:Array Group 11:547880 | <Unnamed>
547881 | Level 1 | Model Group:Array Group 11:547882 | <Unnamed>
547883 | Level 1 | Model Group:Array Group 11:547884 | <Unnamed>
547885 | Level 1 | Model Group:Array Group 11:547886 | <Unnamed>
547887 | Level 1 | Model Group:Array Group 11:547888 | <Unnamed>
547889 | Level 1 | Model Group:Array Group 11:547890 | <Unnamed>
547891 | Level 1 | Model Group:Array Group 11:547892 | <Unnamed>
547893 | Level 1 | Model Group:Array Group 11:547894 | <Unnamed>
547895 | Level 1 | Model Group:Array Group 11:547896 | <Unnamed>
547897 | Level 1 | Model Group:Array Group 11:547898 | <Unnamed>
547899 | Level 1 | Model Group:Array Group 11:547900 | <Unnamed>
547901 | Level 1 | Model Group:Array Group 11:547902 | <Unnamed>
547903 | Level 1 | Model Group:Array Group 11:547904 | <Unnamed>
547905 | Level 1 | Model Group:Array Group 11:547906 | <Unnamed>
547907 | Level 1 | Model Group:Array Group 11:547908 | <Unnamed>
547909 | Level 1 | Model Group:Array Group 11:547910 | <Unnamed>
547911 | Level 1 | Model Group:Array Group 11:547912 | <Unnamed>
547913 | Level 1 | Model Group:Array Group 11:547914 | <Unnamed>
547915 | Level 1 | Model Group:Array Group 11:547916 | <Unnamed>
547917 | Level 1 | Model Group:Array Group 11:547918 | <Unnamed>
547919 | Level 1 | Model Group:Array Group 11:547920 | <Unnamed>
547921 | Level 1 | Model Group:Array Group 11:547922 | <Unnamed>
547923 | Level 1 | Model Group:Array Group 11:547924 | <Unnamed>
547925 | Level 1 | Model Group:Array Group 11:547926 | <Unnamed>
547927 | Level 1 | Model Group:Array Group 11:547928 | <Unnamed>
547929 | Level 1 | Model Group:Array Group 11:547930 | <Unnamed>
547931 | Level 1 | Model Group:Array Group 11:547932 | <Unnamed>
547933 | Level 1 | Model Group:Array Group 11:547934 | <Unnamed>
547935 | Level 1 | Model Group:Array Group 11:547936 | <Unnamed>
547937 | Level 1 | Model Group:Array Group 11:547938 | <Unnamed>
547939 | Level 1 | Model Group:Array Group 11:547940 | <Unnamed>
547941 | Level 1 | Model Group:Array Group 11:547942 | <Unnamed>
547943 | Level 1 | Model Group:Array Group 11:547944 | <Unnamed>
547945 | Level 1 | Model Group:Array Group 11:547946 | <Unnamed>
547947 | Level 1 | Model Group:Array Group 11:547948 | <Unnamed>
547949 | Level 1 | Model Group:Array Group 11:547950 | <Unnamed>
547951 | Level 1 | Model Group:Array Group 11:547952 | <Unnamed>
547953 | Level 1 | Model Group:Array Group 11:547954 | <Unnamed>
547955 | Level 1 | Model Group:Array Group 11:547956 | <Unnamed>
547957 | Level 1 | Model Group:Array Group 11:547958 | <Unnamed>
547959 | Level 1 | Model Group:Array Group 11:547960 | <Unnamed>
547961 | Level 1 | Model Group:Array Group 11:547962 | <Unnamed>
547963 | Level 1 | Model Group:Array Group 11:547964 | <Unnamed>
547965 | Level 1 | Model Group:Array Group 11:547966 | <Unnamed>
547967 | Level 1 | Model Group:Array Group 11:547968 | <Unnamed>
547969 | Level 1 | Model Group:Array Group 11:547970 | <Unnamed>
547971 | Level 1 | Model Group:Array Group 11:547972 | <Unnamed>
547973 | Level 1 |  | <Unnamed>
547975 | Level 1 | Model Group:Array Group 11:547976 | <Unnamed>
547977 | Level 1 | Model Group:Array Group 11:547978 | <Unnamed>
547979 | Level 1 | Model Group:Array Group 11:547980 | <Unnamed>
547981 | Level 1 | Model Group:Array Group 11:547982 | <Unnamed>
547983 | Level 1 | Model Group:Array Group 11:547984 | <Unnamed>
547985 | Level 1 | Model Group:Array Group 11:547986 | <Unnamed>
547987 | Level 1 | Model Group:Array Group 11:547988 | <Unnamed>
547989 | Level 1 | Model Group:Array Group 11:547990 | <Unnamed>
547991 | Level 1 | Model Group:Array Group 11:547992 | <Unnamed>
547993 | Level 1 | Model Group:Array Group 11:547994 | <Unnamed>
547995 | Level 1 | Model Group:Array Group 11:547996 | <Unnamed>
547997 | Level 1 | Model Group:Array Group 11:547998 | <Unnamed>
547999 | Level 1 | Model Group:Array Group 11:548000 | <Unnamed>
548001 | Level 1 | Model Group:Array Group 11:548002 | <Unnamed>
548003 | Level 1 | Model Group:Array Group 11:548004 | <Unnamed>
548005 | Level 1 | Model Group:Array Group 11:548006 | <Unnamed>
548007 | Level 1 | Model Group:Array Group 11:548008 | <Unnamed>
548009 | Level 1 | Model Group:Array Group 11:548010 | <Unnamed>
548011 | Level 1 | Model Group:Array Group 11:548012 | <Unnamed>
550536 | 3 aukštas | Model Group:Array Group 21:550537 | <Unnamed>
550538 | 3 aukštas | Model Group:Array Group 21:550539 | <Unnamed>
550540 | 3 aukštas | Model Group:Array Group 21:550541 | <Unnamed>
550542 | 3 aukštas | Model Group:Array Group 21:550543 | <Unnamed>
550544 | 3 aukštas | Model Group:Array Group 21:550545 | <Unnamed>
550546 | 3 aukštas | Model Group:Array Group 21:550547 | <Unnamed>
550549 | 3 aukštas | Model Group:Array Group 21:550550 | <Unnamed>
550551 | 3 aukštas | Model Group:Array Group 21:550552 | <Unnamed>
550553 | 3 aukštas | Model Group:Array Group 21:550554 | <Unnamed>
550555 | 3 aukštas | Model Group:Array Group 21:550556 | <Unnamed>
550557 | 3 aukštas | Model Group:Array Group 21:550558 | <Unnamed>
550561 | 3 aukštas | Model Group:Array Group 21:550562 | <Unnamed>
550563 | 3 aukštas | Model Group:Array Group 21:550564 | <Unnamed>
550565 | 3 aukštas | Model Group:Array Group 21:550566 | <Unnamed>
550567 | 3 aukštas | Model Group:Array Group 21:550568 | <Unnamed>
550569 | 3 aukštas | Model Group:Array Group 21:550570 | <Unnamed>
550624 | 3 aukštas | Model Group:Array Group 22:550625 | <Unnamed>
550627 | 3 aukštas | Model Group:Array Group 22:550628 | <Unnamed>
550630 | 3 aukštas | Model Group:Array Group 22:550631 | <Unnamed>
550633 | 3 aukštas | Model Group:Array Group 22:550634 | <Unnamed>
550636 | 3 aukštas | Model Group:Array Group 22:550637 | <Unnamed>
550639 | 3 aukštas | Model Group:Array Group 22:550640 | <Unnamed>
550642 | 3 aukštas | Model Group:Array Group 22:550643 | <Unnamed>
550645 | 3 aukštas | Model Group:Array Group 22:550646 | <Unnamed>
550648 | 3 aukštas | Model Group:Array Group 22:550649 | <Unnamed>
550654 | 3 aukštas | Model Group:Array Group 22:550655 | <Unnamed>
550656 | 3 aukštas | Model Group:Array Group 22:550657 | <Unnamed>
550658 | 3 aukštas | Model Group:Array Group 22:550659 | <Unnamed>
550660 | 3 aukštas | Model Group:Array Group 22:550661 | <Unnamed>
550662 | 3 aukštas | Model Group:Array Group 22:550663 | <Unnamed>
550664 | 3 aukštas | Model Group:Array Group 22:550665 | <Unnamed>
550666 | 3 aukštas | Model Group:Array Group 22:550667 | <Unnamed>
550668 | 3 aukštas | Model Group:Array Group 22:550669 | <Unnamed>
550670 | 3 aukštas | Model Group:Array Group 22:550671 | <Unnamed>
550672 | 3 aukštas | Model Group:Array Group 22:550673 | <Unnamed>
550674 | 3 aukštas | Model Group:Array Group 22:550675 | <Unnamed>
550676 | 3 aukštas | Model Group:Array Group 22:550677 | <Unnamed>
550678 | 3 aukštas | Model Group:Array Group 22:550679 | <Unnamed>
550680 | 3 aukštas | Model Group:Array Group 22:550681 | <Unnamed>
550682 | 3 aukštas | Model Group:Array Group 22:550683 | <Unnamed>
550684 | 3 aukštas | Model Group:Array Group 22:550685 | <Unnamed>
550686 | 3 aukštas | Model Group:Array Group 22:550687 | <Unnamed>
553296 | Rūsys | Model Group:Array Group 24:553332 | <Unnamed>
553335 | Rūsys | Model Group:Array Group 24:553336 | <Unnamed>
553351 | Rūsys | Model Group:Array Group 24:553352 | <Unnamed>
553354 | Rūsys | Model Group:Array Group 24:553355 | <Unnamed>
553357 | Rūsys | Model Group:Array Group 24:553358 | <Unnamed>
553360 | Rūsys | Model Group:Array Group 24:553361 | <Unnamed>
553363 | Rūsys | Model Group:Array Group 24:553364 | <Unnamed>
553366 | Rūsys | Model Group:Array Group 24:553367 | <Unnamed>
563487 | 3 aukštas | Model Group:Array Group 22:563488 | <Unnamed>
563489 | 3 aukštas | Model Group:Array Group 22:563490 | <Unnamed>
563491 | 3 aukštas | Model Group:Array Group 22:563492 | <Unnamed>
652270 | 3 aukštas | Model Group:Array Group 22:652271 | <Unnamed>
652272 | 3 aukštas | Model Group:Array Group 22:652273 | <Unnamed>
652274 | 3 aukštas | Model Group:Array Group 22:652275 | <Unnamed>
652276 | 3 aukštas | Model Group:Array Group 22:652277 | <Unnamed>
652278 | 3 aukštas | Model Group:Array Group 22:652279 | <Unnamed>
652280 | 3 aukštas | Model Group:Array Group 22:652281 | <Unnamed>
652282 | 3 aukštas | Model Group:Array Group 22:652283 | <Unnamed>
652284 | 3 aukštas | Model Group:Array Group 22:652285 | <Unnamed>
652286 | 3 aukštas | Model Group:Array Group 22:652287 | <Unnamed>
652290 | 3 aukštas | Model Group:Array Group 22:652291 | <Unnamed>
652292 | 3 aukštas | Model Group:Array Group 22:652293 | <Unnamed>
652294 | 3 aukštas | Model Group:Array Group 22:652295 | <Unnamed>
652297 | 3 aukštas | Model Group:Array Group 22:652298 | <Unnamed>
652299 | 3 aukštas | Model Group:Array Group 22:652300 | <Unnamed>
652301 | 3 aukštas | Model Group:Array Group 22:652302 | <Unnamed>
652303 | 3 aukštas | Model Group:Array Group 22:652304 | <Unnamed>
652305 | 3 aukštas | Model Group:Array Group 22:652306 | <Unnamed>
652307 | 3 aukštas | Model Group:Array Group 22:652308 | <Unnamed>
652309 | 3 aukštas | Model Group:Array Group 22:652310 | <Unnamed>
652311 | 3 aukštas | Model Group:Array Group 22:652312 | <Unnamed>
652313 | 3 aukštas | Model Group:Array Group 22:652314 | <Unnamed>
652317 | 3 aukštas | Model Group:Array Group 22:652318 | <Unnamed>
652319 | 3 aukštas | Model Group:Array Group 22:652320 | <Unnamed>
652321 | 3 aukštas | Model Group:Array Group 22:652322 | <Unnamed>
652339 | 3 aukštas | Model Group:Array Group 22:652340 | <Unnamed>
652341 | 3 aukštas | Model Group:Array Group 22:652342 | <Unnamed>
652343 | 3 aukštas | Model Group:Array Group 22:652344 | <Unnamed>
652345 | 3 aukštas | Model Group:Array Group 22:652346 | <Unnamed>
652347 | 3 aukštas | Model Group:Array Group 22:652348 | <Unnamed>
652349 | 3 aukštas | Model Group:Array Group 22:652350 | <Unnamed>
652351 | 3 aukštas | Model Group:Array Group 22:652352 | <Unnamed>
652353 | 3 aukštas | Model Group:Array Group 22:652354 | <Unnamed>
652355 | 3 aukštas | Model Group:Array Group 22:652356 | <Unnamed>
652359 | 3 aukštas | Model Group:Array Group 22:652360 | <Unnamed>
652361 | 3 aukštas | Model Group:Array Group 22:652362 | <Unnamed>
652363 | 3 aukštas | Model Group:Array Group 22:652364 | <Unnamed>
716107 | 2 aukštas | Model Group:Array Group 11:716108 | <Unnamed>
716138 | 2 aukštas | Model Group:Array Group 11:716139 | <Unnamed>
716147 | 2 aukštas | Model Group:Array Group 11:716148 | <Unnamed>
716156 | 2 aukštas | Model Group:Array Group 11:716157 | <Unnamed>
716165 | 2 aukštas | Model Group:Array Group 11:716166 | <Unnamed>
734059 | Level 1 | Model Group:Array Group 11:734060 | <Unnamed>
734061 | Level 1 | Model Group:Array Group 11:734062 | <Unnamed>
734063 | Level 1 | Model Group:Array Group 11:734064 | <Unnamed>
734101 | Level 1 | Model Group:Array Group 11:734102 | <Unnamed>
734103 | Level 1 | Model Group:Array Group 11:734104 | <Unnamed>
734156 | Level 1 | Model Group:Array Group 11:734157 | <Unnamed>
734158 | Level 1 | Model Group:Array Group 11:734159 | <Unnamed>
744516 | Level 1 | Model Group:Array Group 11:744517 | <Unnamed>
744609 | Level 1 | Model Group:Array Group 11:744610 | <Unnamed>

# IfcFurnishingElement: Persirengimo spintelė dviguba:400x500 V (2)
In: Level 1
Type - Material: <Unnamed> (12)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 400x500 V
Name (Persirengimo spintelė dviguba:400x500 V:...)
695480
704291 | Material: <Unnamed>

# IfcFurnishingElement: Persirengimo spintelė:Persirengimo spintelė (11)
In: 5 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Persirengimo spintelė
Name (Persirengimo spintelė:Persirengimo spintelė:...) | Group | Material
495322 | Model Group:Array Group 10:495327
495330 | Model Group:Array Group 10:495331 | <Unnamed>
495343 | Model Group:Array Group 10:495344 | <Unnamed>
495346 | Model Group:Array Group 10:495347 | <Unnamed>
495349 | Model Group:Array Group 10:495350 | <Unnamed>
495352 | Model Group:Array Group 10:495353 | <Unnamed>
495355 | Model Group:Array Group 10:495356 | <Unnamed>
495358 | Model Group:Array Group 10:495359 | <Unnamed>
495361 | Model Group:Array Group 10:495362 | <Unnamed>
495364 | Model Group:Array Group 10:495365 | <Unnamed>
495367 |  | <Unnamed>

# IfcFurnishingElement: Popular conference cair NELSON:Popular conference cair NELSON (211)
In: 2 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Popular conference cair NELSON
Name (Popular conference cair NELSON:Popular conference cair NELSON:...) | Group
403020 | Model Group:Array Group 1:434997
435000 | Model Group:Array Group 1:435001
435014 | Model Group:Array Group 1:435015
435017 | Model Group:Array Group 1:435018
435020 | Model Group:Array Group 1:435021
435023 | Model Group:Array Group 1:435024
435052 | Model Group:Array Group 1:435054
435055 | Model Group:Array Group 1:435056
435057 | Model Group:Array Group 1:435058
435059 | Model Group:Array Group 1:435060
435061 | Model Group:Array Group 1:435062
435063 | Model Group:Array Group 1:435064
435072 | Model Group:Array Group 1:435074
435075 | Model Group:Array Group 1:435076
435077 | Model Group:Array Group 1:435078
435079 | Model Group:Array Group 1:435080
435081 | Model Group:Array Group 1:435082
435083 | Model Group:Array Group 1:435084
435099 | Model Group:Array Group 1:435101
435102 | Model Group:Array Group 1:435103
435104 | Model Group:Array Group 1:435105
435106 | Model Group:Array Group 1:435107
435108 | Model Group:Array Group 1:435109
435110 | Model Group:Array Group 1:435111
435126 | Model Group:Array Group 1:435128
435129 | Model Group:Array Group 1:435130
435131 | Model Group:Array Group 1:435132
435133 | Model Group:Array Group 1:435134
435135 | Model Group:Array Group 1:435136
435137 | Model Group:Array Group 1:435138
435139 | Model Group:Array Group 1:435141
435142 | Model Group:Array Group 1:435143
435144 | Model Group:Array Group 1:435145
435146 | Model Group:Array Group 1:435147
435148 | Model Group:Array Group 1:435149
435150 | Model Group:Array Group 1:435151
435161 | Model Group:Array Group 4:435169
435164
435172 | Model Group:Array Group 4:435173
435185 | Model Group:Array Group 4:435186
435188 | Model Group:Array Group 4:435189
435191 | Model Group:Array Group 4:435192
435194 | Model Group:Array Group 4:435195
435197 | Model Group:Array Group 4:435198
435200 | Model Group:Array Group 4:435201
435203 | Model Group:Array Group 4:435204
435211 | Model Group:Array Group 5:435212
435225 | Model Group:Array Group 5:435226
435228 | Model Group:Array Group 5:435229
435231 | Model Group:Array Group 5:435232
435234 | Model Group:Array Group 5:435235
435237 | Model Group:Array Group 5:435238
435240 | Model Group:Array Group 5:435241
435243 | Model Group:Array Group 5:435244
435370 | Model Group:Array Group 6:435396
435385 | Model Group:Array Group 7:435454
435399 | Model Group:Array Group 6:435400
435416 | Model Group:Array Group 6:435417
435419 | Model Group:Array Group 6:435420
435422 | Model Group:Array Group 6:435423
435425 | Model Group:Array Group 6:435426
435428 | Model Group:Array Group 6:435429
435431 | Model Group:Array Group 6:435432
435434 | Model Group:Array Group 6:435435
435437 | Model Group:Array Group 6:435438
435440 | Model Group:Array Group 6:435441
435443 | Model Group:Array Group 6:435444
435457 | Model Group:Array Group 7:435458
435468 | Model Group:Array Group 7:435469
435471 | Model Group:Array Group 7:435472
435474 | Model Group:Array Group 7:435475
435477 | Model Group:Array Group 7:435478
435480 | Model Group:Array Group 7:435481
435483 | Model Group:Array Group 7:435484
435486 | Model Group:Array Group 7:435487
435489 | Model Group:Array Group 7:435490
435527 | Model Group:Array Group 7:435528
435529 | Model Group:Array Group 7:435530
435531 | Model Group:Array Group 7:435532
435533 | Model Group:Array Group 7:435534
435535 | Model Group:Array Group 7:435536
435537 | Model Group:Array Group 7:435538
435539 | Model Group:Array Group 7:435540
435541 | Model Group:Array Group 7:435542
435543 | Model Group:Array Group 7:435544
435545 | Model Group:Array Group 7:435546
435586 | Model Group:Array Group 8:435587
435589 | Model Group:Array Group 8:435590
435592 | Model Group:Array Group 8:435593
435595 | Model Group:Array Group 8:435596
435598 | Model Group:Array Group 8:435599
436498 | Model Group:Array Group 7:436499
436500 | Model Group:Array Group 7:436501
436502 | Model Group:Array Group 7:436503
436504 | Model Group:Array Group 7:436505
436510 | Model Group:Array Group 7:436511
436512 | Model Group:Array Group 7:436513
436514 | Model Group:Array Group 7:436515
436516 | Model Group:Array Group 7:436517
436518 | Model Group:Array Group 7:436519
436520 | Model Group:Array Group 7:436521
436522 | Model Group:Array Group 7:436523
436524 | Model Group:Array Group 7:436525
436530 | Model Group:Array Group 7:436531
436532 | Model Group:Array Group 7:436533
436534 | Model Group:Array Group 7:436535
436536 | Model Group:Array Group 7:436537
436551 | Model Group:Array Group 7:436552
436553 | Model Group:Array Group 7:436554
436555 | Model Group:Array Group 7:436556
436557 | Model Group:Array Group 7:436558
436559 | Model Group:Array Group 7:436560
436561 | Model Group:Array Group 7:436562
436563 | Model Group:Array Group 7:436564
436565 | Model Group:Array Group 7:436566
436567 | Model Group:Array Group 7:436568
436569 | Model Group:Array Group 7:436570
436571 | Model Group:Array Group 7:436572
436573 | Model Group:Array Group 7:436574
436575 | Model Group:Array Group 7:436576
436577 | Model Group:Array Group 7:436578
436579 | Model Group:Array Group 7:436580
436581 | Model Group:Array Group 7:436582
436596 | Model Group:Array Group 7:436597
436598 | Model Group:Array Group 7:436599
436600 | Model Group:Array Group 7:436601
436602 | Model Group:Array Group 7:436603
436604 | Model Group:Array Group 7:436605
436606 | Model Group:Array Group 7:436607
436608 | Model Group:Array Group 7:436609
436610 | Model Group:Array Group 7:436611
436612 | Model Group:Array Group 7:436613
436614 | Model Group:Array Group 7:436615
436616 | Model Group:Array Group 7:436617
436618 | Model Group:Array Group 7:436619
436620 | Model Group:Array Group 7:436621
436622 | Model Group:Array Group 7:436623
436624 | Model Group:Array Group 7:436625
436626 | Model Group:Array Group 7:436627
436630 | Model Group:Array Group 7:436631
436632 | Model Group:Array Group 7:436633
436634 | Model Group:Array Group 7:436635
436636 | Model Group:Array Group 7:436637
436638 | Model Group:Array Group 7:436639
436640 | Model Group:Array Group 7:436641
436642 | Model Group:Array Group 7:436643
436644 | Model Group:Array Group 7:436645
436646 | Model Group:Array Group 7:436647
436648 | Model Group:Array Group 7:436649
436650 | Model Group:Array Group 7:436651
436652 | Model Group:Array Group 7:436653
436654 | Model Group:Array Group 7:436655
436656 | Model Group:Array Group 7:436657
436658 | Model Group:Array Group 7:436659
436660 | Model Group:Array Group 7:436661
436664 | Model Group:Array Group 7:436665
436666 | Model Group:Array Group 7:436667
436668 | Model Group:Array Group 7:436669
436670 | Model Group:Array Group 7:436671
436672 | Model Group:Array Group 7:436673
436674 | Model Group:Array Group 7:436675
436676 | Model Group:Array Group 7:436677
436678 | Model Group:Array Group 7:436679
436680 | Model Group:Array Group 7:436681
436682 | Model Group:Array Group 7:436683
436684 | Model Group:Array Group 7:436685
436686 | Model Group:Array Group 7:436687
436688 | Model Group:Array Group 7:436689
436690 | Model Group:Array Group 7:436691
436692 | Model Group:Array Group 7:436693
436694 | Model Group:Array Group 7:436695
436698 | Model Group:Array Group 7:436699
436700 | Model Group:Array Group 7:436701
436702 | Model Group:Array Group 7:436703
436704 | Model Group:Array Group 7:436705
436706 | Model Group:Array Group 7:436707
436708 | Model Group:Array Group 7:436709
436710 | Model Group:Array Group 7:436711
436712 | Model Group:Array Group 7:436713
436714 | Model Group:Array Group 7:436715
436716 | Model Group:Array Group 7:436717
436718 | Model Group:Array Group 7:436719
436720 | Model Group:Array Group 7:436721
436722 | Model Group:Array Group 7:436723
436724 | Model Group:Array Group 7:436725
436726 | Model Group:Array Group 7:436727
436728 | Model Group:Array Group 7:436729
436732 | Model Group:Array Group 7:436733
436734 | Model Group:Array Group 7:436735
436736 | Model Group:Array Group 7:436737
436738 | Model Group:Array Group 7:436739
436740 | Model Group:Array Group 7:436741
436742 | Model Group:Array Group 7:436743
436744 | Model Group:Array Group 7:436745
436746 | Model Group:Array Group 7:436747
436748 | Model Group:Array Group 7:436749
436750 | Model Group:Array Group 7:436751
436752 | Model Group:Array Group 7:436753
436754 | Model Group:Array Group 7:436755
436756 | Model Group:Array Group 7:436757
436758 | Model Group:Array Group 7:436759
436760 | Model Group:Array Group 7:436761
436762 | Model Group:Array Group 7:436763
1393381 | Model Group:Array Group 7:1393382
1393383 | Model Group:Array Group 7:1393384
1393385 | Model Group:Array Group 7:1393386
1393387 | Model Group:Array Group 7:1393388
1393389 | Model Group:Array Group 7:1393390
1393391 | Model Group:Array Group 7:1393392
1393393 | Model Group:Array Group 7:1393394
1393395 | Model Group:Array Group 7:1393396

# IfcFurnishingElement: Posto stalas_I formos:10120x600, Posto stalas_I formos:10120x600:1059604
In: 2 aukštas
Type - Material: <Unnamed> (15)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 10120x600

# IfcFurnishingElement: Posto stalas_I formos:10350x600, Posto stalas_I formos:10350x600:1052900
In: 2 aukštas
Type - Material: <Unnamed> (15)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 10350x600

# IfcFurnishingElement: Posto stalas_I formos:3200x600, Posto stalas_I formos:3200x600:1044465
In: 4 aukštas
Type - Material: <Unnamed> (11)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 3200x600

# IfcFurnishingElement: Posto stalas_I formos:6000x600, Posto stalas_I formos:6000x600:1014844
In: 3 aukštas
Type - Material: <Unnamed> (15)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 6000x600

# IfcFurnishingElement: Posto stalas_L formos:3200/3350x600, Posto stalas_L formos:3200/3350x600:1070047
In: 2 aukštas
Type - Material: <Unnamed> (14)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 3200/3350x600

# IfcFurnishingElement: Posto stalas_L formos:5000/2800x600, Posto stalas_L formos:5000/2800x600:1027604
In: 4 aukštas
Type - Material: <Unnamed> (14)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 5000/2800x600

# IfcFurnishingElement: Posto stalas_L formos:5500/1200x600, Posto stalas_L formos:5500/1200x600:1085731
In: 3 aukštas
Type - Material: <Unnamed> (14)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 5500/1200x600

# IfcFurnishingElement: Posto stalas_L formos:6000/1200x600, Posto stalas_L formos:6000/1200x600:1076899
In: 3 aukštas
Type - Material: <Unnamed> (14)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 6000/1200x600

# IfcFurnishingElement: Posto stalas_U formos:10120x600, Posto stalas_U formos:10120x600:1059605
In: 2 aukštas
Type - Material: <Unnamed> (21)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 10120x600

# IfcFurnishingElement: Posto stalas_U formos:10350x600, Posto stalas_U formos:10350x600:1058704
In: 2 aukštas
Type - Material: <Unnamed> (21)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 10350x600

# IfcFurnishingElement: Procedūrinė kėdė:Procedūrinė kėdė (3)
In: 2 aukštas
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Procedūrinė kėdė
Name (Procedūrinė kėdė:Procedūrinė kėdė:...) | Material
843882
1061255 | <Unnamed>
1061374 | <Unnamed>

# IfcFurnishingElement: Reguliuojamas baro baldas:Reguliuojamas baro baldas, Reguliuojamas baro baldas:Reguliuojamas baro baldas:705723
In: Level 1
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Reguliuojamas baro baldas

# IfcFurnishingElement: Reguliuojamas prekystalio baldas:Reguliuojamas prekystalio baldas, Reguliuojamas prekystalio baldas:Reguliuojamas prekystalio baldas:735747
In: Level 1
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Reguliuojamas prekystalio baldas

# IfcFurnishingElement: Seating-LAMMHULTS-GRADE-4_Leg:Chrome - White (18)
In: 2 aukštas
Type - Classification: E2020 Moveable Furnishings (Uniformat); Material: Plastic - Black (8), Metal - Chrome - Polished (8), Fabric - Divina 3 - 236 (2)
Type - Pset_FurnitureTypeCommon - Description: *Please enter mtrl description here for use in mto*
Type - Pset_ManufacturerTypeInformation - Manufacturer: LAMMHULTS
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Chrome - White
Name (Seating-LAMMHULTS-GRADE-4_Leg:Chrome - White:...) | Material
364648
436478 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436885 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436893
436907 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436919 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436931 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436943 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436953 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436966 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436978 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
436996 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
437018 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
437031 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
437034 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
437065 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
437932 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236
506953 | Plastic - Black, Metal - Chrome - Polished, Fabric - Divina 3 - 236

# IfcFurnishingElement: Spinta su lentynomis be durų_reguliuojama:Spinta su lentynomis be durų_reguliuojama, Spinta su lentynomis be durų_reguliuojama:Spinta su lentynomis be durų_reguliuojama:751273
In: 3 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Spinta su lentynomis be durų_reguliuojama

# IfcFurnishingElement: Spinta su lentynomis be durų_reguliuojama:Spinta su lentynomis be durų_reguliuojama 1200x400 (9)
In: 4 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Spinta su lentynomis be durų_reguliuojama 1200x400
Name (Spinta su lentynomis be durų_reguliuojama:Spinta su lentynomis be durų_reguliuojama 1200x400:...) | Material
757863
894477 | <Unnamed>
894566 | <Unnamed>
895560 | <Unnamed>
895575
895601 | <Unnamed>
895602 | <Unnamed>
895612 | <Unnamed>
895613 | <Unnamed>

# IfcFurnishingElement: Spinta su lentynomis be durų_reguliuojama:Spinta su lentynomis be durų_reguliuojama 600x400, Spinta su lentynomis be durų_reguliuojama:Spinta su lentynomis be durų_reguliuojama 600x400:895324
In: 4 aukštas
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Spinta su lentynomis be durų_reguliuojama 600x400

# IfcFurnishingElement: Spintelė prie lovos:Spintelė prie lovos (47)
Type - Material: <Unnamed> (18)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Spintelė prie lovos
Name (Spintelė prie lovos:Spintelė prie lovos:...) | In | Material
435996 | 2 aukštas
436004 | 2 aukštas | <Unnamed>
436010 | 2 aukštas
436021 | 2 aukštas | <Unnamed>
436031 | 2 aukštas | <Unnamed>
436039 | 2 aukštas | <Unnamed>
436051 | 2 aukštas | <Unnamed>
436075 | 2 aukštas | <Unnamed>
436083 | 2 aukštas | <Unnamed>
436095 | 2 aukštas | <Unnamed>
436105 | 2 aukštas | <Unnamed>
436140 | 2 aukštas | <Unnamed>
436161 | 2 aukštas | <Unnamed>
436169 | 2 aukštas | <Unnamed>
436179 | 2 aukštas | <Unnamed>
436202 | 2 aukštas | <Unnamed>
436212 | 2 aukštas | <Unnamed>
436224 | 2 aukštas | <Unnamed>
440157 | 4 aukštas | <Unnamed>
440163 | 4 aukštas | <Unnamed>
440176 | 4 aukštas | <Unnamed>
440177 | 4 aukštas | <Unnamed>
440195 | 4 aukštas | <Unnamed>
440196 | 4 aukštas | <Unnamed>
440220 | 4 aukštas | <Unnamed>
440240 | 4 aukštas | <Unnamed>
440268 | 4 aukštas | <Unnamed>
440269 | 4 aukštas | <Unnamed>
440281 | 4 aukštas | <Unnamed>
440282 | 4 aukštas | <Unnamed>
440294 | 4 aukštas | <Unnamed>
440295 | 4 aukštas | <Unnamed>
440350 | 4 aukštas | <Unnamed>
440361 | 4 aukštas | <Unnamed>
440413 | 4 aukštas | <Unnamed>
440422 | 4 aukštas | <Unnamed>
440439 | 4 aukštas | <Unnamed>
440448 | 4 aukštas | <Unnamed>
440469 | 4 aukštas | <Unnamed>
440480 | 4 aukštas | <Unnamed>
440499 | 4 aukštas | <Unnamed>
440724 | 4 aukštas | <Unnamed>
440748 | 4 aukštas | <Unnamed>
440810 | 4 aukštas | <Unnamed>
440821 | 4 aukštas | <Unnamed>
638444 | 2 aukštas | <Unnamed>
758013 | 4 aukštas | <Unnamed>

# IfcFurnishingElement: Stalas laboratorinis kampinis:Stalas laboratorinis kampinis (2)
In: 5 aukštas
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas laboratorinis kampinis
Name (Stalas laboratorinis kampinis:Stalas laboratorinis kampinis:...)
1095350
1095380 | Material: <Unnamed>

# IfcFurnishingElement: Stalas laboratorinis su lentynomis:Stalas laboratorinis su lentynomis 2, Stalas laboratorinis su lentynomis:Stalas laboratorinis su lentynomis 2:1107270
In: 5 aukštas
Type - Material: <Unnamed> (33)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas laboratorinis su lentynomis 2

# IfcFurnishingElement: Stalas laboratorinis su lentynomis:Stalas laboratorinis su lentynomis 2400mm, Stalas laboratorinis su lentynomis:Stalas laboratorinis su lentynomis 2400mm:1107520
In: 5 aukštas
Type - Material: <Unnamed> (33)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas laboratorinis su lentynomis 2400mm

# IfcFurnishingElement: Stalas laboratorinis trijų durelių:Stalas laboratorinis trijų durelių (21)
In: 5 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas laboratorinis trijų durelių
Name (Stalas laboratorinis trijų durelių:Stalas laboratorinis trijų durelių:...) | Material
494821
494822 | <Unnamed>
494823 | <Unnamed>
495593 | <Unnamed>
495858
1080010 | <Unnamed>
1088281 | <Unnamed>
1180168 | <Unnamed>
1180169 | <Unnamed>
1342375 | <Unnamed>
1344419 | <Unnamed>
1344655 | <Unnamed>
1346062 | <Unnamed>
1346447 | <Unnamed>
1346524 | <Unnamed>
1346756 | <Unnamed>
1346957 | <Unnamed>
1347157 | <Unnamed>
1347362 | <Unnamed>
1348742 | <Unnamed>
1348981 | <Unnamed>

# IfcFurnishingElement: Stalas laboratorinis trijų durelių:Stalas laboratorinis trijų durelių 1150x750 (3)
In: 5 aukštas
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas laboratorinis trijų durelių 1150x750
Name (Stalas laboratorinis trijų durelių:Stalas laboratorinis trijų durelių 1150x750:...)
1088212
1088278
1214463 | Material: <Unnamed>

# IfcFurnishingElement: Stalas laboratorinis vienų durelių:Stalas laboratorinis vienų durelių, Stalas laboratorinis vienų durelių:Stalas laboratorinis vienų durelių:1091854
In: 5 aukštas
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalas laboratorinis vienų durelių

# IfcFurnishingElement: Stalas su 4 kėdėmis:ST.V 80/80 (16)
Type - Material: Furniture - Chair - Metal Legs (24), Furniture - Chair - Plastic Seat (8), Wood - Alder Stained (5)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: ST.V 80/80
Name (Stalas su 4 kėdėmis:ST.V 80/80:...) | In | Material | Group
552444 | 3 aukštas
552461 | 3 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:552462
557181 | 3 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
564883 | 3 aukštas |  | Model Group:Array Group 23:564884
564885 | 3 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:564886
627933 | 3 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
628046 | 3 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
699761 | 4 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
717163 | Rūsys | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
732747 | Level 1 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:732748
732821 | Level 1 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:732822
733284 | Level 1 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:733285
733286 | Level 1 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:733287
775085 | 4 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
1103162 | 5 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:1103163
1103164 | 5 aukštas | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained | Model Group:Array Group 23:1103165

# IfcFurnishingElement: Stalas su 4 kėdėmis:ST.V 80/80 V (9)
In: Level 1
Type - Material: Furniture - Chair - Metal Legs (24), Furniture - Chair - Plastic Seat (8), Wood - Alder Stained (5)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: ST.V 80/80 V
Name (Stalas su 4 kėdėmis:ST.V 80/80 V:...) | Material
550167
550170 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
550173 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
550176 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
550184 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
550219 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
550221 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
818538 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained
818539 | Furniture - Chair - Metal Legs, Furniture - Chair - Plastic Seat, Wood - Alder Stained

# IfcFurnishingElement: Stalo korpusas:Stalo korpusas V, Stalo korpusas:Stalo korpusas V:696015
In: Level 1
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Stalo korpusas V

# IfcFurnishingElement: Stelažas reguliojamas:STLŽ-100/50 V, Stelažas reguliojamas:STLŽ-100/50 V:688780
In: Level 1
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: STLŽ-100/50 V

# IfcFurnishingElement: Stelažas reguliojamas:STLŽ-140/60 V, Stelažas reguliojamas:STLŽ-140/60 V:692482
In: Level 1
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: STLŽ-140/60 V

# IfcFurnishingElement: Stelažas reguliojamas:STLŽ-77/60, Stelažas reguliojamas:STLŽ-77/60:1095510
In: 5 aukštas
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: STLŽ-77/60

# IfcFurnishingElement: Stelažas reguliojamas:STLŽ-90/60 (413)
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: STLŽ-90/60
Name (Stelažas reguliojamas:STLŽ-90/60:...) | In | Material | Group
420312 | 3 aukštas
433757 | 3 aukštas | <Unnamed>
433760 | 3 aukštas | <Unnamed>
433763 | 3 aukštas | <Unnamed>
434038 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434043
434046 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434047
434062 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434063
434065 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434066
434068 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434069
434071 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434072
434074 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434075
434077 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434078
434080 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434081
434098 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434099
434100 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434101
434102 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434103
434104 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434105
434106 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434107
434108 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434109
434110 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434111
434112 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434113
434209 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434210
434211 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434212
434213 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434214
434215 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434216
434217 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434218
434219 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434220
434221 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434222
434223 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434224
434225 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434226
434227 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434228
434229 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434230
434231 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434232
434233 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434234
434235 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434236
434237 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434238
434239 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434240
434241 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434242
434252 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434253
434254 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434255
434256 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434257
434258 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434259
434260 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434261
434262 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434263
434264 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434265
434266 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434267
434268 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434269
434270 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434271
434272 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434273
434274 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434275
434276 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434277
434278 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434279
434280 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434281
434282 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434283
434284 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434285
434320 | 3 aukštas | <Unnamed> | Model Group:Array Group 2:434321
434449 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434450
434467 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434468
434470 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434471
434473 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434474
434476 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434477
434496 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434497
434498 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434499
434500 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434501
434502 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434503
434504 | 3 aukštas | <Unnamed> | Model Group:Array Group 3:434505
434706 | 3 aukštas | <Unnamed>
435946 | 2 aukštas | <Unnamed>
435953 | 2 aukštas | <Unnamed>
435956 | 2 aukštas | <Unnamed>
435959 | 2 aukštas | <Unnamed>
436253 | 2 aukštas | <Unnamed>
437278 | 2 aukštas | <Unnamed>
437296 | 2 aukštas | <Unnamed>
437309 | 2 aukštas | <Unnamed>
437312 | 2 aukštas | <Unnamed>
437315 | 2 aukštas | <Unnamed>
437318 | 2 aukštas | <Unnamed>
437321 | 2 aukštas | <Unnamed>
437324 | 2 aukštas | <Unnamed>
437327 | 2 aukštas | <Unnamed>
437330 | 2 aukštas | <Unnamed>
437333 | 2 aukštas | <Unnamed>
437336 | 2 aukštas | <Unnamed>
437339 | 2 aukštas | <Unnamed>
437342 | 2 aukštas | <Unnamed>
437345 | 2 aukštas | <Unnamed>
438191 | 2 aukštas | <Unnamed>
440545 | 4 aukštas | <Unnamed>
440548 | 4 aukštas | <Unnamed>
440563 | 4 aukštas | <Unnamed>
495867 | 5 aukštas | <Unnamed>
495874 | 5 aukštas | <Unnamed>
495877 | 5 aukštas | <Unnamed>
495880 | 5 aukštas | <Unnamed>
