Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-30T18:22:24+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Alternate UI 23.0.1.318

# IfcProject, 0001
LongName: Project Name; Phase: .

# IfcSite, Default
RefLatitude: 54, 45, 6, 493731; RefLongitude: 25, 16, 42, 895717; RefElevation: -3.46517e-11 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 9
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Level 1 | Level 1 | 152840
Level 2 | Level 2 | 157340

# IfcBuildingStorey: Level:Plenum (5)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Rūsys | Rūsys | 149840
3 aukštas | 3 aukštas | 162140
4 aukštas | 4 aukštas | 166640
5 aukštas | 5 aukštas | 171140
Stogas | Stogas | 175640

# IfcBuildingElementProxy: 1F 230V antviršinis kišt. lizdas 2 vnt:Default, 1F 230V antviršinis kišt. lizdas 2 vnt:Default:1515888
In: 3 aukštas
Type - Material: RS16 single socket-outlet IP44 surface pure white - EKO07475 - white (7)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Default; sets with these values: 2

# IfcBuildingElementProxy: 1F 230V antviršinis kišt. lizdas:Default (7)
Type - Material: RS16 single socket-outlet IP44 surface pure white - EKO07475 - white (4)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Default; sets with these values: 2
Name (1F 230V antviršinis kišt. lizdas:Default:...) | In | Material
1197302 | Rūsys
1210881 | Rūsys | RS16 single socket-outlet IP44 surface pure white - EKO07475 - white
1211335 | Rūsys | RS16 single socket-outlet IP44 surface pure white - EKO07475 - white
1234982 | Level 1 | RS16 single socket-outlet IP44 surface pure white - EKO07475 - white
1246739 | Level 2 | RS16 single socket-outlet IP44 surface pure white - EKO07475 - white
1247048 | Level 2 | RS16 single socket-outlet IP44 surface pure white - EKO07475 - white
1272124 | Level 2 | RS16 single socket-outlet IP44 surface pure white - EKO07475 - white

# IfcBuildingElementProxy: 24V antviršinis kišt. lizdas:Default, 24V antviršinis kišt. lizdas:Default:1207803
In: Rūsys
Type - Material: RS16 single socket-outlet IP44 surface pure white - EKO07475 - white (4)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Default; sets with these values: 2

# IfcBuildingElementProxy: 3F 16A antviršinis kištukinis lizdas:CEE SOCKET H6 / 400/16/5/44 (24)
Type - Material: Plastic (2), Laminate, Red, Matte (3)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: CEE SOCKET H6 / 400/16/5/44; sets with these values: 2
Name (3F 16A antviršinis kištukinis lizdas:CEE SOCKET H6 / 400/16/5/44:...) | In | Material
1186440 | Rūsys
1225644 | Rūsys | Plastic, Laminate, Red, Matte
1225909 | Rūsys | Plastic, Laminate, Red, Matte
1226117 | Rūsys | Plastic, Laminate, Red, Matte
1231946 | Level 1 | Plastic, Laminate, Red, Matte
1232203 | Level 1 | Plastic, Laminate, Red, Matte
1232529 | Level 1 | Plastic, Laminate, Red, Matte
1232576 | Level 1 | Plastic, Laminate, Red, Matte
1236372 | Rūsys | Plastic, Laminate, Red, Matte
1253930 | Level 2 | Plastic, Laminate, Red, Matte
1254695 | Level 2 | Plastic, Laminate, Red, Matte
1268713 | Level 2 | Plastic, Laminate, Red, Matte
1269582 | Level 2 | Plastic, Laminate, Red, Matte
1269874 | Level 2 | Plastic, Laminate, Red, Matte
1270071 | Level 2 | Plastic, Laminate, Red, Matte
1270757 | Level 2 | Plastic, Laminate, Red, Matte
1272430 | Level 2 | Plastic, Laminate, Red, Matte
1298537 | 3 aukštas | Plastic, Laminate, Red, Matte
1302595 | 3 aukštas | Plastic, Laminate, Red, Matte
1309987 | 4 aukštas | Plastic, Laminate, Red, Matte
1311827 | 4 aukštas | Plastic, Laminate, Red, Matte
1312042 | 4 aukštas | Plastic, Laminate, Red, Matte
1323274 | 4 aukštas | Plastic, Laminate, Red, Matte
1353522 | 5 aukštas | Plastic, Laminate, Red, Matte

# IfcBuildingElementProxy: Atvadas kabeliui:Atvadas (282)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Atvadas; sets with these values: 2
Pset_ProvisionForVoid - Width: 33.9188 mm; Height: 66.5 mm; Depth: 73 mm
Name (Atvadas kabeliui:Atvadas:...) | In
1213840 | Rūsys
1218116 | Rūsys
1226291 | Rūsys
1226356 | Rūsys
1226560 | Rūsys
1226602 | Rūsys
1237266 | Level 2
1237480 | Level 2
1237491 | Level 2
1237502 | Level 2
1237513 | Level 2
1237677 | Level 2
1238527 | Level 2
1238538 | Level 2
1238549 | Level 2
1238919 | Level 2
1239927 | Level 2
1239938 | Level 2
1239948 | Level 2
1241945 | Level 2
1242054 | Level 2
1242385 | Level 2
1242386 | Level 2
1242614 | Level 2
1242615 | Level 2
1242762 | Level 2
1245187 | Level 2
1245491 | Level 2
1245499 | Level 2
1245509 | Level 2
1247437 | Level 2
1247562 | Level 2
1247572 | Level 2
1247580 | Level 2
1249093 | Level 2
1249287 | Level 2
1249366 | Level 2
1249401 | Level 2
1249498 | Level 2
1249547 | Level 2
1249642 | Level 2
1249703 | Level 2
1249796 | Level 2
1254723 | Level 2
1254944 | Level 2
1255234 | Level 2
1255437 | Level 2
1255753 | Level 2
1256190 | Level 2
1256704 | Level 2
1258086 | Level 2
1258371 | Level 2
1258384 | Level 2
1258393 | Level 2
1258402 | Level 2
1258413 | Level 2
1258422 | Level 2
1258460 | Level 2
1262637 | Level 2
1262707 | Level 2
1265296 | Level 2
1265358 | Level 2
1266688 | Level 2
1266754 | Level 2
1266946 | Level 2
1266983 | Level 2
1267054 | Level 2
1267834 | Level 2
1268128 | Level 2
1268185 | Level 2
1268390 | Level 2
1268929 | Level 2
1269210 | Level 2
1271329 | Level 2
1271573 | Level 2
1271608 | Level 2
1271682 | Level 2
1271980 | Level 2
1272004 | Level 2
1272701 | Level 2
1272782 | Level 2
1272793 | Level 2
1272826 | Level 2
1272835 | Level 2
1272844 | Level 2
1272872 | Level 2
1273253 | Level 2
1273646 | Level 2
1273655 | Level 2
1273664 | Level 2
1273673 | Level 2
1292537 | 3 aukštas
1292929 | 3 aukštas
1292942 | 3 aukštas
1292955 | 3 aukštas
1292964 | 3 aukštas
1292999 | 3 aukštas
1295033 | 3 aukštas
1295044 | 3 aukštas
1295053 | 3 aukštas
1295064 | 3 aukštas
1295075 | 3 aukštas
1295084 | 3 aukštas
1296191 | 3 aukštas
1296200 | 3 aukštas
1296209 | 3 aukštas
1296220 | 3 aukštas
1296229 | 3 aukštas
1296242 | 3 aukštas
1304009 | 3 aukštas
1304038 | 3 aukštas
1304053 | 3 aukštas
1304064 | 3 aukštas
1304075 | 3 aukštas
1304084 | 3 aukštas
1308932 | 4 aukštas
1309175 | 4 aukštas
1311262 | 4 aukštas
1311365 | 4 aukštas
1316546 | 4 aukštas
1316633 | 4 aukštas
1316748 | 4 aukštas
1317031 | 4 aukštas
1317194 | 4 aukštas
1317199 | 4 aukštas
1317364 | 4 aukštas
1317369 | 4 aukštas
1317527 | 4 aukštas
1317532 | 4 aukštas
1320903 | 4 aukštas
1320908 | 4 aukštas
1320913 | 4 aukštas
1321077 | 4 aukštas
1321082 | 4 aukštas
1321097 | 4 aukštas
1321102 | 4 aukštas
1321390 | 4 aukštas
1321859 | 4 aukštas
1321929 | 4 aukštas
1321934 | 4 aukštas
1322081 | 4 aukštas
1322086 | 4 aukštas
1322204 | 4 aukštas
1375836 | 5 aukštas
1375999 | 5 aukštas
1376607 | 5 aukštas
1376955 | 4 aukštas
1377183 | 4 aukštas
1377362 | 4 aukštas
1377959 | Level 2
1390147 | 5 aukštas
1390314 | 5 aukštas
1569597 | 5 aukštas
1569757 | 5 aukštas
1569887 | 5 aukštas
1598069 | 5 aukštas
1615267 | Rūsys
1615335 | Level 1
1615457 | Level 1
1615468 | Level 2
1616918 | Rūsys
1616982 | Rūsys
1617071 | Level 1
1617122 | Level 1
1617170 | Level 1
1617207 | Level 1
1617218 | Level 2
1617274 | Level 2
1617293 | Level 2
1617344 | Level 2
1617353 | 3 aukštas
1617404 | 3 aukštas
1617413 | 3 aukštas
1617435 | 3 aukštas
1617539 | 4 aukštas
1617610 | 4 aukštas
1617631 | 4 aukštas
1617673 | 4 aukštas
1617692 | 5 aukštas
1617732 | 5 aukštas
1617740 | 5 aukštas
1617928 | 5 aukštas
1618097 | 4 aukštas
1618120 | 4 aukštas
1618233 | 3 aukštas
1618255 | 3 aukštas
1618299 | Level 2
1618421 | Level 2
1618553 | Level 1
1618597 | Level 1
1618619 | Level 1
1618642 | Rūsys
1618874 | Rūsys
1618942 | Rūsys
1618981 | Rūsys
1619028 | Rūsys
1619072 | Rūsys
1619097 | Rūsys
1619122 | Level 1
1619145 | Level 1
1619167 | Level 1
1619189 | Level 1
1619211 | Level 1
1619243 | Level 1
1619297 | Level 1
1619319 | Level 1
1619341 | Level 2
1619445 | Level 2
1619463 | Level 2
1619488 | Level 2
1619514 | Level 2
1619540 | Level 2
1619615 | Level 2
1619640 | Level 2
1619700 | Level 2
1619726 | Level 2
1619773 | Level 2
1619799 | Level 2
1619854 | Level 2
1619879 | Level 2
1619904 | Level 2
1619931 | Level 2
1619956 | Level 2
1619983 | Level 2
1620008 | Level 2
1620033 | Level 2
1620058 | Level 2
1620083 | Level 2
1620108 | 3 aukštas
1620183 | 3 aukštas
1620210 | 3 aukštas
1620235 | 3 aukštas
1620283 | 3 aukštas
1620310 | 3 aukštas
1620335 | 3 aukštas
1620361 | 4 aukštas
1620384 | 4 aukštas
1620406 | 4 aukštas
1620429 | 4 aukštas
1620451 | 4 aukštas
1620474 | 4 aukštas
1620497 | 4 aukštas
1620520 | 4 aukštas
1620543 | 4 aukštas
1620565 | 4 aukštas
1620587 | 4 aukštas
1620610 | 4 aukštas
1620634 | 4 aukštas
1620656 | 4 aukštas
1620678 | 4 aukštas
1620700 | 5 aukštas
1620754 | 5 aukštas
1620779 | 5 aukštas
1620806 | 5 aukštas
1620831 | 5 aukštas
1620873 | 5 aukštas
1623221 | 5 aukštas
1623335 | 5 aukštas
1623344 | 5 aukštas
1623383 | 5 aukštas
1623394 | 5 aukštas
1623553 | 5 aukštas
1623562 | 5 aukštas
1623571 | 5 aukštas
1623580 | 5 aukštas
1623763 | 5 aukštas
1623772 | 5 aukštas
1623783 | 5 aukštas
1623792 | 5 aukštas
1623801 | 5 aukštas
1623833 | 5 aukštas
1623877 | 5 aukštas
1623954 | 5 aukštas
1624078 | 5 aukštas
1624155 | 5 aukštas
1624188 | 5 aukštas
1624290 | 5 aukštas
1624301 | 5 aukštas
1624312 | 5 aukštas
1624345 | 5 aukštas
1624442 | 5 aukštas
1624725 | 5 aukštas

# IfcBuildingElementProxy: E_Distribution Board_36M:THIS IS A TYPE CATALOG FAMILY, E_Distribution Board_36M:JS-K:1399195
In: Level 1
Type - Material: Color RAL 7035 (16)
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: THIS IS A TYPE CATALOG FAMILY; sets with these values: 2
Pset_ProvisionForVoid - Width: 320 mm; Height: 600 mm; Depth: 107 mm

# IfcBuildingElementProxy: E_Lightning Conductor_MEPcontent_Unspecified_Holder:Standard (36)
In: Stogas
Type - Material: <Unnamed> (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Pset_ProvisionForVoid - Height: 90 mm
Name (E_Lightning Conductor_MEPcontent_Unspecified_Holder:Standard:...) | Material
1043754
1061352 | <Unnamed>
1061364 | <Unnamed>
1061374 | <Unnamed>
1061384 | <Unnamed>
1061400 | <Unnamed>
1061410 | <Unnamed>
1061418 | <Unnamed>
1061438 | <Unnamed>
1061446 | <Unnamed>
1061456 | <Unnamed>
1061464 | <Unnamed>
1061472 | <Unnamed>
1061482 | <Unnamed>
1061490 | <Unnamed>
1061498 | <Unnamed>
1061508 | <Unnamed>
1061516 | <Unnamed>
1061526 | <Unnamed>
1061534 | <Unnamed>
1061542 | <Unnamed>
1061875 | <Unnamed>
1062287 | <Unnamed>
1062675 | <Unnamed>
1063036 | <Unnamed>
1063044 | <Unnamed>
1063052 | <Unnamed>
1063060 | <Unnamed>
1063068 | <Unnamed>
1063076 | <Unnamed>
1063092 | <Unnamed>
1063100 | <Unnamed>
1063108 | <Unnamed>
1063116 | <Unnamed>
1063124 | <Unnamed>
1063134 | <Unnamed>

# IfcBuildingElementProxy: Emergency switch:ZAQUA022 (2)
In: Rūsys
Type - Material: PRD_AR_SyntheticLightGrey (2), PRD_AR_Black
Type - Pset_BuildingElementProxyCommon - Reference: n/a
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ZAQUA022; Manufacturer: KWC Group AG
Type - Pset_ProductRequirements - Name: Key switch ZAQUA022; Category: Electrical Fixtures
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ProvisionForVoid - Shape: Cuboid
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Name (Emergency switch:ZAQUA022:...)
1602200
1606414 | Material: PRD_AR_SyntheticLightGrey, PRD_AR_Black

# IfcBuildingElementProxy: Floor-box-12-modules:Grindinė dėžutė 12 vietų (28)
Type - Material: Polyamide (Iron Grey) (3), <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Grindinė dėžutė 12 vietų; sets with these values: 2
Name (Floor-box-12-modules:Grindinė dėžutė 12 vietų:...) | In | Material
1230658 | Level 1
1234629 | Level 1 | Polyamide (Iron Grey), <Unnamed>
1341528 | 5 aukštas | Polyamide (Iron Grey), <Unnamed>
1409859 | Level 1 | Polyamide (Iron Grey), <Unnamed>
1423901 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1423943 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1424023 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1424067 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1424127 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1424902 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1425500 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1425507 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1425513 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1425521 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1431652 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1431699 | Level 2 | Polyamide (Iron Grey), <Unnamed>
1518756 | 3 aukštas | Polyamide (Iron Grey), <Unnamed>
1522526 | 3 aukštas | Polyamide (Iron Grey), <Unnamed>
1522587 | 3 aukštas | Polyamide (Iron Grey), <Unnamed>
1522651 | 3 aukštas | Polyamide (Iron Grey), <Unnamed>
1533883 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1543443 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1543528 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1543616 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1543692 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1543986 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1561432 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>
1561496 | 4 aukštas | Polyamide (Iron Grey), <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 1 lizdas:1 LIZDAS (227)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 1 LIZDAS; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm
Name (Kištukinis lizdas 1 lizdas:1 LIZDAS:...) | In | Material
1226653 | Rūsys
1226696 | Rūsys | <Unnamed>
1227123 | Rūsys | <Unnamed>
1227137 | Rūsys | <Unnamed>
1227194 | Rūsys | <Unnamed>
1227529 | Rūsys | <Unnamed>
1227604 | Rūsys | <Unnamed>
1227882 | Rūsys | <Unnamed>
1227936 | Rūsys | <Unnamed>
1228018 | Rūsys | <Unnamed>
1228177 | Level 1 | <Unnamed>
1231301 | Level 1 | <Unnamed>
1231346 | Level 1 | <Unnamed>
1231565 | Level 1 | <Unnamed>
1231627 | Level 1 | <Unnamed>
1234048 | Level 1 | <Unnamed>
1234141 | Level 1 | <Unnamed>
1234173 | Level 1 | <Unnamed>
1234926 | Level 1 | <Unnamed>
1237533 | Level 2 | <Unnamed>
1237642 | Level 2 | <Unnamed>
1237650 | Level 2 | <Unnamed>
1237657 | Level 2 | <Unnamed>
1237664 | Level 2 | <Unnamed>
1239121 | Level 2 | <Unnamed>
1240035 | Level 2 | <Unnamed>
1240150 | Level 2 | <Unnamed>
1240440 | Level 2 | <Unnamed>
1242794 | Level 2 | <Unnamed>
1245559 | Level 2 | <Unnamed>
1245740 | Level 2 | <Unnamed>
1245942 | Level 2 | <Unnamed>
1245953 | Level 2 | <Unnamed>
1247605 | Level 2 | <Unnamed>
1247671 | Level 2 | <Unnamed>
1249959 | Level 2 | <Unnamed>
1253417 | Level 2 | <Unnamed>
1256864 | Level 2 | <Unnamed>
1256909 | Level 2 | <Unnamed>
1257004 | Level 2 | <Unnamed>
1257128 | Level 2 | <Unnamed>
1257475 | Level 2 | <Unnamed>
1257659 | Level 2 | <Unnamed>
1258541 | Level 2 | <Unnamed>
1258696 | Level 2 | <Unnamed>
1259175 | Level 2 | <Unnamed>
1259701 | Level 2 | <Unnamed>
1260206 | Level 2 | <Unnamed>
1260581 | Level 2 | <Unnamed>
1261397 | Level 2 | <Unnamed>
1262016 | Level 2 | <Unnamed>
1266104 | Level 2 | <Unnamed>
1266169 | Level 2 | <Unnamed>
1267124 | Level 2 | <Unnamed>
1267233 | Level 2 | <Unnamed>
1267434 | Level 2 | <Unnamed>
1268422 | Level 2 | <Unnamed>
1268430 | Level 2 | <Unnamed>
1269042 | Level 2 | <Unnamed>
1270518 | Level 2 | <Unnamed>
1270599 | Level 2 | <Unnamed>
1271148 | Level 2 | <Unnamed>
1271243 | Level 2 | <Unnamed>
1271721 | Level 2 | <Unnamed>
1271770 | Level 2 | <Unnamed>
1272225 | Level 2 | <Unnamed>
1272524 | Level 2 | <Unnamed>
1274196 | Level 2 | <Unnamed>
1274320 | Level 2 | <Unnamed>
1274512 | Level 2 | <Unnamed>
1274657 | Level 2 | <Unnamed>
1274790 | Level 2 | <Unnamed>
1275075 | Level 2 | <Unnamed>
1290682 | 3 aukštas | <Unnamed>
1290742 | 3 aukštas | <Unnamed>
1290879 | 3 aukštas | <Unnamed>
1291887 | 3 aukštas | <Unnamed>
1292426 | 3 aukštas | <Unnamed>
1293295 | 3 aukštas | <Unnamed>
1293305 | 3 aukštas | <Unnamed>
1293346 | 3 aukštas | <Unnamed>
1293838 | 3 aukštas | <Unnamed>
1293873 | 3 aukštas | <Unnamed>
1294161 | 3 aukštas | <Unnamed>
1294355 | 3 aukštas | <Unnamed>
1294425 | 3 aukštas | <Unnamed>
1294802 | 3 aukštas | <Unnamed>
1295096 | 3 aukštas | <Unnamed>
1295135 | 3 aukštas | <Unnamed>
1295258 | 3 aukštas | <Unnamed>
1295415 | 3 aukštas | <Unnamed>
1295516 | 3 aukštas | <Unnamed>
1295930 | 3 aukštas | <Unnamed>
1296253 | 3 aukštas | <Unnamed>
1296296 | 3 aukštas | <Unnamed>
1296424 | 3 aukštas | <Unnamed>
1296514 | 3 aukštas | <Unnamed>
1296664 | 3 aukštas | <Unnamed>
1296844 | 3 aukštas | <Unnamed>
1297530 | 3 aukštas | <Unnamed>
1297605 | 3 aukštas | <Unnamed>
1302167 | 3 aukštas | <Unnamed>
1302884 | 3 aukštas | <Unnamed>
1302970 | 3 aukštas | <Unnamed>
1303056 | 3 aukštas | <Unnamed>
1303101 | 3 aukštas | <Unnamed>
1303172 | 3 aukštas | <Unnamed>
1303386 | 3 aukštas | <Unnamed>
1303462 | 3 aukštas | <Unnamed>
1303614 | 3 aukštas | <Unnamed>
1303788 | 3 aukštas | <Unnamed>
1308603 | 4 aukštas | <Unnamed>
1309229 | 4 aukštas | <Unnamed>
1309471 | 4 aukštas | <Unnamed>
1309718 | 4 aukštas | <Unnamed>
1310400 | 4 aukštas | <Unnamed>
1310605 | 4 aukštas | <Unnamed>
1310968 | 4 aukštas | <Unnamed>
1311039 | 4 aukštas | <Unnamed>
1311584 | 4 aukštas | <Unnamed>
1311672 | 4 aukštas | <Unnamed>
1312615 | 4 aukštas | <Unnamed>
1312653 | 4 aukštas | <Unnamed>
1312769 | 4 aukštas | <Unnamed>
1312983 | 4 aukštas | <Unnamed>
1313410 | 4 aukštas | <Unnamed>
1313510 | 4 aukštas | <Unnamed>
1314190 | 4 aukštas | <Unnamed>
1314403 | 4 aukštas | <Unnamed>
1314927 | 4 aukštas | <Unnamed>
1315188 | 4 aukštas | <Unnamed>
1315565 | 4 aukštas | <Unnamed>
1317816 | 4 aukštas | <Unnamed>
1317892 | 4 aukštas | <Unnamed>
1317951 | 4 aukštas | <Unnamed>
1318356 | 4 aukštas | <Unnamed>
1318539 | 4 aukštas | <Unnamed>
1318864 | 4 aukštas | <Unnamed>
1318954 | 4 aukštas | <Unnamed>
1319799 | 4 aukštas | <Unnamed>
1322345 | 4 aukštas | <Unnamed>
1322388 | 4 aukštas | <Unnamed>
1322609 | 4 aukštas | <Unnamed>
1322677 | 4 aukštas | <Unnamed>
1322793 | 4 aukštas | <Unnamed>
1322816 | 4 aukštas | <Unnamed>
1322878 | 4 aukštas | <Unnamed>
1323058 | 4 aukštas | <Unnamed>
1323136 | 4 aukštas | <Unnamed>
1340481 | 5 aukštas | <Unnamed>
1340511 | 5 aukštas | <Unnamed>
1350459 | 5 aukštas | <Unnamed>
1350532 | 5 aukštas | <Unnamed>
1350771 | 5 aukštas | <Unnamed>
1350974 | 5 aukštas | <Unnamed>
1351143 | 5 aukštas | <Unnamed>
1353284 | 5 aukštas | <Unnamed>
1353925 | 5 aukštas | <Unnamed>
1353957 | 5 aukštas | <Unnamed>
1354296 | 5 aukštas | <Unnamed>
1354525 | 5 aukštas | <Unnamed>
1355979 | 5 aukštas | <Unnamed>
1356269 | 5 aukštas | <Unnamed>
1356295 | 5 aukštas | <Unnamed>
1357515 | 5 aukštas | <Unnamed>
1357702 | 5 aukštas | <Unnamed>
1358436 | 5 aukštas | <Unnamed>
1358519 | 5 aukštas | <Unnamed>
1358781 | 5 aukštas | <Unnamed>
1359238 | 5 aukštas | <Unnamed>
1359285 | 5 aukštas | <Unnamed>
1359507 | 5 aukštas | <Unnamed>
1359578 | 5 aukštas | <Unnamed>
1359623 | 5 aukštas | <Unnamed>
1359918 | 5 aukštas | <Unnamed>
1359968 | 5 aukštas | <Unnamed>
1362339 | 5 aukštas | <Unnamed>
1362434 | 5 aukštas | <Unnamed>
1362472 | 5 aukštas | <Unnamed>
1362637 | 5 aukštas | <Unnamed>
1364153 | 5 aukštas | <Unnamed>
1364218 | 5 aukštas | <Unnamed>
1364291 | 5 aukštas | <Unnamed>
1364414 | 5 aukštas | <Unnamed>
1364631 | 5 aukštas | <Unnamed>
1364687 | 5 aukštas | <Unnamed>
1364906 | 5 aukštas | <Unnamed>
1365141 | 5 aukštas | <Unnamed>
1365301 | 5 aukštas | <Unnamed>
1365574 | 5 aukštas | <Unnamed>
1365674 | 5 aukštas | <Unnamed>
1365909 | 5 aukštas | <Unnamed>
1366024 | 5 aukštas | <Unnamed>
1366077 | 5 aukštas | <Unnamed>
1366626 | 5 aukštas | <Unnamed>
1367582 | 5 aukštas | <Unnamed>
1367717 | 5 aukštas | <Unnamed>
1367888 | 5 aukštas | <Unnamed>
1369218 | 5 aukštas | <Unnamed>
1369340 | 5 aukštas | <Unnamed>
1369436 | 5 aukštas | <Unnamed>
1369443 | 5 aukštas | <Unnamed>
1369450 | 5 aukštas | <Unnamed>
1369851 | 5 aukštas | <Unnamed>
1369898 | 5 aukštas | <Unnamed>
1370319 | 5 aukštas | <Unnamed>
1370369 | 5 aukštas | <Unnamed>
1370540 | 5 aukštas | <Unnamed>
1370963 | 5 aukštas | <Unnamed>
1371114 | 5 aukštas | <Unnamed>
1371309 | 5 aukštas | <Unnamed>
1371538 | 5 aukštas | <Unnamed>
1372018 | 5 aukštas | <Unnamed>
1373883 | 5 aukštas | <Unnamed>
1373975 | 5 aukštas | <Unnamed>
1374147 | 5 aukštas | <Unnamed>
1374302 | 5 aukštas | <Unnamed>
1374597 | 5 aukštas | <Unnamed>
1615583 | Level 1 | <Unnamed>
1615784 | Level 2 | <Unnamed>
1616054 | Level 2 | <Unnamed>
1616182 | Level 2 | <Unnamed>
1616257 | Level 2 | <Unnamed>
1616348 | Level 2 | <Unnamed>
1616609 | Level 2 | <Unnamed>
1616686 | Level 2 | <Unnamed>
1616803 | Level 2 | <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 2 lizdas (lovelyje):2 LIZDAS (14)
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 2 LIZDAS; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm
Name (Kištukinis lizdas 2 lizdas (lovelyje):2 LIZDAS:...) | In | Material
1504767 | 3 aukštas
1504997 | 3 aukštas | <Unnamed>
1506263 | 3 aukštas | <Unnamed>
1506314 | 3 aukštas | <Unnamed>
1520654 | 3 aukštas | <Unnamed>
1520753 | 3 aukštas | <Unnamed>
1520856 | 3 aukštas | <Unnamed>
1520896 | 3 aukštas | <Unnamed>
1521071 | 3 aukštas | <Unnamed>
1521277 | 3 aukštas | <Unnamed>
1559481 | 4 aukštas | <Unnamed>
1559572 | 4 aukštas | <Unnamed>
1559602 | 4 aukštas | <Unnamed>
1560876 | 4 aukštas | <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 2 lizdas:2 LIZDAS (338)
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 2 LIZDAS; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm
Name (Kištukinis lizdas 2 lizdas:2 LIZDAS:...) | In | Material
1221058 | Rūsys
1243775 | Level 2 | <Unnamed>
1243891 | Level 2 | <Unnamed>
1244203 | Level 2 | <Unnamed>
1247955 | Level 2 | <Unnamed>
1250325 | Level 2 | <Unnamed>
1250512 | Level 2 | <Unnamed>
1252353 | Level 2 | <Unnamed>
1252619 | Level 2 | <Unnamed>
1293763 | 3 aukštas | <Unnamed>
1300843 | 3 aukštas | <Unnamed>
1340935 | 5 aukštas | <Unnamed>
1341073 | 5 aukštas | <Unnamed>
1341274 | 5 aukštas | <Unnamed>
1341985 | 5 aukštas | <Unnamed>
1342021 | 5 aukštas | <Unnamed>
1342382 | 5 aukštas | <Unnamed>
1351585 | 5 aukštas | <Unnamed>
1360195 | 5 aukštas | <Unnamed>
1360280 | 5 aukštas | <Unnamed>
1360819 | 5 aukštas | <Unnamed>
1361182 | 5 aukštas | <Unnamed>
1362794 | 5 aukštas | <Unnamed>
1362851 | 5 aukštas | <Unnamed>
1362966 | 5 aukštas | <Unnamed>
1368325 | 5 aukštas | <Unnamed>
1373241 | 5 aukštas | <Unnamed>
1373829 | 5 aukštas | <Unnamed>
1403093 | Rūsys | <Unnamed>
1403114 | Rūsys | <Unnamed>
1403449 | Rūsys | <Unnamed>
1404713 | Rūsys | <Unnamed>
1405243 | Rūsys | <Unnamed>
1405331 | Rūsys | <Unnamed>
1405507 | Rūsys | <Unnamed>
1405604 | Rūsys | <Unnamed>
1407997 | Level 1 | <Unnamed>
1409091 | Level 1 | <Unnamed>
1409151 | Level 1 | <Unnamed>
1409607 | Level 1 | <Unnamed>
1412764 | Level 1 | <Unnamed>
1412860 | Level 1 | <Unnamed>
1413279 | Level 1 | <Unnamed>
1413839 | Level 1 | <Unnamed>
1413980 | Level 1 | <Unnamed>
1414059 | Level 1 | <Unnamed>
1414547 | Level 1 | <Unnamed>
1415825 | Level 1 | <Unnamed>
1416145 | Level 1 | <Unnamed>
1416265 | Level 1 | <Unnamed>
1416486 | Level 1 | <Unnamed>
1416588 | Level 1 | <Unnamed>
1417027 | Level 1 | <Unnamed>
1417127 | Level 1 | <Unnamed>
1417640 | Level 1 | <Unnamed>
1417668 | Level 1 | <Unnamed>
1418245 | Level 1 | <Unnamed>
1418281 | Level 1 | <Unnamed>
1418712 | Level 1 | <Unnamed>
1418725 | Level 1 | <Unnamed>
1419370 | Level 1 | <Unnamed>
1419420 | Level 1 | <Unnamed>
1419791 | Level 1 | <Unnamed>
1420371 | Level 1 | <Unnamed>
1420513 | Level 1 | <Unnamed>
1420600 | Level 1 | <Unnamed>
1420816 | Level 2 | <Unnamed>
1421426 | Level 2 | <Unnamed>
1421436 | Level 2 | <Unnamed>
1421823 | Level 2 | <Unnamed>
1422880 | Level 2 | <Unnamed>
1422902 | Level 2 | <Unnamed>
1423090 | Level 2 | <Unnamed>
1425803 | Level 2 | <Unnamed>
1425893 | Level 2 | <Unnamed>
1426263 | Level 2 | <Unnamed>
1426271 | Level 2 | <Unnamed>
1426402 | Level 2 | <Unnamed>
1426788 | Level 2 | <Unnamed>
1428022 | Level 2 | <Unnamed>
1428046 | Level 2 | <Unnamed>
1428426 | Level 2 | <Unnamed>
1429050 | Level 2 | <Unnamed>
1429208 | Level 2 | <Unnamed>
1429530 | Level 2 | <Unnamed>
1429821 | Level 2 | <Unnamed>
1429923 | Level 2 | <Unnamed>
1429965 | Level 2 | <Unnamed>
1430182 | Level 2 | <Unnamed>
1430300 | Level 2 | <Unnamed>
1430320 | Level 2 | <Unnamed>
1430491 | Level 2 | <Unnamed>
1430582 | Level 2 | <Unnamed>
1430631 | Level 2 | <Unnamed>
1430758 | Level 2 | <Unnamed>
1431081 | Level 2 | <Unnamed>
1431992 | Level 2 | <Unnamed>
1432547 | Level 2 | <Unnamed>
1432800 | Level 2 | <Unnamed>
1432840 | Level 2 | <Unnamed>
1432866 | Level 2 | <Unnamed>
1433196 | Level 2 | <Unnamed>
1433228 | Level 2 | <Unnamed>
1433521 | Level 2 | <Unnamed>
1433851 | Level 2 | <Unnamed>
1435193 | Level 2 | <Unnamed>
1435217 | Level 2 | <Unnamed>
1436086 | Level 2 | <Unnamed>
1436128 | Level 2 | <Unnamed>
1436469 | Level 2 | <Unnamed>
1436482 | Level 2 | <Unnamed>
1436664 | Level 2 | <Unnamed>
1436860 | Level 2 | <Unnamed>
1437140 | Level 2 | <Unnamed>
1437296 | Level 2 | <Unnamed>
1437381 | Level 2 | <Unnamed>
1437414 | Level 2 | <Unnamed>
1438182 | Level 2 | <Unnamed>
1438343 | Level 2 | <Unnamed>
1438387 | Level 2 | <Unnamed>
1438476 | Level 2 | <Unnamed>
1438707 | Level 2 | <Unnamed>
1439077 | Level 2 | <Unnamed>
1439091 | Level 2 | <Unnamed>
1439367 | Level 2 | <Unnamed>
1439827 | Level 2 | <Unnamed>
1439843 | Level 2 | <Unnamed>
1440078 | Level 2 | <Unnamed>
1441081 | Level 2 | <Unnamed>
1444190 | Level 2 | <Unnamed>
1444360 | Level 2 | <Unnamed>
1444557 | Level 2 | <Unnamed>
1445020 | Level 2 | <Unnamed>
1445164 | Level 2 | <Unnamed>
1445657 | Level 2 | <Unnamed>
1445688 | Level 2 | <Unnamed>
1445939 | Level 2 | <Unnamed>
1446106 | Level 2 | <Unnamed>
1446739 | Level 2 | <Unnamed>
1448108 | Level 2 | <Unnamed>
1448134 | Level 2 | <Unnamed>
1448417 | Level 2 | <Unnamed>
1448488 | Level 2 | <Unnamed>
1449916 | Level 2 | <Unnamed>
1449932 | Level 2 | <Unnamed>
1450014 | Level 2 | <Unnamed>
1450415 | Level 2 | <Unnamed>
1452895 | Level 2 | <Unnamed>
1452910 | Level 2 | <Unnamed>
1452983 | Level 2 | <Unnamed>
1453330 | Level 2 | <Unnamed>
1453465 | Level 2 | <Unnamed>
1453474 | Level 2 | <Unnamed>
1453940 | Level 2 | <Unnamed>
1453962 | Level 2 | <Unnamed>
1454360 | Level 2 | <Unnamed>
1454690 | Level 2 | <Unnamed>
1454941 | Level 2 | <Unnamed>
1455439 | Level 2 | <Unnamed>
1455693 | Level 2 | <Unnamed>
1455749 | Level 2 | <Unnamed>
1455890 | Level 2 | <Unnamed>
1456277 | Level 2 | <Unnamed>
1456629 | Level 2 | <Unnamed>
1456981 | Level 2 | <Unnamed>
1457476 | Level 2 | <Unnamed>
1457887 | Level 2 | <Unnamed>
1457914 | Level 2 | <Unnamed>
1458913 | Level 2 | <Unnamed>
1458939 | Level 2 | <Unnamed>
1459643 | Level 2 | <Unnamed>
1459683 | Level 2 | <Unnamed>
1459968 | Level 2 | <Unnamed>
1460961 | Level 2 | <Unnamed>
1466456 | Level 2 | <Unnamed>
1466596 | Level 2 | <Unnamed>
1467169 | Level 2 | <Unnamed>
1467187 | Level 2 | <Unnamed>
1467640 | Level 2 | <Unnamed>
1467668 | Level 2 | <Unnamed>
1467798 | Level 2 | <Unnamed>
1467834 | Level 2 | <Unnamed>
1468289 | Level 2 | <Unnamed>
1468671 | Level 2 | <Unnamed>
1468791 | Level 2 | <Unnamed>
1469980 | Level 2 | <Unnamed>
1470337 | Level 2 | <Unnamed>
1470408 | Level 2 | <Unnamed>
1471054 | Level 2 | <Unnamed>
1471106 | Level 2 | <Unnamed>
1473454 | Level 2 | <Unnamed>
1473484 | Level 2 | <Unnamed>
1474221 | 3 aukštas | <Unnamed>
1474234 | 3 aukštas | <Unnamed>
1475158 | 3 aukštas | <Unnamed>
1475196 | 3 aukštas | <Unnamed>
1475737 | 3 aukštas | <Unnamed>
1476290 | 3 aukštas | <Unnamed>
1476589 | 3 aukštas | <Unnamed>
1477238 | 3 aukštas | <Unnamed>
1477457 | 3 aukštas | <Unnamed>
1477744 | 3 aukštas | <Unnamed>
1477904 | 3 aukštas | <Unnamed>
1478418 | 3 aukštas | <Unnamed>
1478695 | 3 aukštas | <Unnamed>
1478848 | 3 aukštas | <Unnamed>
1480052 | 3 aukštas | <Unnamed>
1480073 | 3 aukštas | <Unnamed>
1480151 | 3 aukštas | <Unnamed>
1480535 | 3 aukštas | <Unnamed>
1480857 | 3 aukštas | <Unnamed>
1482463 | 3 aukštas | <Unnamed>
1484837 | 3 aukštas | <Unnamed>
1484917 | 3 aukštas | <Unnamed>
1485261 | 3 aukštas | <Unnamed>
1485636 | 3 aukštas | <Unnamed>
1485889 | 3 aukštas | <Unnamed>
1486711 | 3 aukštas | <Unnamed>
1486758 | 3 aukštas | <Unnamed>
1486993 | 3 aukštas | <Unnamed>
1487462 | 3 aukštas | <Unnamed>
1488283 | 3 aukštas | <Unnamed>
1488356 | 3 aukštas | <Unnamed>
1488698 | 3 aukštas | <Unnamed>
1489035 | 3 aukštas | <Unnamed>
1489727 | 3 aukštas | <Unnamed>
1489849 | 3 aukštas | <Unnamed>
1489858 | 3 aukštas | <Unnamed>
1490026 | 3 aukštas | <Unnamed>
1490850 | 3 aukštas | <Unnamed>
1490887 | 3 aukštas | <Unnamed>
1491075 | 3 aukštas | <Unnamed>
1491351 | 3 aukštas | <Unnamed>
1491961 | 3 aukštas | <Unnamed>
1492330 | 3 aukštas | <Unnamed>
1492497 | 3 aukštas | <Unnamed>
1492990 | 3 aukštas | <Unnamed>
1506687 | 3 aukštas | <Unnamed>
1506898 | 3 aukštas | <Unnamed>
1511343 | 3 aukštas | <Unnamed>
1511380 | 3 aukštas | <Unnamed>
1511631 | 3 aukštas | <Unnamed>
1512162 | 3 aukštas | <Unnamed>
1512247 | 3 aukštas | <Unnamed>
1512935 | 3 aukštas | <Unnamed>
1517912 | 3 aukštas | <Unnamed>
1517928 | 3 aukštas | <Unnamed>
1519116 | 3 aukštas | <Unnamed>
1519151 | 3 aukštas | <Unnamed>
1519190 | 3 aukštas | <Unnamed>
1519282 | 3 aukštas | <Unnamed>
1519412 | 3 aukštas | <Unnamed>
1519492 | 3 aukštas | <Unnamed>
1519890 | 3 aukštas | <Unnamed>
1520328 | 3 aukštas | <Unnamed>
1520503 | 3 aukštas | <Unnamed>
1522287 | 3 aukštas | <Unnamed>
1523146 | 3 aukštas | <Unnamed>
1523170 | 3 aukštas | <Unnamed>
1523513 | 3 aukštas | <Unnamed>
1523871 | 3 aukštas | <Unnamed>
1524571 | 3 aukštas | <Unnamed>
1524720 | 3 aukštas | <Unnamed>
1525201 | 3 aukštas | <Unnamed>
1525631 | 3 aukštas | <Unnamed>
1525892 | 3 aukštas | <Unnamed>
1533134 | 4 aukštas | <Unnamed>
1533142 | 4 aukštas | <Unnamed>
1533531 | 4 aukštas | <Unnamed>
1534010 | 4 aukštas | <Unnamed>
1534044 | 4 aukštas | <Unnamed>
1534202 | 4 aukštas | <Unnamed>
1534687 | 4 aukštas | <Unnamed>
1535265 | 4 aukštas | <Unnamed>
1535332 | 4 aukštas | <Unnamed>
1535697 | 4 aukštas | <Unnamed>
1536146 | 4 aukštas | <Unnamed>
1536981 | 4 aukštas | <Unnamed>
1537207 | 4 aukštas | <Unnamed>
1537289 | 4 aukštas | <Unnamed>
1537297 | 4 aukštas | <Unnamed>
1537787 | 4 aukštas | <Unnamed>
1537924 | 4 aukštas | <Unnamed>
1542584 | 4 aukštas | <Unnamed>
1542647 | 4 aukštas | <Unnamed>
1542918 | 4 aukštas | <Unnamed>
1543055 | 4 aukštas | <Unnamed>
1544262 | 4 aukštas | <Unnamed>
1544289 | 4 aukštas | <Unnamed>
1544814 | 4 aukštas | <Unnamed>
1545626 | 4 aukštas | <Unnamed>
1545644 | 4 aukštas | <Unnamed>
1546059 | 4 aukštas | <Unnamed>
1546491 | 4 aukštas | <Unnamed>
1547227 | 4 aukštas | <Unnamed>
1547241 | 4 aukštas | <Unnamed>
1547487 | 4 aukštas | <Unnamed>
1547646 | 4 aukštas | <Unnamed>
1548209 | 4 aukštas | <Unnamed>
1548402 | 4 aukštas | <Unnamed>
1548461 | 4 aukštas | <Unnamed>
1548625 | 4 aukštas | <Unnamed>
1549274 | 4 aukštas | <Unnamed>
1549288 | 4 aukštas | <Unnamed>
1549685 | 4 aukštas | <Unnamed>
1549861 | 4 aukštas | <Unnamed>
1549879 | 4 aukštas | <Unnamed>
1550263 | 4 aukštas | <Unnamed>
1550970 | 4 aukštas | <Unnamed>
1550990 | 4 aukštas | <Unnamed>
1551314 | 4 aukštas | <Unnamed>
1551322 | 4 aukštas | <Unnamed>
1551806 | 4 aukštas | <Unnamed>
1552540 | 4 aukštas | <Unnamed>
1552569 | 4 aukštas | <Unnamed>
1552864 | 4 aukštas | <Unnamed>
1553494 | 4 aukštas | <Unnamed>
1553965 | 4 aukštas | <Unnamed>
1554361 | 4 aukštas | <Unnamed>
1554697 | 4 aukštas | <Unnamed>
1554965 | 4 aukštas | <Unnamed>
1554975 | 4 aukštas | <Unnamed>
1555103 | 4 aukštas | <Unnamed>
1555273 | 4 aukštas | <Unnamed>
1556276 | 4 aukštas | <Unnamed>
1556314 | 4 aukštas | <Unnamed>
1556874 | 4 aukštas | <Unnamed>
1556941 | 4 aukštas | <Unnamed>
1557153 | 4 aukštas | <Unnamed>
1557211 | 4 aukštas | <Unnamed>
1557453 | 4 aukštas | <Unnamed>
1557463 | 4 aukštas | <Unnamed>
1557896 | 4 aukštas | <Unnamed>
1558204 | 4 aukštas | <Unnamed>
1558288 | 4 aukštas | <Unnamed>
1561272 | 4 aukštas | <Unnamed>
1561310 | 4 aukštas | <Unnamed>
1599279 | Level 1 | <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 230+380 antviršinis:CEE COMBI / DK H6 / 400/16/5/44 (35)
Type - Material: Laminate, Navy (3), Plastic (2), Laminate, Red, Matte (2), <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: @Solar
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: CEE COMBI / DK H6 / 400/16/5/44; sets with these values: 2
Name (Kištukinis lizdas 230+380 antviršinis:CEE COMBI / DK H6 / 400/16/5/44:...) | In | Material
1180504 | Level 1
1182852 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1182946 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183319 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183329 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183337 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183345 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183485 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183840 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183882 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1183926 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184118 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184191 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184199 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184207 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184215 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184225 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184288 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184575 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184623 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184633 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184641 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184651 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184661 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184669 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184679 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184689 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184741 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184859 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184869 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1184879 | Level 1 | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1305825 | 3 aukštas | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1307588 | 3 aukštas | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1307596 | 3 aukštas | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>
1307604 | 3 aukštas | Laminate, Navy, Plastic, Laminate, Red, Matte, <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 3 lizdas:3 LIZDAS (26)
Type - Material: <Unnamed> (6)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 3 LIZDAS; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm
Name (Kištukinis lizdas 3 lizdas:3 LIZDAS:...) | In | Material
1351382 | 5 aukštas
1363477 | 5 aukštas | <Unnamed>
1363558 | 5 aukštas | <Unnamed>
1366704 | 5 aukštas | <Unnamed>
1366735 | 5 aukštas | <Unnamed>
1367034 | 5 aukštas | <Unnamed>
1367116 | 5 aukštas | <Unnamed>
1368465 | 5 aukštas | <Unnamed>
1368499 | 5 aukštas | <Unnamed>
1461460 | Level 2 | <Unnamed>
1461488 | Level 2 | <Unnamed>
1461769 | Level 2 | <Unnamed>
1462024 | Level 2 | <Unnamed>
1462628 | Level 2 | <Unnamed>
1462859 | Level 2 | <Unnamed>
1463028 | Level 2 | <Unnamed>
1463565 | Level 2 | <Unnamed>
1464157 | Level 2 | <Unnamed>
1464177 | Level 2 | <Unnamed>
1464354 | Level 2 | <Unnamed>
1464558 | Level 2 | <Unnamed>
1464728 | Level 2 | <Unnamed>
1465109 | Level 2 | <Unnamed>
1465291 | Level 2 | <Unnamed>
1465769 | Level 2 | <Unnamed>
1616513 | Level 2 | <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 4 lizdas (lovelyje):4 LIZDAI (20)
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 4 LIZDAI; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm
Name (Kištukinis lizdas 4 lizdas (lovelyje):4 LIZDAI:...) | In | Material
1507160 | 3 aukštas
1508111 | 3 aukštas | <Unnamed>
1509491 | 3 aukštas | <Unnamed>
1509686 | 3 aukštas | <Unnamed>
1509775 | 3 aukštas | <Unnamed>
1510377 | 3 aukštas | <Unnamed>
1526695 | 3 aukštas | <Unnamed>
1526721 | 3 aukštas | <Unnamed>
1527119 | 3 aukštas | <Unnamed>
1527633 | 3 aukštas | <Unnamed>
1527822 | 3 aukštas | <Unnamed>
1528462 | 3 aukštas | <Unnamed>
1528538 | 3 aukštas | <Unnamed>
1529207 | 3 aukštas | <Unnamed>
1529314 | 3 aukštas | <Unnamed>
1529695 | 3 aukštas | <Unnamed>
1559177 | 4 aukštas | <Unnamed>
1559845 | 4 aukštas | <Unnamed>
1559920 | 4 aukštas | <Unnamed>
1560642 | 4 aukštas | <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 4 lizdas:4 LIZDAI (171)
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 4 LIZDAI; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm
Name (Kištukinis lizdas 4 lizdas:4 LIZDAI:...) | In | Material
1225743 | Rūsys
1342459 | 5 aukštas | <Unnamed>
1343941 | 5 aukštas | <Unnamed>
1343973 | 5 aukštas | <Unnamed>
1344136 | 5 aukštas | <Unnamed>
1344621 | 5 aukštas | <Unnamed>
1344820 | 5 aukštas | <Unnamed>
1345187 | 5 aukštas | <Unnamed>
1345447 | 5 aukštas | <Unnamed>
1345531 | 5 aukštas | <Unnamed>
1345815 | 5 aukštas | <Unnamed>
1346248 | 5 aukštas | <Unnamed>
1346421 | 5 aukštas | <Unnamed>
1346529 | 5 aukštas | <Unnamed>
1347253 | 5 aukštas | <Unnamed>
1347575 | 5 aukštas | <Unnamed>
1347642 | 5 aukštas | <Unnamed>
1347990 | 5 aukštas | <Unnamed>
1348479 | 5 aukštas | <Unnamed>
1349440 | 5 aukštas | <Unnamed>
1349492 | 5 aukštas | <Unnamed>
1349562 | 5 aukštas | <Unnamed>
1350037 | 5 aukštas | <Unnamed>
1356032 | 5 aukštas | <Unnamed>
1356119 | 5 aukštas | <Unnamed>
1356336 | 5 aukštas | <Unnamed>
1356390 | 5 aukštas | <Unnamed>
1356731 | 5 aukštas | <Unnamed>
1356887 | 5 aukštas | <Unnamed>
1357002 | 5 aukštas | <Unnamed>
1357104 | 5 aukštas | <Unnamed>
1357721 | 5 aukštas | <Unnamed>
1359021 | 5 aukštas | <Unnamed>
1361386 | 5 aukštas | <Unnamed>
1361429 | 5 aukštas | <Unnamed>
1362115 | 5 aukštas | <Unnamed>
1368915 | 5 aukštas | <Unnamed>
1369682 | 5 aukštas | <Unnamed>
1370246 | 5 aukštas | <Unnamed>
1372469 | 5 aukštas | <Unnamed>
1373380 | 5 aukštas | <Unnamed>
1373447 | 5 aukštas | <Unnamed>
1403011 | Rūsys | <Unnamed>
1403539 | Rūsys | <Unnamed>
1403598 | Rūsys | <Unnamed>
1404625 | Rūsys | <Unnamed>
1404932 | Rūsys | <Unnamed>
1405820 | Level 1 | <Unnamed>
1407447 | Level 1 | <Unnamed>
1408124 | Level 1 | <Unnamed>
1408194 | Level 1 | <Unnamed>
1408352 | Level 1 | <Unnamed>
1408612 | Level 1 | <Unnamed>
1409013 | Level 1 | <Unnamed>
1409273 | Level 1 | <Unnamed>
1414751 | Level 1 | <Unnamed>
1414788 | Level 1 | <Unnamed>
1414923 | Level 1 | <Unnamed>
1415110 | Level 1 | <Unnamed>
1415178 | Level 1 | <Unnamed>
1415263 | Level 1 | <Unnamed>
1415468 | Level 1 | <Unnamed>
1415601 | Level 1 | <Unnamed>
1415918 | Level 1 | <Unnamed>
1416012 | Level 1 | <Unnamed>
1419938 | Level 1 | <Unnamed>
1420058 | Level 1 | <Unnamed>
1420071 | Level 1 | <Unnamed>
1420293 | Level 1 | <Unnamed>
1428707 | Level 2 | <Unnamed>
1438885 | Level 2 | <Unnamed>
1438986 | Level 2 | <Unnamed>
1440243 | Level 2 | <Unnamed>
1440420 | Level 2 | <Unnamed>
1440481 | Level 2 | <Unnamed>
1440798 | Level 2 | <Unnamed>
1441442 | Level 2 | <Unnamed>
1441502 | Level 2 | <Unnamed>
1441588 | Level 2 | <Unnamed>
1441632 | Level 2 | <Unnamed>
1441812 | Level 2 | <Unnamed>
1441867 | Level 2 | <Unnamed>
1441963 | Level 2 | <Unnamed>
1442155 | Level 2 | <Unnamed>
1442194 | Level 2 | <Unnamed>
1443007 | Level 2 | <Unnamed>
1443067 | Level 2 | <Unnamed>
1443706 | Level 2 | <Unnamed>
1446919 | Level 2 | <Unnamed>
1446961 | Level 2 | <Unnamed>
1447177 | Level 2 | <Unnamed>
1447382 | Level 2 | <Unnamed>
1447730 | Level 2 | <Unnamed>
1448845 | Level 2 | <Unnamed>
1448904 | Level 2 | <Unnamed>
1449288 | Level 2 | <Unnamed>
1449775 | Level 2 | <Unnamed>
1450542 | Level 2 | <Unnamed>
1450606 | Level 2 | <Unnamed>
1450923 | Level 2 | <Unnamed>
1451298 | Level 2 | <Unnamed>
1452019 | Level 2 | <Unnamed>
1457311 | Level 2 | <Unnamed>
1457338 | Level 2 | <Unnamed>
1458499 | Level 2 | <Unnamed>
1458515 | Level 2 | <Unnamed>
1467465 | Level 2 | <Unnamed>
1467701 | Level 2 | <Unnamed>
1468592 | Level 2 | <Unnamed>
1468937 | Level 2 | <Unnamed>
1469013 | Level 2 | <Unnamed>
1469056 | Level 2 | <Unnamed>
1472010 | Level 2 | <Unnamed>
1472052 | Level 2 | <Unnamed>
1472866 | Level 2 | <Unnamed>
1473159 | Level 2 | <Unnamed>
1479353 | 3 aukštas | <Unnamed>
1479883 | 3 aukštas | <Unnamed>
1481214 | 3 aukštas | <Unnamed>
1481238 | 3 aukštas | <Unnamed>
1482696 | 3 aukštas | <Unnamed>
1482716 | 3 aukštas | <Unnamed>
1483010 | 3 aukštas | <Unnamed>
1483375 | 3 aukštas | <Unnamed>
1483915 | 3 aukštas | <Unnamed>
1484208 | 3 aukštas | <Unnamed>
1487035 | 3 aukštas | <Unnamed>
1487055 | 3 aukštas | <Unnamed>
1487269 | 3 aukštas | <Unnamed>
1487672 | 3 aukštas | <Unnamed>
1487720 | 3 aukštas | <Unnamed>
1488141 | 3 aukštas | <Unnamed>
1490581 | 3 aukštas | <Unnamed>
1518527 | 3 aukštas | <Unnamed>
1526434 | 3 aukštas | <Unnamed>
1526549 | 3 aukštas | <Unnamed>
1531256 | 4 aukštas | <Unnamed>
1531367 | 4 aukštas | <Unnamed>
1531463 | 4 aukštas | <Unnamed>
1531535 | 4 aukštas | <Unnamed>
1531935 | 4 aukštas | <Unnamed>
1531937 | 4 aukštas | <Unnamed>
1531938 | 4 aukštas | <Unnamed>
1531940 | 4 aukštas | <Unnamed>
1531949 | 4 aukštas | <Unnamed>
1532062 | 4 aukštas | <Unnamed>
1532335 | 4 aukštas | <Unnamed>
1532337 | 4 aukštas | <Unnamed>
1532422 | 4 aukštas | <Unnamed>
1532480 | 4 aukštas | <Unnamed>
1533690 | 4 aukštas | <Unnamed>
1533782 | 4 aukštas | <Unnamed>
1538381 | 4 aukštas | <Unnamed>
1538472 | 4 aukštas | <Unnamed>
1538648 | 4 aukštas | <Unnamed>
1539040 | 4 aukštas | <Unnamed>
1539595 | 4 aukštas | <Unnamed>
1540105 | 4 aukštas | <Unnamed>
1540771 | 4 aukštas | <Unnamed>
1541042 | 4 aukštas | <Unnamed>
1541401 | 4 aukštas | <Unnamed>
1541604 | 4 aukštas | <Unnamed>
1542007 | 4 aukštas | <Unnamed>
1557943 | 4 aukštas | <Unnamed>
1558653 | 4 aukštas | <Unnamed>
1558711 | 4 aukštas | <Unnamed>
1558818 | 4 aukštas | <Unnamed>
1560964 | 4 aukštas | <Unnamed>
1561069 | 4 aukštas | <Unnamed>
1561100 | 4 aukštas | <Unnamed>
1616409 | Level 2 | <Unnamed>

# IfcBuildingElementProxy: Kištukinis lizdas 5 lizdas:5 LIZDAS, Kištukinis lizdas 5 lizdas:5 LIZDAS:1247249
In: Level 2
Type - Material: <Unnamed> (10)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: 5 LIZDAS; sets with these values: 2
Pset_ProvisionForVoid - Width: 70 mm; Height: 66.1734 mm; Depth: 53.975 mm

# IfcBuildingElementProxy: M_Lighting and Appliance Panelboard - 480V MLO:125 A (71)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - Pset_ProvisionForVoid - Width: 400 mm; Depth: 146.1 mm
Pset_BuildingElementProxyCommon - Reference: 125 A; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.12192 mm; Height: 660.4 mm
Name (M_Lighting and Appliance Panelboard - 480V MLO:...) | In
JS-ŠP:1075327 | Rūsys | Group: <unnamed>
VAS-ŠP:1076224 | Rūsys
LFAS-1:1077163 | Rūsys
AS-0.1:1078256 | Rūsys
VAS-GS:1079352 | Rūsys
JS-5.1:1081965 | 5 aukštas
KJS-5.1:1085390 | 5 aukštas
JS-1.1:1093933 | Level 1
AS-1.1:1093997 | Level 1
JS-1.2:1095075 | Level 1
AS-1.2:1095184 | Level 1
AS-2.2:1095696 | Level 2
JS-2.2:1095746 | Level 2
JS-2.1:1096341 | Level 2
AS-2.1:1096402 | Level 2
JS-3.1:1097150 | 3 aukštas
AS-3.1:1097176 | 3 aukštas
JS-3.2:1098036 | 3 aukštas
AS-3.2:1098075 | 3 aukštas
JS-4.1:1098787 | 4 aukštas
AS-4.1:1098840 | 4 aukštas
JS-4.2:1099392 | 4 aukštas
AS-4.2:1099451 | 4 aukštas
JS-RP.1:1185016 | Level 1
JS-ŠM:1210671 | Rūsys
JS-VN:1210757 | Rūsys
JS-lift.:1374981 | Rūsys
AAS-0.1:1395071 | Rūsys
KJS-1.2:1396089 | Level 1
KJS-1.1:1396450 | Level 1
KJS-2.1:1396676 | Level 2
ST-2.1:1396678 | Level 2
KJS-2.2:1396818 | Level 2
ST-2.2:1396820 | Level 2
KJS-3.2:1397017 | 3 aukštas
ST-3.2:1397019 | 3 aukštas
KJS-4.2:1397240 | 4 aukštas
ST-4.2:1397242 | 4 aukštas
KJS-4.1:1397411 | 4 aukštas
ST-4.1:1397413 | 4 aukštas
AS-5.1:1398070 | 5 aukštas
AAS-5.1:1398072 | 5 aukštas
ST-3.1:1398466 | 3 aukštas
KJS-3.1:1398468 | 3 aukštas
JS-VP:1562156 | Rūsys
VAS-ŠM:1562601 | Rūsys
AAS-1.1:1562626 | Level 1
AAS-4.1:1562747 | 4 aukštas
AAS-3.1:1563122 | 3 aukštas
JS-Lab.:1563259 | 5 aukštas
ST-2.3:1580971 | Level 2
JS-UPS-1:1593852 | Rūsys
JS-UPS-2:1594188 | Rūsys
JS-UPS-3:1594197 | Rūsys
JS-UPS-4:1594205 | Rūsys
AAS-1.2:1595313 | Level 1
VAS-DŠ:1597871 | Rūsys
JS-UPS-5:1617834 | Rūsys
VAS-AHU0.1:1620926 | Rūsys
VAS-ŠVOK R:1620934 | Rūsys
JS-ŠVOK:1621223 | Rūsys
VAS-ŠVOK 1.2:1621487 | Level 1
VAS-ŠVOK 1.1:1621549 | Level 1
VAS-ŠVOK 2.2:1621650 | Level 2
VAS-ŠVOK 2.1:1621790 | Level 2
VAS-ŠVOK 3.1:1621891 | 3 aukštas
VAS-ŠVOK 3.2:1622078 | 3 aukštas
VAS-ŠVOK 4.1:1622246 | 4 aukštas
VAS-ŠVOK 4.2:1622361 | 4 aukštas
VAS-ŠVOK 5:1622435 | 5 aukštas
JS-AHU:1623174 | 5 aukštas

# IfcBuildingElementProxy: M_Lighting and Appliance Panelboard - 480V MLO:250 A (2)
In: Rūsys
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - Pset_ProvisionForVoid - Width: 400 mm; Depth: 146.1 mm
Pset_BuildingElementProxyCommon - Reference: 250 A; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.12192 mm; Height: 965.2 mm
Name (M_Lighting and Appliance Panelboard - 480V MLO:...)
JS-0.1:1078325
JS-RP.0:1185129

# IfcBuildingElementProxy: Paskirstymo skydas (ant pagrindo):Paskirstymo skydas (montavimas ant pagrindo) IP55 (2)
In: Rūsys
Type - Material: <Unnamed> (16), Siemens S8 Plaste Schwarz, Siemens RAL 7035 (2), Glas unsichtbar
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Paskirstymo skydas (montavimas ant pagrindo) IP55; sets with these values: 2
Pset_ProvisionForVoid - Width: 2050 mm; Height: 1950 mm; Depth: 2050 mm
Name (Paskirstymo skydas (ant pagrindo):...)
ĮPS-1:903913
ĮPS-2:904341 | Material: <Unnamed>, Siemens S8 Plaste Schwarz, Siemens RAL 7035, Glas unsichtbar

# IfcBuildingElementProxy: Potencialų suvienodinimo šyna (medicininei įrangai):Potencialų suvienodinimo šyna (medicininei įrangai) (13)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Potencialų suvienodinimo šyna (medicininei įrangai); sets with these values: 2
Pset_ProvisionForVoid - Width: 188 mm; Height: 52 mm; Depth: 43 mm
Name (Potencialų suvienodinimo šyna (medicininei įrangai):Potencialų suvienodinimo šyna (medicininei įrangai):...) | In
1065790 | Level 1
1070995 | Level 1
1071361 | Level 2
1071831 | Level 2
1072029 | 3 aukštas
1072120 | 3 aukštas
1072554 | 4 aukštas
1072901 | 4 aukštas
1073210 | 5 aukštas
1262889 | Level 2
1263178 | Level 2
1263278 | Level 2
1263524 | Level 2

# IfcBuildingElementProxy: Potencialų suvienodinimo šyna:Potencialų suvienodinimo šyna (15)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Potencialų suvienodinimo šyna; sets with these values: 2
Pset_ProvisionForVoid - Width: 188 mm; Height: 52 mm; Depth: 43 mm
Name (Potencialų suvienodinimo šyna:Potencialų suvienodinimo šyna:...) | In
972011 | Rūsys
973122 | Rūsys
973180 | Rūsys
974081 | Rūsys
977676 | Rūsys
1017091 | Rūsys
1065837 | Level 1
1070858 | Level 1
1071272 | Level 2
1071825 | Level 2
1072010 | 3 aukštas
1072173 | 3 aukštas
1072561 | 4 aukštas
1072628 | 4 aukštas
1073299 | 5 aukštas

# IfcBuildingElementProxy: Skydelis su kištukiniais lizdais:Default (15)
In: Rūsys
Type - Material: light grey (RAL 7035) (58), Glass (2)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Type - Pset_ProvisionForVoid - Width: 236 mm; Height: 460 mm; Depth: 160 mm
Pset_BuildingElementProxyCommon - Reference: Default; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.0719328 mm
Name (Skydelis su kištukiniais lizdais:Default:...) | Material
1165660
1174249 | light grey (RAL 7035), Glass
1174259 | light grey (RAL 7035), Glass
1174269 | light grey (RAL 7035), Glass
1174277 | light grey (RAL 7035), Glass
1174287 | light grey (RAL 7035), Glass
1174357 | light grey (RAL 7035), Glass
1174494 | light grey (RAL 7035), Glass
1174502 | light grey (RAL 7035), Glass
1174516 | light grey (RAL 7035), Glass
1174524 | light grey (RAL 7035), Glass
1174532 | light grey (RAL 7035), Glass
1174542 | light grey (RAL 7035), Glass
1174556 | light grey (RAL 7035), Glass
1174809 | light grey (RAL 7035), Glass

# IfcBuildingElementProxy: Spec. patalpų šviesinė spinduliuotės indikacija:Siren (9)
In: Level 2
Type - Material: Plastic - Comelit - Red, Plastic - Comelit - White
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: Siren; sets with these values: 2
Name (Spec. patalpų šviesinė spinduliuotės indikacija:Siren:...)
1287406
1287701
1287780
1288261
1288504
1288874
1289669
1289890
1290165

# IfcBuildingElementProxy: Stiebo virsus:Family1, Stiebo virsus:Family1:1041731
In: Stogas
Type - Classification: ﻿﻿ ​ ​ ​ ﻿ ﻿ ​ ​ ​ ﻿﻿ (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Diameter: 16.1703 mm
Pset_BuildingElementProxyCommon - Reference: Family1; sets with these values: 2

# IfcBuildingElementProxy: UPS:80-250 kW UPS (5)
In: Rūsys
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: 80-250 kW UPS; sets with these values: 2
Name (UPS:...)
UPS-1:1582590
UPS-2:1593061
UPS-3:1593069
UPS-4:1593077
UPS-4:1617832

# IfcBuildingElementProxy: ĮPS:225 A (4)
In: Level 2
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - Pset_ProvisionForVoid - Width: 1000 mm; Depth: 400 mm
Pset_BuildingElementProxyCommon - Reference: 225 A; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.3048 mm; Height: 812.8 mm
Name (ĮPS:...)
JS-RG1 (1 kat.):1263945
JS-RG2 (1 kat.):1264089
JS-KT1 (1 kat.):1264215
JS-KT2 (1 kat.):1264387

# IfcDistributionPort (1919)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x InPort_915272
2 x OutPort_915299
OutPort_915932
InPort_915286
Port_915286
Port_915932
Port_916281
InPort_916281
2 x OutPort_916287
2 x InPort_916284
OutPort_916817
Port_916313
InPort_916313
2 x OutPort_916786
InPort_916331
2 x OutPort_916337
Port_916331
2 x InPort_916334
OutPort_916972
2 x InPort_916352
OutPort_916941
Port_916370
InPort_916370
2 x OutPort_916376
2 x InPort_916373
OutPort_917017
Port_916388
InPort_916388
2 x OutPort_916394
2 x InPort_916391
OutPort_917044
Port_916817
Port_916941
Port_916972
Port_917017
Port_917044
2 x InPort_918266
2 x OutPort_1380614
2 x OutPort_1383165
2 x InPort_918274
2 x OutPort_918763
2 x OutPort_1380616
2 x InPort_918315
2 x OutPort_1383201
2 x OutPort_1380397
2 x InPort_918755
OutPort_1382854
2 x InPort_919122
OutPort_1382827
OutPort_919130
InPort_919130
OutPort_1380215
2 x InPort_960866
OutPort_964684
2 x OutPort_966021
2 x InPort_962181
OutPort_962246
OutPort_1336243
Port_962246
2 x InPort_964113
2 x OutPort_1576592
OutPort_964559
InPort_964559
OutPort_964622
InPort_964622
2 x OutPort_1002455
InPort_964684
2 x OutPort_998085
2 x InPort_964737
2 x OutPort_998084
2 x InPort_964872
OutPort_964881
2 x OutPort_965172
2 x InPort_964881
OutPort_966028
OutPort_964882
InPort_964882
2 x OutPort_965774
2 x InPort_965149
2 x OutPort_1003033
InPort_965768
Port_965768
InPort_965774
OutPort_965775
InPort_965775
2 x OutPort_1576984
InPort_965880
2 x OutPort_1577543
Port_965880
InPort_966017
Port_966017
InPort_966021
OutPort_966022
InPort_966022
2 x OutPort_966027
InPort_966023
Port_966023
InPort_966027
2 x OutPort_1002973
InPort_966028
2 x OutPort_1002972
2 x Port_968920
2 x Port_968928
2 x Port_968942
2 x Port_968952
2 x Port_969313
2 x Port_969581
2 x Port_969729
2 x InPort_975088
2 x OutPort_976202
2 x OutPort_975105
2 x InPort_975095
2 x OutPort_995595
2 x InPort_975107
2 x OutPort_975127
2 x OutPort_976632
2 x InPort_975119
2 x OutPort_976005
Port_975997
InPort_975997
Port_976195
InPort_976195
2 x InPort_976465
2 x OutPort_976494
2 x InPort_976480
2 x OutPort_976677
2 x OutPort_976498
2 x InPort_976485
InPort_976494
OutPort_976495
InPort_976495
2 x OutPort_976703
InPort_976632
2 x OutPort_1375358
2 x InPort_976633
OutPort_1375357
Port_976670
InPort_976670
InPort_976696
Port_976696
2 x InPort_976765
2 x OutPort_976992
2 x OutPort_977334
Port_976850
InPort_976850
2 x OutPort_977311
Port_976901
InPort_976901
Port_976923
InPort_976923
OutPort_976974
InPort_976974
2 x OutPort_976993
InPort_976992
2 x InPort_977052
OutPort_977309
2 x OutPort_977423
2 x InPort_977063
InPort_977309
2 x OutPort_977335
InPort_977334
InPort_977373
Port_977373
2 x InPort_980730
OutPort_981990
OutPort_980981
InPort_980981
2 x OutPort_1355497
2 x InPort_981848
2 x OutPort_1091863
2 x OutPort_1090794
InPort_981990
3 x InPort_982749
OutPort_982850
OutPort_983936
OutPort_982822
Port_982822
Port_982850
InPort_983936
2 x OutPort_1029130
2 x InPort_984222
OutPort_984834
OutPort_1023914
InPort_984834
OutPort_985047
InPort_985047
2 x OutPort_1025098
3 x InPort_985460
OutPort_985463
2 x OutPort_987335
OutPort_985461
Port_985461
Port_985463
2 x InPort_985468
OutPort_986776
OutPort_985474
InPort_985474
3 x OutPort_1028062
InPort_985476
Port_985476
2 x InPort_986776
2 x OutPort_1027603
OutPort_986895
Port_986895
2 x InPort_986934
OutPort_987020
OutPort_1027337
2 x InPort_987020
OutPort_987127
Port_987127
2 x InPort_987652
2 x OutPort_1010200
OutPort_987841
InPort_987841
OutPort_987944
Port_987944
Port_988072
InPort_988072
2 x OutPort_1009807
2 x InPort_988668
OutPort_990165
OutPort_991205
2 x InPort_988725
OutPort_990036
OutPort_991247
2 x InPort_988746
2 x OutPort_1007951
2 x OutPort_989008
2 x InPort_988763
OutPort_989155
2 x InPort_988778
2 x OutPort_989843
2 x OutPort_1096882
Port_988820
InPort_988820
2 x OutPort_993204
InPort_989138
2 x OutPort_993391
Port_989138
2 x InPort_989155
OutPort_989393
2 x InPort_989352
2 x OutPort_989490
InPort_989365
2 x OutPort_1015465
Port_989365
InPort_989393
2 x InPort_989490
InPort_989843
2 x OutPort_992350
Port_989877
InPort_989877
2 x InPort_990036
2 x OutPort_990405
2 x OutPort_990339
InPort_990165
2 x InPort_990177
OutPort_1008417
InPort_991205
2 x OutPort_991415
2 x InPort_991247
OutPort_991311
InPort_991311
2 x InPort_997910
2 x OutPort_1030806
OutPort_1004031
2 x InPort_998076
2 x OutPort_1016288
InPort_998084
2 x InPort_1002702
InPort_1002972
InPort_1004031
2 x InPort_1005979
OutPort_1006484
OutPort_1034513
InPort_1006484
2 x OutPort_1019873
3 x InPort_1007537
OutPort_1036199
2 x OutPort_1027475
OutPort_1031553
3 x InPort_1007711
OutPort_1034413
OutPort_1033713
2 x OutPort_1008621
InPort_1007951
OutPort_1008077
InPort_1008077
OutPort_1008102
InPort_1008102
OutPort_1008208
Port_1008208
InPort_1008417
OutPort_1008539
2 x InPort_1008539
2 x OutPort_1097001
2 x InPort_1009527
OutPort_1009610
OutPort_1009528
InPort_1009528
Port_1009610
InPort_1009807
OutPort_1010009
Port_1010009
Port_1010198
InPort_1010198
InPort_1010200
OutPort_1010381
Port_1010381
2 x Port_1011232
2 x InPort_1018281
OutPort_1019767
2 x InPort_1019767
OutPort_1020119
InPort_1020119
2 x OutPort_1576687
2 x InPort_1020625
2 x OutPort_1355222
OutPort_1086417
2 x InPort_1021643
OutPort_1023013
OutPort_1022008
InPort_1022008
2 x OutPort_1087561
InPort_1023013
OutPort_1025381
2 x InPort_1023914
2 x OutPort_1027031
2 x InPort_1024102
OutPort_1024535
OutPort_1024179
InPort_1024179
OutPort_1024299
InPort_1024299
2 x InPort_1024535
OutPort_1024778
OutPort_1025057
Port_1024778
InPort_1025057
InPort_1025098
OutPort_1084437
InPort_1025381
OutPort_1026238
InPort_1026238
2 x OutPort_1084547
3 x InPort_1026698
2 x OutPort_1028998
2 x OutPort_1033339
Port_1026950
InPort_1026950
2 x InPort_1027337
2 x InPort_1027960
OutPort_1028013
OutPort_1028348
InPort_1028013
Port_1028348
2 x InPort_1031201
2 x OutPort_1613716
2 x OutPort_1613420
InPort_1031205
OutPort_1031211
Port_1031205
InPort_1031211
2 x OutPort_1613717
InPort_1031284
2 x OutPort_1612961
Port_1031284
InPort_1031553
OutPort_1033200
InPort_1033200
Port_1033713
Port_1034413
Port_1034513
Port_1036199
2 x InPort_1059837
2 x OutPort_1062989
2 x OutPort_1059857
2 x InPort_1059846
2 x OutPort_1060358
2 x InPort_1059900
2 x OutPort_1062991
2 x InPort_1059914
2 x OutPort_1060751
2 x InPort_1060351
2 x OutPort_1060438
InPort_1060431
Port_1060431
2 x InPort_1060744
2 x OutPort_1060759
Port_1060754
InPort_1060754
Port_1075327
Port_1076224
Port_1077163
Port_1078256
Port_1078325
Port_1079352
Port_1081965
InPort_1084437
Port_1085390
InPort_1086417
OutPort_1087404
InPort_1087404
OutPort_1087436
InPort_1087436
2 x InPort_1090689
InPort_1090794
OutPort_1090915
Port_1090915
Port_1093308
InPort_1093308
Port_1093933
Port_1093997
Port_1095075
Port_1095184
Port_1095696
Port_1095746
Port_1096341
Port_1096402
InPort_1096807
Port_1096807
InPort_1096882
Port_1097150
Port_1097176
Port_1098036
Port_1098075
Port_1098787
Port_1098840
Port_1099392
Port_1099451
2 x Port_1180504
2 x Port_1182852
2 x Port_1182946
2 x Port_1183319
2 x Port_1183329
2 x Port_1183337
2 x Port_1183345
2 x Port_1183485
2 x Port_1183840
2 x Port_1183882
2 x Port_1183926
2 x Port_1184118
2 x Port_1184191
2 x Port_1184199
2 x Port_1184207
2 x Port_1184215
2 x Port_1184225
2 x Port_1184288
2 x Port_1184575
2 x Port_1184623
2 x Port_1184633
2 x Port_1184641
2 x Port_1184651
2 x Port_1184661
2 x Port_1184669
2 x Port_1184679
2 x Port_1184689
2 x Port_1184741
2 x Port_1184859
2 x Port_1184869
2 x Port_1184879
Port_1185016
Port_1185129
Port_1186440
Port_1210671
Port_1210757
Port_1213840
Port_1218116
Port_1221058
Port_1225644
Port_1225743
Port_1225909
