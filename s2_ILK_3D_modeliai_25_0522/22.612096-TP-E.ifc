Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcDistributionPort (1919)
Name
Port_1226117
Port_1226291
Port_1226356
Port_1226560
Port_1226602
Port_1226653
Port_1226696
Port_1227123
Port_1227137
Port_1227194
Port_1227529
Port_1227604
Port_1227882
Port_1227936
Port_1228018
Port_1228177
Port_1231301
Port_1231346
Port_1231565
Port_1231627
Port_1231946
Port_1232203
Port_1232529
Port_1232576
Port_1234048
Port_1234141
Port_1234173
Port_1234926
Port_1236372
Port_1237266
Port_1237480
Port_1237491
Port_1237502
Port_1237513
Port_1237533
Port_1237642
Port_1237650
Port_1237657
Port_1237664
Port_1237677
Port_1238527
Port_1238538
Port_1238549
Port_1238919
Port_1239121
Port_1239927
Port_1239938
Port_1239948
Port_1240035
Port_1240150
Port_1240440
Port_1241945
Port_1242054
Port_1242385
Port_1242386
Port_1242614
Port_1242615
Port_1242762
Port_1242794
Port_1243775
Port_1243891
Port_1244203
Port_1245187
Port_1245491
Port_1245499
Port_1245509
Port_1245559
Port_1245740
Port_1245942
Port_1245953
Port_1247249
Port_1247437
Port_1247562
Port_1247572
Port_1247580
Port_1247605
Port_1247671
Port_1247955
Port_1249093
Port_1249287
Port_1249366
Port_1249401
Port_1249498
Port_1249547
Port_1249642
Port_1249703
Port_1249796
Port_1249959
Port_1250325
Port_1250512
Port_1252353
Port_1252619
Port_1253417
Port_1253930
Port_1254695
Port_1254723
Port_1254944
Port_1255234
Port_1255437
Port_1255753
Port_1256190
Port_1256704
Port_1256864
Port_1256909
Port_1257004
Port_1257128
Port_1257475
Port_1257659
Port_1258086
Port_1258371
Port_1258384
Port_1258393
Port_1258402
Port_1258413
Port_1258422
Port_1258460
Port_1258541
Port_1258696
Port_1259175
Port_1259701
Port_1260206
Port_1260581
Port_1261397
Port_1262016
Port_1262637
Port_1262707
Port_1263945
Port_1264089
Port_1264215
Port_1264387
Port_1265296
Port_1265358
Port_1266104
Port_1266169
Port_1266688
Port_1266754
Port_1266946
Port_1266983
Port_1267054
Port_1267124
Port_1267233
Port_1267434
Port_1267834
Port_1268128
Port_1268185
Port_1268390
Port_1268422
Port_1268430
Port_1268713
Port_1268929
Port_1269042
Port_1269210
Port_1269582
Port_1269874
Port_1270071
Port_1270518
Port_1270599
Port_1270757
Port_1271148
Port_1271243
Port_1271329
Port_1271573
Port_1271608
Port_1271682
Port_1271721
Port_1271770
Port_1271980
Port_1272004
Port_1272225
Port_1272430
Port_1272524
Port_1272701
Port_1272782
Port_1272793
Port_1272826
Port_1272835
Port_1272844
Port_1272872
Port_1273253
Port_1273646
Port_1273655
Port_1273664
Port_1273673
Port_1274196
Port_1274320
Port_1274512
Port_1274657
Port_1274790
Port_1275075
2 x Port_1287406
2 x Port_1287701
2 x Port_1287780
2 x Port_1288261
2 x Port_1288504
2 x Port_1288874
2 x Port_1289669
2 x Port_1289890
2 x Port_1290165
Port_1290682
Port_1290742
Port_1290879
Port_1291887
Port_1292426
Port_1292537
Port_1292929
Port_1292942
Port_1292955
Port_1292964
Port_1292999
Port_1293295
Port_1293305
Port_1293346
Port_1293763
Port_1293838
Port_1293873
Port_1294161
Port_1294355
Port_1294425
Port_1294802
Port_1295033
Port_1295044
Port_1295053
Port_1295064
Port_1295075
Port_1295084
Port_1295096
Port_1295135
Port_1295258
Port_1295415
Port_1295516
Port_1295930
Port_1296191
Port_1296200
Port_1296209
Port_1296220
Port_1296229
Port_1296242
Port_1296253
Port_1296296
Port_1296424
Port_1296514
Port_1296664
Port_1296844
Port_1297530
Port_1297605
Port_1298537
Port_1300843
Port_1302167
Port_1302595
Port_1302884
Port_1302970
Port_1303056
Port_1303101
Port_1303172
Port_1303386
Port_1303462
Port_1303614
Port_1303788
Port_1304009
Port_1304038
Port_1304053
Port_1304064
Port_1304075
Port_1304084
2 x Port_1305825
2 x Port_1307588
2 x Port_1307596
2 x Port_1307604
Port_1308603
Port_1308932
Port_1309175
Port_1309229
Port_1309471
Port_1309718
Port_1309987
Port_1310400
Port_1310605
Port_1310968
Port_1311039
Port_1311262
Port_1311365
Port_1311584
Port_1311672
Port_1311827
Port_1312042
Port_1312615
Port_1312653
Port_1312769
Port_1312983
Port_1313410
Port_1313510
Port_1314190
Port_1314403
Port_1314927
Port_1315188
Port_1315565
Port_1316546
Port_1316633
Port_1316748
Port_1317031
Port_1317194
Port_1317199
Port_1317364
Port_1317369
Port_1317527
Port_1317532
Port_1317816
Port_1317892
Port_1317951
Port_1318356
Port_1318539
Port_1318864
Port_1318954
Port_1319799
Port_1320903
Port_1320908
Port_1320913
Port_1321077
Port_1321082
Port_1321097
Port_1321102
Port_1321390
Port_1321859
Port_1321929
Port_1321934
Port_1322081
Port_1322086
Port_1322204
Port_1322345
Port_1322388
Port_1322609
Port_1322677
Port_1322793
Port_1322816
Port_1322878
Port_1323058
Port_1323136
Port_1323274
InPort_1336243
Port_1340481
Port_1340511
Port_1340935
Port_1341073
Port_1341274
Port_1341985
Port_1342021
Port_1342382
Port_1342459
Port_1343941
Port_1343973
Port_1344136
Port_1344621
Port_1344820
Port_1345187
Port_1345447
Port_1345531
Port_1345815
Port_1346248
Port_1346421
Port_1346529
Port_1347253
Port_1347575
Port_1347642
Port_1347990
Port_1348479
Port_1349440
Port_1349492
Port_1349562
Port_1350037
Port_1350459
Port_1350532
Port_1350771
Port_1350974
Port_1351143
Port_1351382
Port_1351585
Port_1353284
Port_1353522
Port_1353925
Port_1353957
Port_1354296
Port_1354525
InPort_1355222
2 x OutPort_1355900
InPort_1355497
Port_1355979
Port_1356032
Port_1356119
Port_1356269
Port_1356295
Port_1356336
Port_1356390
Port_1356731
Port_1356887
Port_1357002
Port_1357104
Port_1357515
Port_1357702
Port_1357721
Port_1358436
Port_1358519
Port_1358781
Port_1359021
Port_1359238
Port_1359285
Port_1359507
Port_1359578
Port_1359623
Port_1359918
Port_1359968
Port_1360195
Port_1360280
Port_1360819
Port_1361182
Port_1361386
Port_1361429
Port_1362115
Port_1362339
Port_1362434
Port_1362472
Port_1362637
Port_1362794
Port_1362851
Port_1362966
Port_1363477
Port_1363558
Port_1364153
Port_1364218
Port_1364291
Port_1364414
Port_1364631
Port_1364687
Port_1364906
Port_1365141
Port_1365301
Port_1365574
Port_1365674
Port_1365909
Port_1366024
Port_1366077
Port_1366626
Port_1366704
Port_1366735
Port_1367034
Port_1367116
Port_1367582
Port_1367717
Port_1367888
Port_1368325
Port_1368465
Port_1368499
Port_1368915
Port_1369218
Port_1369340
Port_1369436
Port_1369443
Port_1369450
Port_1369682
Port_1369851
Port_1369898
Port_1370246
Port_1370319
Port_1370369
Port_1370540
Port_1370963
Port_1371114
Port_1371309
Port_1371538
Port_1372018
Port_1372469
Port_1373241
Port_1373380
Port_1373447
Port_1373829
Port_1373883
Port_1373975
Port_1374147
Port_1374302
Port_1374597
Port_1374981
2 x InPort_1375357
OutPort_1375360
InPort_1375360
2 x OutPort_1375379
2 x InPort_1375370
2 x OutPort_1375386
Port_1375381
InPort_1375381
Port_1375836
Port_1375999
Port_1376607
Port_1376955
Port_1377183
Port_1377362
Port_1377959
2 x InPort_1379888
2 x InPort_1379923
2 x OutPort_1380399
InPort_1380215
Port_1382827
Port_1382854
Port_1383155
InPort_1383155
InPort_1383193
Port_1383193
Port_1390147
Port_1390314
Port_1395071
Port_1396089
Port_1396450
Port_1396676
Port_1396678
Port_1396818
Port_1396820
Port_1397017
Port_1397019
Port_1397240
Port_1397242
Port_1397411
Port_1397413
Port_1398070
Port_1398072
Port_1398466
Port_1398468
Port_1399195
Port_1403011
Port_1403093
Port_1403114
Port_1403449
Port_1403539
Port_1403598
Port_1404625
Port_1404713
Port_1404932
Port_1405243
Port_1405331
Port_1405507
Port_1405604
Port_1405820
Port_1407447
Port_1407997
Port_1408124
Port_1408194
Port_1408352
Port_1408612
Port_1409013
Port_1409091
Port_1409151
Port_1409273
Port_1409607
Port_1412764
Port_1412860
Port_1413279
Port_1413839
Port_1413980
Port_1414059
Port_1414547
Port_1414751
Port_1414788
Port_1414923
Port_1415110
Port_1415178
Port_1415263
Port_1415468
Port_1415601
Port_1415825
Port_1415918
Port_1416012
Port_1416145
Port_1416265
Port_1416486
Port_1416588
Port_1417027
Port_1417127
Port_1417640
Port_1417668
Port_1418245
Port_1418281
Port_1418712
Port_1418725
Port_1419370
Port_1419420
Port_1419791
Port_1419938
Port_1420058
Port_1420071
Port_1420293
Port_1420371
Port_1420513
Port_1420600
Port_1420816
Port_1421426
Port_1421436
Port_1421823
Port_1422880
Port_1422902
Port_1423090
Port_1425803
Port_1425893
Port_1426263
Port_1426271
Port_1426402
Port_1426788
Port_1428022
Port_1428046
Port_1428426
Port_1428707
Port_1429050
Port_1429208
Port_1429530
Port_1429821
Port_1429923
Port_1429965
Port_1430182
Port_1430300
Port_1430320
Port_1430491
Port_1430582
Port_1430631
Port_1430758
Port_1431081
Port_1431992
Port_1432547
Port_1432800
Port_1432840
Port_1432866
Port_1433196
Port_1433228
Port_1433521
Port_1433851
Port_1435193
Port_1435217
Port_1436086
Port_1436128
Port_1436469
Port_1436482
Port_1436664
Port_1436860
Port_1437140
Port_1437296
Port_1437381
Port_1437414
Port_1438182
Port_1438343
Port_1438387
Port_1438476
Port_1438707
Port_1438885
Port_1438986
Port_1439077
Port_1439091
Port_1439367
Port_1439827
Port_1439843
Port_1440078
Port_1440243
Port_1440420
Port_1440481
Port_1440798
Port_1441081
Port_1441442
Port_1441502
Port_1441588
Port_1441632
Port_1441812
Port_1441867
Port_1441963
Port_1442155
Port_1442194
Port_1443007
Port_1443067
Port_1443706
Port_1444190
Port_1444360
Port_1444557
Port_1445020
Port_1445164
Port_1445657
Port_1445688
Port_1445939
Port_1446106
Port_1446739
Port_1446919
Port_1446961
Port_1447177
Port_1447382
Port_1447730
Port_1448108
Port_1448134
Port_1448417
Port_1448488
Port_1448845
Port_1448904
Port_1449288
Port_1449775
Port_1449916
Port_1449932
Port_1450014
Port_1450415
Port_1450542
Port_1450606
Port_1450923
Port_1451298
Port_1452019
Port_1452895
Port_1452910
Port_1452983
Port_1453330
Port_1453465
Port_1453474
Port_1453940
Port_1453962
Port_1454360
Port_1454690
Port_1454941
Port_1455439
Port_1455693
Port_1455749
Port_1455890
Port_1456277
Port_1456629
Port_1456981
Port_1457311
Port_1457338
Port_1457476
Port_1457887
Port_1457914
Port_1458499
Port_1458515
Port_1458913
Port_1458939
Port_1459643
Port_1459683
Port_1459968
Port_1460961
Port_1461460
Port_1461488
Port_1461769
Port_1462024
Port_1462628
Port_1462859
Port_1463028
Port_1463565
Port_1464157
Port_1464177
Port_1464354
Port_1464558
Port_1464728
Port_1465109
Port_1465291
Port_1465769
Port_1466456
Port_1466596
Port_1467169
Port_1467187
Port_1467465
Port_1467640
Port_1467668
Port_1467701
Port_1467798
Port_1467834
Port_1468289
Port_1468592
Port_1468671
Port_1468791
Port_1468937
Port_1469013
Port_1469056
Port_1469980
Port_1470337
Port_1470408
Port_1471054
Port_1471106
Port_1472010
Port_1472052
Port_1472866
Port_1473159
Port_1473454
Port_1473484
Port_1474221
Port_1474234
Port_1475158
Port_1475196
Port_1475737
Port_1476290
Port_1476589
Port_1477238
Port_1477457
Port_1477744
Port_1477904
Port_1478418
Port_1478695
Port_1478848
Port_1479353
Port_1479883
Port_1480052
Port_1480073
Port_1480151
Port_1480535
Port_1480857
Port_1481214
Port_1481238
Port_1482463
Port_1482696
Port_1482716
Port_1483010
Port_1483375
Port_1483915
Port_1484208
Port_1484837
Port_1484917
Port_1485261
Port_1485636
Port_1485889
Port_1486711
Port_1486758
Port_1486993
Port_1487035
Port_1487055
Port_1487269
Port_1487462
Port_1487672
Port_1487720
Port_1488141
Port_1488283
Port_1488356
Port_1488698
Port_1489035
Port_1489727
Port_1489849
Port_1489858
Port_1490026
Port_1490581
Port_1490850
Port_1490887
Port_1491075
Port_1491351
Port_1491961
Port_1492330
Port_1492497
Port_1492990
Port_1504767
Port_1504997
Port_1506263
Port_1506314
Port_1506687
Port_1506898
Port_1507160
Port_1508111
Port_1509491
Port_1509686
Port_1509775
Port_1510377
Port_1511343
Port_1511380
Port_1511631
Port_1512162
Port_1512247
Port_1512935
Port_1517912
Port_1517928
Port_1518527
Port_1519116
Port_1519151
Port_1519190
Port_1519282
Port_1519412
Port_1519492
Port_1519890
Port_1520328
Port_1520503
Port_1520654
Port_1520753
Port_1520856
Port_1520896
Port_1521071
Port_1521277
Port_1522287
Port_1523146
Port_1523170
Port_1523513
Port_1523871
Port_1524571
Port_1524720
Port_1525201
Port_1525631
Port_1525892
Port_1526434
Port_1526549
Port_1526695
Port_1526721
Port_1527119
Port_1527633
Port_1527822
Port_1528462
Port_1528538
Port_1529207
Port_1529314
Port_1529695
Port_1531256
Port_1531367
Port_1531463
Port_1531535
Port_1531935
Port_1531937
Port_1531938
Port_1531940
Port_1531949
Port_1532062
Port_1532335
Port_1532337
Port_1532422
Port_1532480
Port_1533134
Port_1533142
Port_1533531
Port_1533690
Port_1533782
Port_1534010
Port_1534044
Port_1534202
Port_1534687
Port_1535265
Port_1535332
Port_1535697
Port_1536146
Port_1536981
Port_1537207
Port_1537289
Port_1537297
Port_1537787
Port_1537924
Port_1538381
Port_1538472
Port_1538648
Port_1539040
Port_1539595
Port_1540105
Port_1540771
Port_1541042
Port_1541401
Port_1541604
Port_1542007
Port_1542584
Port_1542647
Port_1542918
Port_1543055
Port_1544262
Port_1544289
Port_1544814
Port_1545626
Port_1545644
Port_1546059
Port_1546491
Port_1547227
Port_1547241
Port_1547487
Port_1547646
Port_1548209
Port_1548402
Port_1548461
Port_1548625
Port_1549274
Port_1549288
Port_1549685
Port_1549861
Port_1549879
Port_1550263
Port_1550970
Port_1550990
Port_1551314
Port_1551322
Port_1551806
Port_1552540
Port_1552569
Port_1552864
Port_1553494
Port_1553965
Port_1554361
Port_1554697
Port_1554965
Port_1554975
Port_1555103
Port_1555273
Port_1556276
Port_1556314
Port_1556874
Port_1556941
Port_1557153
Port_1557211
Port_1557453
Port_1557463
Port_1557896
Port_1557943
Port_1558204
Port_1558288
Port_1558653
Port_1558711
Port_1558818
Port_1559177
Port_1559481
Port_1559572
Port_1559602
Port_1559845
Port_1559920
Port_1560642
Port_1560876
Port_1560964
Port_1561069
Port_1561100
Port_1561272
Port_1561310
Port_1562156
Port_1562601
Port_1562626
Port_1562747
Port_1563122
Port_1563259
Port_1569597
Port_1569757
Port_1569887
InPort_1576592
OutPort_1576644
InPort_1576644
InPort_1576984
OutPort_1577197
InPort_1577197
OutPort_1577370
InPort_1577370
Port_1580971
Port_1582590
Port_1593061
Port_1593069
Port_1593077
Port_1593852
Port_1594188
Port_1594197
Port_1594205
Port_1595313
Port_1597871
Port_1598069
Port_1599279
Port_1602200
Port_1606414
Port_1612836
InPort_1612836
2 x OutPort_1613352
2 x InPort_1612882
InPort_1612961
OutPort_1612962
Port_1612962
InPort_1613352
OutPort_1613353
Port_1613353
2 x InPort_1613414
2 x OutPort_1613433
Port_1613421
InPort_1613421
Port_1613676
InPort_1613676
InPort_1613716
Port_1615267
Port_1615335
Port_1615457
Port_1615468
Port_1615583
Port_1615784
Port_1616054
Port_1616182
Port_1616257
Port_1616348
Port_1616409
Port_1616513
Port_1616609
Port_1616686
Port_1616803
Port_1616918
Port_1616982
Port_1617071
Port_1617122
Port_1617170
Port_1617207
Port_1617218
Port_1617274
Port_1617293
Port_1617344
Port_1617353
Port_1617404
Port_1617413
Port_1617435
Port_1617539
Port_1617610
Port_1617631
Port_1617673
Port_1617692
Port_1617732
Port_1617740
Port_1617832
Port_1617834
Port_1617928
Port_1618097
Port_1618120
Port_1618233
Port_1618255
Port_1618299
Port_1618421
Port_1618553
Port_1618597
Port_1618619
Port_1618642
Port_1618874
Port_1618942
Port_1618981
Port_1619028
Port_1619072
Port_1619097
Port_1619122
Port_1619145
Port_1619167
Port_1619189
Port_1619211
Port_1619243
Port_1619297
Port_1619319
Port_1619341
Port_1619445
Port_1619463
Port_1619488
Port_1619514
Port_1619540
Port_1619615
Port_1619640
Port_1619700
Port_1619726
Port_1619773
Port_1619799
Port_1619854
Port_1619879
Port_1619904
Port_1619931
Port_1619956
Port_1619983
Port_1620008
Port_1620033
Port_1620058
Port_1620083
Port_1620108
Port_1620183
Port_1620210
Port_1620235
Port_1620283
Port_1620310
Port_1620335
Port_1620361
Port_1620384
Port_1620406
Port_1620429
Port_1620451
Port_1620474
Port_1620497
Port_1620520
Port_1620543
Port_1620565
Port_1620587
Port_1620610
Port_1620634
Port_1620656
Port_1620678
Port_1620700
Port_1620754
Port_1620779
Port_1620806
Port_1620831
Port_1620873
Port_1620926
Port_1620934
Port_1621223
Port_1621487
Port_1621549
Port_1621650
Port_1621790
Port_1621891
Port_1622078
Port_1622246
Port_1622361
Port_1622435
Port_1623174
Port_1623221
Port_1623335
Port_1623344
Port_1623383
Port_1623394
Port_1623553
Port_1623562
Port_1623571
Port_1623580
Port_1623763
Port_1623772
Port_1623783
Port_1623792
Port_1623801
Port_1623833
Port_1623877
Port_1623954
Port_1624078
Port_1624155
Port_1624188
Port_1624290
Port_1624301
Port_1624312
Port_1624345
Port_1624442
Port_1624725

# IfcFlowFitting: M_Channel Horizontal Bend:Standard (3)
In: 5 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Channel Horizontal Bend:Standard:...)
1031211
1613420
1613433

# IfcFlowFitting: M_Channel Horizontal Tee:300mm Radius (3)
In: 5 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: 300mm Radius; sets with these values: 2
Name (M_Channel Horizontal Tee:300mm Radius:...)
1612961
1613352
1613716

# IfcFlowFitting: M_Conduit Elbow - Plain End - PVC:Standard (27)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Conduit Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Conduit Elbow - Plain End - PVC:Standard:...) | In
915932 | Rūsys
916817 | Rūsys
916941 | Rūsys
916972 | Rūsys
917017 | Rūsys
917044 | Rūsys
975105 | Rūsys
975127 | Rūsys
976005 | Rūsys
976202 | Rūsys
976498 | Rūsys
976677 | Rūsys
976703 | Rūsys
976974 | Rūsys
977309 | Rūsys
977311 | Rūsys
977423 | Rūsys
995595 | Rūsys
1059857 | Stogas
1060358 | Stogas
1060438 | Stogas
1060751 | Stogas
1060759 | Stogas
1062989 | Stogas
1062991 | Stogas
1375379 | Rūsys
1375386 | Rūsys

# IfcFlowFitting: M_Conduit Elbow - without Fittings - RNC:Standard (16)
In: Rūsys
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Conduit Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Conduit Elbow - without Fittings - RNC:Standard:...)
915299
916287
916337
916376
916394
916786
918763
919130
1380397
1380399
1380614
1380616
1382827
1382854
1383165
1383201

# IfcFlowFitting: M_Conduit Junction Box - Tee - PVC:Standard (5)
In: Rūsys
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Conduit Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Conduit Junction Box - Tee - PVC:Standard:...)
976494
976632
976992
977334
1375357

# IfcFlowFitting: M_Ladder Horizontal Bend:Standard (23)
Type - Material: <Unnamed> (7)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Ladder Horizontal Bend:Standard:...) | In | Material
962181 | Rūsys
964559 | Rūsys | <Unnamed>
964684 | Rūsys
965172 | Rūsys | <Unnamed>
980730 | 5 aukštas
984834 | 4 aukštas | <Unnamed>
985474 | 3 aukštas | <Unnamed>
987841 | Level 1
989008 | Level 2 | <Unnamed>
990165 | Level 2 | <Unnamed>
990177 | Level 2 | <Unnamed>
991205 | Level 2 | <Unnamed>
1003033 | Rūsys | <Unnamed>
1008102 | Level 2 | <Unnamed>
1009527 | Level 1 | <Unnamed>
1016288 | Rūsys | <Unnamed>
1024179 | 4 aukštas | <Unnamed>
1026238 | 4 aukštas | <Unnamed>
1027960 | 3 aukštas | <Unnamed>
1086417 | 5 aukštas | <Unnamed>
1087436 | 5 aukštas | <Unnamed>
1091863 | 5 aukštas | <Unnamed>
1577543 | Rūsys | <Unnamed>

# IfcFlowFitting: M_Ladder Horizontal Cross:300mm Radius, M_Ladder Horizontal Cross:300mm Radius:989490
In: Level 2
Type - Material: <Unnamed> (9)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: 300mm Radius; sets with these values: 2

# IfcFlowFitting: M_Ladder Horizontal Tee:300mm Radius (30)
Type - Material: <Unnamed> (8)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: 300mm Radius; sets with these values: 2
Name (M_Ladder Horizontal Tee:300mm Radius:...) | In | Material
964881 | Rūsys
965774 | Rūsys
966021 | Rūsys | <Unnamed>
966027 | Rūsys | <Unnamed>
982749 | 4 aukštas
985460 | 3 aukštas | <Unnamed>
986776 | 3 aukštas
987020 | 3 aukštas
989155 | Level 2 | <Unnamed>
989843 | Level 2 | <Unnamed>
990036 | Level 2 | <Unnamed>
991247 | Level 2 | <Unnamed>
998084 | Rūsys | <Unnamed>
1002972 | Rūsys | <Unnamed>
1007951 | Level 2 | <Unnamed>
1008539 | Level 2
1009807 | Level 1 | <Unnamed>
1010200 | Level 1 | <Unnamed>
1019767 | Rūsys | <Unnamed>
1023914 | 4 aukštas | <Unnamed>
1024535 | 4 aukštas
1025098 | 4 aukštas | <Unnamed>
1026698 | 4 aukštas | <Unnamed>
1027337 | 3 aukštas | <Unnamed>
1028062 | 3 aukštas | <Unnamed>
1090794 | 5 aukštas | <Unnamed>
1096882 | Level 2 | <Unnamed>
1355222 | 5 aukštas
1355497 | 5 aukštas | <Unnamed>
1576984 | Rūsys | <Unnamed>

# IfcFlowFitting: M_Ladder Reducer:Standard (11)
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Ladder Reducer:Standard:...) | In
992350 | Level 2
993204 | Level 2 | Material: <Unnamed>
993391 | Level 2 | Material: <Unnamed>
1002455 | Level 1
1015465 | Level 2 | Material: <Unnamed>
1028998 | 4 aukštas
1029130 | 4 aukštas | Material: <Unnamed>
1033200 | 4 aukštas
1084437 | 4 aukštas | Material: <Unnamed>
1576687 | Rūsys
1577197 | Rūsys

# IfcFlowFitting: M_Ladder Union:Standard (4)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Ladder Union:Standard:...) | In | Material
1033713 | Level 1
1034413 | Level 1 | <Unnamed>
1034513 | Rūsys | <Unnamed>
1036199 | Level 1 | <Unnamed>

# IfcFlowFitting: M_Ladder Vertical Inside Bend:Standard (6)
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Ladder Vertical Inside Bend:Standard:...) | In
1004031 | Rūsys
1006484 | Rūsys | Material: <Unnamed>
1022008 | 5 aukštas
1023013 | 4 aukštas
1030806 | Level 1 | Material: <Unnamed>
1031553 | 4 aukštas | Material: <Unnamed>

# IfcFlowFitting: T-Abzweigstücke_Magic_60_FS_en:T-Abzweigstücke_Magic_60_FS_en - - id -4e776af7, T-Abzweigstücke_Magic_60_FS_en:T-Abzweigstücke_Magic_60_FS_en - - id -4e776af7:1576592
In: Rūsys
Type - Classification: D5080.90, D6090.10 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: OBO
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: T-Abzweigstücke_Magic_60_FS_en - - id -4e776af7; sets with these values: 2

# IfcFlowSegment: Cable Tray with Fittings:Ladder Cable Tray (38)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Pset_ProductRequirements - Category: Cable Trays
Pset_DistributionFlowElementCommon - Reference: Ladder Cable Tray; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Ladder Cable Tray:...) | In | Length (mm)
960866 | Rūsys | 3303.92
962246 | Rūsys | 12686.6
964113 | Rūsys | 34802.7
964622 | Rūsys | 5516.39
964737 | Rūsys | 22885.3
964872 | Rūsys | 5519.24
964882 | Rūsys | 8623.56
965149 | Rūsys | 1267.68
965768 | Rūsys | 520
965775 | Rūsys | 9060
965880 | Rūsys | 720
966017 | Rūsys | 464.873
966022 | Rūsys | 4447.53
966023 | Rūsys | 464.873
966028 | Rūsys | 1267.68
997910 | Level 1 | 16530
998076 | Rūsys | 4970.87
998085 | Rūsys | 2849.02
1002702 | Rūsys | 5519.24
1002973 | Rūsys | 1670
1005979 | Rūsys | 4334.68
1007537 | Level 1 | 6630
1007711 | Level 1 | 4000
1008077 | Level 2 | 1240.08
1008208 | Level 2 | 3340
1008621 | Level 2 | 457.157
1010381 | Level 1 | 13700
1018281 | Rūsys | 8427.35
1019873 | Rūsys | 6584.32
1020119 | Rūsys | 22260
1020625 | 5 aukštas | 4515
1084547 | 4 aukštas | 1240.42
1087404 | 5 aukštas | 24.8847
1087561 | 5 aukštas | 322.027
1090689 | 5 aukštas | 3037.94
1336243 | Rūsys | 830
1576644 | Rūsys | 893.331
1577370 | Rūsys | 400

# IfcFlowSegment: Cable Tray with Fittings:MKS-M 60 FS - - id -4e776af7, Cable Tray with Fittings:MKS-M 60 FS - - id -4e776af7:1011232
In: Rūsys
Type - PredefinedType: CABLETRAYSEGMENT
Type - Pset_ManufacturerTypeInformation - Manufacturer: OBO
Type - Pset_ProductRequirements - Category: Cable Trays
Pset_DistributionFlowElementCommon - Reference: MKS-M 60 FS - - id -4e776af7; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1200 mm; sets with these values: 2

# IfcFlowSegment: Cable Tray with Fittings:Solid Bottom Cable Tray (11)
In: 5 aukštas
Type - PredefinedType: CABLETRAYSEGMENT
Type - Pset_ProductRequirements - Category: Cable Trays
Pset_DistributionFlowElementCommon - Reference: Solid Bottom Cable Tray; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Solid Bottom Cable Tray:...) | Length (mm)
1031201 | 8499.16
1031205 | 885
1031284 | 10080
1612836 | 25463.7
1612882 | 3850
1612962 | 25463.7
1613353 | 6486.26
1613414 | 210.914
1613421 | 25225
1613676 | 4090.43
1613717 | 75.1818

# IfcFlowSegment: Cable Tray without Fittings:Ladder Cable Tray (57)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Pset_ProductRequirements - Category: Cable Trays
Pset_DistributionFlowElementCommon - Reference: Ladder Cable Tray; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray without Fittings:Ladder Cable Tray:...) | In | Length (mm)
980981 | 5 aukštas | 33330
981848 | 5 aukštas | 33330
981990 | 5 aukštas | 3037.94
982822 | 4 aukštas | 4420
982850 | 4 aukštas | 20780
983936 | 4 aukštas | 5750
984222 | 4 aukštas | 39277.8
985047 | 4 aukštas | 2309.73
985461 | 3 aukštas | 11950
985463 | 3 aukštas | 23750
985468 | 3 aukštas | 43160
985476 | 3 aukštas | 41580
986895 | 3 aukštas | 6714.76
986934 | 3 aukštas | 10091.2
987127 | 3 aukštas | 23750
987335 | 3 aukštas | 5487.21
987652 | Level 1 | 32390
987944 | Level 1 | 6706.25
988072 | Level 1 | 32600
988668 | Level 2 | 37899.1
988725 | Level 2 | 37899.1
988746 | Level 2 | 18397.4
988763 | Level 2 | 12622.3
988778 | Level 2 | 19428
988820 | Level 2 | 25180
989138 | Level 2 | 25300
989352 | Level 2 | 31547.3
989365 | Level 2 | 9020
989393 | Level 2 | 8878.14
989877 | Level 2 | 7820
990339 | Level 2 | 3930
990405 | Level 2 | 6750
991311 | Level 2 | 1380.52
991415 | Level 2 | 6750
1008417 | Level 2 | 2180
1009528 | Level 1 | 4489.22
1009610 | Level 1 | 226.594
1010009 | Level 1 | 7100
1010198 | Level 1 | 235
1021643 | 4 aukštas | 3680.08
1024102 | 4 aukštas | 1905
1024299 | 4 aukštas | 317.5
1024778 | 4 aukštas | 41330.3
1025057 | 4 aukštas | 3602.18
1025381 | 4 aukštas | 2580
1026950 | 4 aukštas | 20543.1
1027031 | 4 aukštas | 7670.56
1027475 | 3 aukštas | 388.21
1027603 | 3 aukštas | 5318.76
1028013 | 3 aukštas | 3456.47
1028348 | 3 aukštas | 715
1033339 | 4 aukštas | 261.77
1090915 | 5 aukštas | 5716.3
1093308 | 5 aukštas | 8200
1096807 | Level 2 | 15500
1097001 | Level 2 | 4607.59
1355900 | 5 aukštas | 1080

# IfcFlowSegment: Conduit with Fittings:Cu 1x10mm2 (žaliai, geltona) (26)
In: Rūsys
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: Cu 1x10mm2 (žaliai, geltona); sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit with Fittings:Cu 1x10mm2 (žaliai, geltona):...) | Length (mm)
975088 | 3220.6
975095 | 6020.6
975107 | 5847
975119 | 4675.45
975997 | 350.3
976195 | 760.3
976465 | 24045.2
976480 | 2720.6
976485 | 2626.5
976495 | 2796.51
976633 | 12788.2
976670 | 1060.3
976696 | 1060.3
976765 | 32821.1
976850 | 600.3
976901 | 1143
976923 | 1060.3
976993 | 11403.3
977052 | 5939.86
977063 | 22503.3
977335 | 8698.78
977373 | 3760.3
1375358 | 11968.1
1375360 | 3513.97
1375370 | 1620.6
1375381 | 6560.3

# IfcFlowSegment: Conduit with Fittings:Plieninė cinkuota juosta 40x4 mm, Conduit with Fittings:Plieninė cinkuota juosta 40x4 mm:916391
In: Rūsys
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: Plieninė cinkuota juosta 40x4 mm; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 20663.7 mm; sets with these values: 2

# IfcFlowSegment: Conduit with Fittings:Rigid Nonmetallic Conduit (RNC Sch 80) (11)
In: Rūsys
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: Rigid Nonmetallic Conduit (RNC Sch 80); sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit with Fittings:Rigid Nonmetallic Conduit (RNC Sch 80):...) | Length (mm)
915272 | 19126.7
915286 | 52398.9
916281 | 52703.7
916284 | 19444.5
916313 | 53008.5
916331 | 53313.3
916334 | 20054.1
916352 | 19749.3
916370 | 53618.1
916373 | 20358.9
916388 | 53922.9

# IfcFlowSegment: Conduit with Fittings:d-8mm žaibas (8)
In: Stogas
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: d-8mm žaibas; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit with Fittings:d-8mm žaibas:...) | Length (mm)
1059837 | 23118.6
1059846 | 136.718
1059900 | 13767.3
1059914 | 194.116
1060351 | 23878.5
1060431 | 1170.41
1060744 | 23678.5
1060754 | 844.079

# IfcFlowSegment: Conduit without Fittings:Plieninė cinkuota juosta 40x4 mm (7)
In: Rūsys
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: Plieninė cinkuota juosta 40x4 mm; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit without Fittings:Plieninė cinkuota juosta 40x4 mm:...) | Length (mm)
968920 | 3385
968928 | 8005
968942 | 3375
968952 | 9695.53
969313 | 1685
969581 | 1220
969729 | 1250

# IfcFlowSegment: Conduit without Fittings:Rigid Nonmetallic Conduit (RNC Sch 80) (10)
In: Rūsys
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: Rigid Nonmetallic Conduit (RNC Sch 80); sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit without Fittings:Rigid Nonmetallic Conduit (RNC Sch 80):...) | Length (mm)
918266 | 30838.9
918274 | 299.923
918315 | 30338.9
918755 | 23278.9
919122 | 23478.9
1379888 | 3499.88
1379923 | 3480.37
1380215 | 540.454
1383155 | 1287.14
1383193 | 1073

# IfcFlowTerminal: Lovelis antviršinis:Single, Electric Ivory (20)
Type - Material: PVC - Panduit - Electric Ivory
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: Single, Electric Ivory; sets with these values: 2
Name (Lovelis antviršinis:Single, Electric Ivory:...) | In
1505684 | 3 aukštas
1506218 | 3 aukštas
1509279 | 3 aukštas
1509434 | 3 aukštas
1509526 | 3 aukštas
1510786 | 3 aukštas
1510976 | 3 aukštas
1521575 | 3 aukštas
1521797 | 3 aukštas
1521827 | 3 aukštas
1522069 | 3 aukštas
1529942 | 3 aukštas
1530361 | 3 aukštas
1530523 | 3 aukštas
1530585 | 3 aukštas
1531023 | 3 aukštas
1558938 | 4 aukštas
1560099 | 4 aukštas
1560152 | 4 aukštas
1560477 | 4 aukštas

# IfcFlowTerminal: Lovelis antviršinis:Single, White (2)
In: 3 aukštas
Type - Material: PVC - Panduit - White
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: Single, White; sets with these values: 2
Name (Lovelis antviršinis:Single, White:...)
1499055
1500413

# IfcFlowTerminal: Surface_Raceway-Panduit-Pan_Way-T70_Cover:Electric Ivory (20)
Type - Material: PVC - Panduit - Electric Ivory
Type - Pset_ManufacturerTypeInformation - Manufacturer: Panduit Corp.
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: Electric Ivory; sets with these values: 2
Name (Surface_Raceway-Panduit-Pan_Way-T70_Cover:Electric Ivory:...) | In
1505686 | 3 aukštas
1506219 | 3 aukštas
1509280 | 3 aukštas
1509435 | 3 aukštas
1509528 | 3 aukštas
1510788 | 3 aukštas
1510978 | 3 aukštas
1521577 | 3 aukštas
1521798 | 3 aukštas
1521829 | 3 aukštas
1522071 | 3 aukštas
1529944 | 3 aukštas
1530363 | 3 aukštas
1530525 | 3 aukštas
1530587 | 3 aukštas
1531025 | 3 aukštas
1558940 | 4 aukštas
1560101 | 4 aukštas
1560154 | 4 aukštas
1560479 | 4 aukštas

# IfcFlowTerminal: Surface_Raceway-Panduit-Pan_Way-T70_Cover:White (2)
In: 3 aukštas
Type - Material: PVC - Panduit - White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Panduit Corp.
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: White; sets with these values: 2
Name (Surface_Raceway-Panduit-Pan_Way-T70_Cover:White:...)
1499056
1500414
