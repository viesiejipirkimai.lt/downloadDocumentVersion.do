Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcDistributionPort (2401)
Name
Port_1440401
Port_1440402
Port_1440403
Port_1440404
Port_1440405
Port_1440406
Port_1440407
Port_1440408
Port_1440409
Port_1440411
Port_1440412
Port_1440413
Port_1440414
Port_1440415
Port_1440416
Port_1440417
Port_1440418
Port_1440419
Port_1440420
Port_1440421
Port_1440422
Port_1440423
Port_1440424
Port_1440425
Port_1440426
Port_1440427
Port_1440428
Port_1440429
Port_1462191
Port_1462192
Port_1462193
Port_1462194
Port_1462196
Port_1462197
Port_1462198
Port_1462199
Port_1462200
Port_1462201
Port_1462202
Port_1462203
Port_1462204
Port_1462205
Port_1462206
Port_1462207
Port_1462208
Port_1462209
Port_1462210
Port_1462211
Port_1462212
Port_1462213
Port_1462214
Port_1462215
Port_1462216
Port_1462217
Port_1462218
Port_1462219
Port_1462220
Port_1462221
Port_1462222
Port_1462223
Port_1462224
Port_1462225
Port_1462226
Port_1462228
Port_1462229
Port_1462230
Port_1462231
Port_1462232
Port_1462233
Port_1462234
Port_1462235
Port_1462236
Port_1462237
Port_1462238
Port_1462239
Port_1462241
Port_1462242
Port_1462243
Port_1462244
Port_1462245
Port_1462246
Port_1462247
Port_1462249
Port_1462250
Port_1462251
Port_1462252
Port_1462253
Port_1462254
Port_1462255
Port_1462256
Port_1462259
Port_1462260
Port_1462261
Port_1462262
Port_1462263
Port_1462264
Port_1462265
Port_1462266
Port_1462267
Port_1462268
Port_1462270
Port_1462271
Port_1462272
Port_1462273
Port_1462274
Port_1462275
Port_1462276
Port_1462277
Port_1462278
Port_1462279
Port_1462280
Port_1462281
Port_1462282
Port_1462284
Port_1462285
Port_1462286
Port_1462288
Port_1462289
Port_1462290
Port_1462291
Port_1462292
Port_1462293
Port_1462294
Port_1462295
Port_1462296
Port_1462297
Port_1462298
Port_1462299
Port_1462300
Port_1462301
Port_1462302
Port_1462303
Port_1462304
Port_1462305
Port_1462306
Port_1462307
Port_1462308
Port_1462309
Port_1462310
Port_1462312
Port_1462313
Port_1462315
Port_1462316
Port_1462317
Port_1462318
Port_1462319
Port_1462320
Port_1462329
Port_1462330
Port_1462331
Port_1462332
Port_1462333
Port_1462335
Port_1462336
Port_1462337
Port_1462338
Port_1462340
Port_1462341
Port_1462342
Port_1462343
Port_1462344
Port_1462345
Port_1462346
Port_1462347
Port_1462348
Port_1462349
Port_1462350
Port_1462351
Port_1462352
Port_1462353
Port_1462354
Port_1462355
Port_1462356
Port_1462357
Port_1462358
Port_1462359
Port_1462360
Port_1462361
Port_1462362
Port_1462363
Port_1462364
Port_1462366
Port_1462367
Port_1462368
Port_1462369
Port_1462370
Port_1462372
Port_1462373
Port_1462374
Port_1462375
Port_1462376
Port_1462377
Port_1462378
Port_1462379
Port_1462380
Port_1462381
Port_1462382
Port_1462383
Port_1462384
Port_1462385
Port_1462386
Port_1462387
Port_1462388
Port_1462389
Port_1462390
Port_1462392
Port_1462393
Port_1462394
Port_1462395
Port_1462396
Port_1462397
Port_1462398
Port_1462399
Port_1462401
Port_1462402
Port_1462403
Port_1462404
Port_1462405
Port_1462406
Port_1462408
Port_1462410
Port_1467748
Port_1491134
Port_1491422
Port_1491517
Port_1491636
Port_1491670
Port_1491859
Port_1491985
Port_1492061
Port_1492123
Port_1493000
Port_1493001
Port_1493002
Port_1493003
Port_1493004
Port_1493005
Port_1493006
Port_1493008
Port_1493009
Port_1493010
Port_1493118
Port_1493119
Port_1493120
Port_1493121
Port_1493239
Port_1493573
Port_1493574
Port_1493575
Port_1493576
Port_1493807
Port_1493837
Port_1493903
Port_1493904
Port_1494002
Port_1494003
Port_1494115
Port_1494116
Port_1494238
Port_1494239
Port_1494325
Port_1494395
Port_1494479
Port_1494577
Port_1494634
Port_1494822
Port_1494823
Port_1494824
Port_1494973
Port_1495071
Port_1495140
Port_1495190
Port_1495220
Port_1495277
Port_1495372
Port_1495402
Port_1514011
Port_1514012
Port_1514587
Port_1514630
Port_1514679
Port_1514736
Port_1514801
Port_1515137
Port_1515273
Port_1515341
Port_1515437
Port_1515463
Port_1515464
Port_1532603
Port_1532783
Port_1532845
Port_1532890
Port_1533015
Port_1533056
Port_1533066
Port_1533076
Port_1533088
Port_1533125
Port_1533218
Port_1533250
Port_1533298
Port_1533416
Port_1533455
Port_1533499
Port_1533533
Port_1533572
Port_1533613
Port_1533643
Port_1533713
Port_1533725
Port_1533733
Port_1533809
Port_1533948
Port_1534077
Port_1534176
Port_1534340
Port_1534364
Port_1534380
Port_1534392
Port_1534433
Port_1534503
Port_1534587
Port_1534595
Port_1534603
Port_1534611
Port_1534621
Port_1534711
Port_1534772
Port_1534788
Port_1534800
Port_1534853
Port_1535087
Port_1535167
Port_1535215
Port_1535223
Port_1535305
Port_1535373
Port_1535451
Port_1535536
Port_1535544
Port_1535552
Port_1535560
Port_1535568
Port_1535743
Port_1535799
Port_1535907
Port_1535959
Port_1536069
Port_1536206
Port_1536342
Port_1536407
Port_1536495
Port_1536521
Port_1536529
Port_1536537
Port_1536793
Port_1536852
Port_1536914
Port_1548462
Port_1548464
Port_1548465
Port_1548466
Port_1548467
Port_1548468
Port_1548470
Port_1548472
Port_1548473
Port_1548474
Port_1548475
Port_1548476
Port_1548477
Port_1548478
Port_1548479
Port_1548480
Port_1548482
Port_1548491
Port_1548493
Port_1548664
Port_1548666
Port_1549410
Port_1549912
Port_1550437
Port_1550445
Port_1550549
Port_1550559
Port_1550981
Port_1551027
Port_1551205
Port_1731737
Port_1732113
Port_1732443
Port_1732977
Port_1733242
Port_1733571
Port_1733762
Port_1733877
Port_1734079
Port_1734216
Port_1734458
Port_1735223
Port_1735320
Port_1735440
Port_1735608
Port_1735762
Port_1735836
Port_1737078
Port_1737108
Port_1737570
Port_1737735
Port_1737772
Port_1737896
Port_1738230
Port_1738346
Port_1738384
Port_1738659
Port_1738706
Port_1738890
Port_1739149
Port_1739277
Port_1739386
Port_1739542
Port_1740665
Port_1740800
Port_1741004
Port_1741167
Port_1741454
Port_1741605
Port_1741931
Port_1742089
Port_1742221
Port_1744534
Port_1747018
Port_1747079
Port_1747928
Port_1747966
Port_1748120
Port_1748306
Port_1748428
Port_1748545
Port_1748679
Port_1749426
Port_1749562
Port_1749701
Port_1749893
Port_1749979
Port_1750128
Port_1750189
Port_1750286
Port_1750334
Port_1750432
Port_1750506
Port_1750632
Port_1750690
Port_1750782
Port_1750818
Port_1750874
Port_1750914
Port_1751164
Port_1752477
Port_1752534
Port_1752682
Port_1752811
Port_1753252
Port_1753408
Port_1753480
Port_1753669
Port_1753789
Port_1754006
Port_1754132
Port_1754345
Port_1754452
Port_1754579
Port_1756091
Port_1756157
Port_1756238
Port_1756298
Port_1756350
Port_1756452
Port_1756490
Port_1756570
Port_1756628
Port_1756662
Port_1756710
Port_1756778
Port_1756840
Port_1756932
Port_1757034
Port_1758038
Port_1758318
Port_1758376
Port_1758420
Port_1758468
Port_1758502
Port_1758542
Port_1758576
Port_1765707
Port_1765791
Port_1765917
Port_1766012
Port_1766119
Port_1766245
Port_1766424
Port_1766674
Port_1766748
Port_1767058
Port_1767128
Port_1767288
Port_1767348
Port_1767475
Port_1767581
Port_1767715
Port_1767945
Port_1768065
Port_1768244
Port_1768355
Port_1768431
Port_1768556
Port_1768668
Port_1768768
Port_1768861
Port_1768986
Port_1769093
Port_1769274
Port_1769602
Port_1769757
Port_1769996
Port_1770350
Port_1770625
Port_1770678
Port_1770826
Port_1770830
Port_1770946
Port_1771001
Port_1771086
Port_1771362
Port_1771494
Port_1771591
Port_1771676
Port_1771721
Port_1771989
Port_1772049
Port_1772151
Port_1772279
Port_1772354
Port_1772429
Port_1772459
Port_1772545
Port_1772578
Port_1772828
Port_1772882
Port_1773008
Port_1773047
Port_1773130
Port_1773164
Port_1773213
Port_1773217
Port_1773411
Port_1773500
Port_1773504
Port_1773756
Port_1773814
Port_1773951
Port_1774011
Port_1774108
Port_1774247
Port_1774301
Port_1774390
Port_1774427
Port_1774556
Port_1774603
Port_1774693
Port_1774909
Port_1775403
Port_1775478
Port_1775628
Port_1775707
Port_1775812
Port_1776004
Port_1776287
Port_1776391
Port_1777414
Port_1777520
Port_1777688
Port_1777791
Port_1777999
Port_1778346
Port_1778435
Port_1778466
Port_1778577
Port_1778669
Port_1778783
Port_1778837
Port_1778956
Port_1779076
Port_1779318
Port_1781076
Port_1781306
Port_1781380
Port_1781510
Port_1781635
Port_1781671
Port_1781797
Port_1781921
Port_1782002
Port_1782154
Port_1783441
Port_1783655
Port_1783753
Port_1784312
Port_1784475
Port_1784570
Port_1784683
Port_1785755
Port_1785756
Port_1785757
Port_1785758
Port_1785759
Port_1785760
Port_1785761
Port_1785835
Port_1785901
Port_1786208
Port_1786445
Port_1786511
Port_1786719
Port_1787194
Port_1787260
Port_1787610
Port_1787695
Port_1787800
Port_1787912
Port_1788452
Port_1788481
Port_1788583
Port_1788819
Port_1789030
Port_1789092
Port_1789200
Port_1789330
Port_1789412
Port_1789488
Port_1789575
Port_1789668
Port_1790184
Port_1790266
Port_1790350
Port_1790388
Port_1790535
Port_1790651
Port_1790723
Port_1790811
Port_1800104
Port_1800207
Port_1802071
Port_1802205
Port_1802335
Port_1802508
Port_1802891
Port_1802951
Port_1803032
Port_1803134
Port_1803195
Port_1803392
Port_1803437
Port_1803499
Port_1803565
Port_1803684
Port_1803776
Port_1803861
Port_1803971
Port_1804066
Port_1804315
Port_1804361
Port_1804626
Port_1804732
Port_1804872
Port_1805004
Port_1805056
Port_1805112
Port_1805206
Port_1805265
Port_1805453
Port_1805533
Port_1805591
Port_1805620
Port_1805770
Port_1805867
Port_1805959
Port_1806012
Port_1813571
Port_1813572
Port_1813573
Port_1813574
Port_1813575
Port_1813576
Port_1813577
Port_1813578
Port_1813579
Port_1813580
Port_1813581
Port_1813582
Port_1813583
Port_1813584
Port_1813585
Port_1813586
Port_1813587
Port_1813588
Port_1813589
Port_1813590
Port_1813591
Port_1813592
Port_1813593
Port_1813594
Port_1813595
Port_1813596
Port_1813597
Port_1813598
Port_1813599
Port_1813600
Port_1813601
Port_1813602
Port_1813603
Port_1813605
Port_1813606
Port_1813607
Port_1813608
Port_1813609
Port_1813891
Port_1814000
Port_1814061
Port_1814065
Port_1814171
Port_1814229
Port_1814284
Port_1814489
Port_1814587
Port_1814621
Port_1814731
Port_1815226
Port_1815333
Port_1815445
Port_1815597
Port_1815703
Port_1815796
Port_1815916
Port_1816028
Port_1816138
Port_1816142
Port_1816415
Port_1816473
Port_1816505
Port_1816543
Port_1816547
Port_1816599
Port_1816767
Port_1817062
Port_1817183
Port_1817325
Port_1817481
Port_1817581
Port_1817707
Port_1817877
Port_1817949
Port_1818233
Port_1818310
Port_1818421
Port_1818542
Port_1818636
Port_1818722
Port_1819028
Port_1819156
Port_1819284
Port_1819360
Port_1819463
Port_1819519
Port_1819687
Port_1819750
Port_1819792
Port_1820010
Port_1820160
Port_1820373
Port_1820470
Port_1820575
Port_1820727
Port_1820839
Port_1820928
Port_1821018
Port_1821110
Port_1821167
Port_1821274
Port_1821431
Port_1821534
Port_1821585
Port_1821728
Port_1821877
Port_1822601
Port_1823111
Port_1823411
Port_1823513
Port_1823589
Port_1823889
Port_1823980
Port_1824115
Port_1824261
Port_1824286
Port_1824371
Port_1824493
Port_1824497
Port_1824501
Port_1824505
Port_1824554
Port_1824675
Port_1824736
Port_1824827
Port_1824919
Port_1825013
Port_1825181
Port_1825199
Port_1825229
Port_1825281
Port_1825285
Port_1825345
Port_1825587
Port_1825749
Port_1825895
Port_1825963
Port_1826040
Port_1826079
Port_1826153
Port_1826208
Port_1826292
Port_1826364
Port_1826397
Port_1826481
Port_1826637
Port_1826675
Port_1826697
Port_1826736
Port_1827412
Port_1828076
Port_1828266
Port_1828518
Port_1829288
Port_1829830
Port_1830021
Port_1830193
Port_1830249
Port_1830299
Port_1830344
Port_1830402
Port_1830454
Port_1830569
Port_1830646
Port_1830729
Port_1830779
Port_1830856
Port_1831521
Port_1831736
Port_1831932
Port_1832017
Port_1832117
Port_1832293
Port_1832475
Port_1832552
Port_1832698
Port_1832855
Port_1832919
Port_1832962
Port_1833005
Port_1833084
Port_1833153
Port_1833267
Port_1833403
Port_1833606
Port_1833762
Port_1833969
Port_1834034
Port_1834086
Port_1834294
Port_1834405
Port_1834491
Port_1834534
Port_1834813
Port_1834912
Port_1835312
Port_1835447
Port_1835602
Port_1835734
Port_1835893
Port_1836021
Port_1836073
Port_1836120
Port_1836209
Port_1836289
Port_1836357
Port_1836539
Port_1836671
Port_1836896
Port_1837020
Port_1837213
Port_1837346
Port_1837459
Port_1837529
Port_1837611
Port_1837668
Port_1837749
Port_1838259
Port_1838405
Port_1838493
Port_1838659
Port_1838733
Port_1838807
Port_1838872
Port_1839005
Port_1839009
Port_1839108
Port_1839234
Port_1839274
Port_1839394
Port_1839777
Port_1839967
Port_1840075
Port_1840140
Port_1840321
Port_1840387
Port_1840489
Port_1840586
Port_1840672
Port_1842851
Port_1842944
Port_1843170
Port_1843289
Port_1843470
Port_1843508
Port_1843635
Port_1843687
Port_1843871
Port_1843940
Port_1843980
Port_1844107
Port_1844231
Port_1844394
Port_1844658
Port_1844783
Port_1845072
Port_1845199
Port_1845264
Port_1845429
Port_1845520
Port_1845599
Port_1845731
Port_1845898
Port_1846006
Port_1846080
Port_1846359
Port_1846485
Port_1846642
Port_1846786
Port_1846855
Port_1846909
Port_1847030
Port_1847177
Port_1847279
Port_1847389
Port_1847513
Port_1847747
Port_1847762
Port_1847886
Port_1847944
Port_1848351
Port_1848352
Port_1848597
Port_1848762
Port_1848859
Port_1849008
Port_1849012
Port_1849058
Port_1849062
Port_1849164
Port_1849437
Port_1849545
Port_1849648
Port_1849716
Port_1849795
Port_1849927
Port_1850089
Port_1850194
Port_1850281
Port_1850388
Port_1850469
Port_1850728
Port_1850802
Port_1850908
Port_1851009
Port_1851069
Port_1851102
Port_1851195
Port_1851247
Port_1851335
Port_1851535
Port_1851593
Port_1851677
Port_1851799
Port_1851869
Port_1851993
Port_1852083
Port_1852485
Port_1852613
Port_1852701
Port_1852741
Port_1852841
Port_1853218
Port_1855952
Port_1855954
Port_1855955
Port_1855956
Port_1855958
Port_1855959
Port_1855960
Port_1855961
Port_1855962
Port_1855963
Port_1855964
Port_1855965
Port_1855966
Port_1855967
Port_1855977
Port_1856209
Port_1856263
Port_1856333
Port_1856876
Port_1868077
Port_1868078
Port_1868079
Port_1868080
Port_1870209
Port_1871263
Port_1885143
Port_1885233
Port_1885291
Port_1885381
Port_1885477
Port_1885674
Port_1885723
Port_1886625
Port_1886699
Port_1886797
Port_1886867
Port_1887017
Port_1887119
Port_1887426
Port_1887621
Port_1887720
Port_1887831
Port_1888351
Port_1888352
Port_1888353
Port_1888354
Port_1888355
Port_1888356
Port_1888357
Port_1888358
Port_1888359
Port_1888360
Port_1888361
Port_1888362
Port_1888363
Port_1888364
Port_1888365
Port_1888366
Port_1888367
Port_1888368
Port_1888369
Port_1888370
Port_1888371
Port_1888372
Port_1888373
Port_1888374
Port_1888375
Port_1888376
Port_1888377
Port_1888378
Port_1888379
Port_1888380
Port_1888381
Port_1888382
Port_1888383
Port_1888384
Port_1888385
Port_1888386
Port_1888387
Port_1888388
Port_1888389
Port_1888390
Port_1888391
Port_1888392
Port_1888393
Port_1888394
Port_1888395
Port_1888396
Port_1888397
Port_1888398
Port_1888399
Port_1888400
Port_1888401
Port_1888402
Port_1888403
Port_1888407
Port_1888410
Port_1888411
Port_1888412
Port_1888413
Port_1888414
Port_1888415
Port_1888416
Port_1888417
Port_1888418
Port_1888419
Port_1888420
Port_1888421
Port_1888422
Port_1888423
Port_1888424
Port_1888425
Port_1888426
Port_1888427
Port_1888428
Port_1889154
Port_1889257
Port_1889327
Port_1889375
Port_1889489
Port_1889637
Port_1889741
Port_1889797
Port_1889863
Port_1889983
Port_1890037
Port_1890195
Port_1890243
Port_1890367
Port_1890490
Port_1890616
Port_1890689
Port_1890831
Port_1890914
Port_1891237
Port_1891319
Port_1891377
Port_1891630
Port_1891698
Port_1891762
Port_1891830
Port_1891976
Port_1892098
Port_1892178
Port_1892262
Port_1892326
Port_1893059
Port_1893197
Port_1893323
Port_1893604
Port_1893792
Port_1893971
Port_1894126
Port_1894207
Port_1894558
Port_1894619
Port_1894719
Port_1894768
Port_1894909
Port_1894987
Port_1895103
Port_1895284
Port_1895433
Port_1895539
Port_1895719
Port_1895982
Port_1896090
Port_1896373
Port_1896588
Port_1896836
Port_1896949
Port_1897129
Port_1897221
Port_1897340
Port_1897430
Port_1898011
Port_1898121
Port_1898260
Port_1898310
Port_1898424
Port_1898558
Port_1898686
Port_1898798
Port_1898992
Port_1899098
Port_1899244
Port_1899416
Port_1899604
Port_1899891
Port_1899956
Port_1900199
Port_1900469
Port_1900580
Port_1900714
Port_1900879
Port_1901477
Port_1901547
Port_1901610
Port_1901727
Port_1901836
Port_1901942
Port_1902090
Port_1902203
Port_1902352
Port_1902585
Port_1902609
Port_1902652
Port_1902718
Port_1902798
Port_1902883
Port_1903003
Port_1903083
Port_1903173
Port_1903235
Port_1903368
Port_1903448
Port_1903533
Port_1903602
Port_1903673
Port_1903753
Port_1903846
Port_1903946
Port_1904051
Port_1904219
Port_1904286
Port_1904391
Port_1904443
Port_1908909
Port_1909162
Port_1909370
Port_1909617
Port_1909825
Port_1910120
Port_1910393
Port_1910836
Port_1911132
Port_1911263
Port_1911397
Port_1911777
Port_1911925
Port_1912015
Port_1912351
Port_1912431
Port_1912526
Port_1913150
Port_1913234
Port_1913336
Port_1913653
Port_1913762
Port_1913904
Port_1914112
Port_1914351
Port_1914629
Port_1915201
Port_1915298
Port_1916409
Port_1917234
Port_1917517
Port_1917980
Port_1918279
Port_1918399
Port_1918670
Port_1918943
Port_1919133
Port_1919351
Port_1919573
Port_1919808
Port_1920131
Port_1920501
Port_1920993
Port_1921574
Port_1921989
Port_1922853
Port_1923143
Port_1923401
Port_1923888
Port_1923986
Port_1924078
Port_1925405
Port_1925755
Port_1925944
Port_1926076
Port_1926389
Port_1927080
Port_1927351
Port_1927742
Port_1927982
Port_1928289
Port_1929036
Port_1929233
Port_1929953
Port_1930102
Port_1930262
Port_1930406
Port_1930517
Port_1930647
Port_1930875
Port_1931073
Port_1931286
Port_1931412
Port_1931556
Port_1931668
Port_1931804
Port_1932361
Port_1932417
Port_1932467
Port_1932615
Port_1932710
Port_1932828
Port_1933135
Port_1933265
Port_1933377
Port_1933511
Port_1933659
Port_1933816
Port_1934122
Port_1934215
Port_1934340
Port_1934536
Port_1934634
Port_1934839
Port_1934925
Port_1934926
Port_1935370
Port_1935531
Port_1935789
Port_1935908
Port_1936220
Port_1936467
Port_1937060
Port_1937180
Port_1937419
Port_1937533
Port_1937667
Port_1937817
Port_1938007
Port_1938085
Port_1938223
Port_1938343
Port_1938400
Port_1938929
Port_1938975
Port_1939075
Port_1939328
Port_1939849
Port_1940019
Port_1940103
Port_1940432
Port_1940499
Port_1940674
Port_1940923
Port_1940970
Port_1941051
Port_1941199
Port_1941264
Port_1941367
Port_1941796
Port_1941952
Port_1942040
Port_1942845
Port_1943194
Port_1943363
Port_1943516
Port_1943686
Port_1943767
Port_1943925
Port_1944234
Port_1944387
Port_1944548
Port_1944693
Port_1945159
Port_1945266
Port_1945416
Port_1945545
Port_1945922
Port_1946040
Port_1946233
Port_1946359
Port_1946492
Port_1946716
Port_1946844
Port_1947018
Port_1947269
Port_1947360
Port_1947584
Port_1947722
Port_1947817
Port_1947971
Port_1948109
Port_1948308
Port_1948573
Port_1948805
Port_1949453
Port_1949735
Port_1949736
Port_1949854
Port_1950123
Port_1950561
Port_1950652
Port_1950770
Port_1950840
Port_1951134
Port_1951655
Port_1951836
Port_1952051
Port_1952822
Port_1953000
Port_1953192
Port_1953351
Port_1953561
Port_1953836
Port_1970186
Port_1979309
Port_1979310
Port_1985815
Port_1985894
Port_1985899
Port_1985919
Port_1985983
Port_1986226
Port_1986348
Port_1986558
Port_1986717
Port_1986819
Port_1986883
Port_1986973
Port_1987317
Port_1987439
Port_1987487
Port_1987545
Port_1987997
Port_1988028
Port_1988164
Port_1988202
Port_1988341
Port_1988420
Port_1988683
Port_1988759
Port_1988914
Port_1989189
Port_1989286
Port_1989377
Port_1989506
Port_1989577
Port_1989794
Port_1989836
Port_1989922
Port_1989970
Port_1990034
Port_1990076
Port_1990170
Port_1990210
Port_1990274
Port_1990425
Port_1990475
Port_1990641
Port_1991034
Port_1991143
Port_1991193
Port_1991249
Port_1991385
Port_1991423
Port_1991455
Port_1991513
Port_1991553
Port_1991637
Port_1991831
Port_1991875
Port_1991939
Port_1991975
Port_1992131
Port_1992482
Port_1992664
Port_1992736
Port_1992855
Port_1993020
Port_1993108
Port_1993140
Port_1993243
Port_1993303
Port_1994335
Port_1994665
Port_1994728
Port_1994804
Port_1994868
Port_1994870
Port_1994878
Port_1994880
Port_1994883
Port_1994885
Port_1994897
Port_1998155
Port_1998388
Port_1998663
Port_1998832
Port_1998868
Port_1998890
Port_1998949
Port_1998998
Port_1999021
Port_1999043
Port_1999092
Port_1999141
Port_1999164
Port_1999194
Port_1999198
Port_2001331
Port_2001888
Port_2177551
Port_2177561
Port_2177562
Port_2177563
Port_2177564
Port_2177733
Port_2177920
Port_2184127
Port_2186175
Port_2192370
Port_2192373
Port_2192374
Port_2192375
Port_2192376
Port_2192377
Port_2192378
Port_2205894
Port_2205895
Port_2205896
Port_2205897
Port_2205905
Port_2205906
Port_2205907
Port_2205910
Port_2205923
Port_2205924
Port_2206271

# IfcFlowController: AS_Neigaliuju valdymo pultas:AS_Pasikalbėjimo įrenginys (102)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: AS_Pasikalbėjimo įrenginys; sets with these values: 2
Name (AS_Neigaliuju valdymo pultas:AS_Pasikalbėjimo įrenginys:...) | In
1888407 | 2 aukštas
1888410 | 2 aukštas
1888411 | 2 aukštas
1888412 | 2 aukštas
1888413 | 2 aukštas
1888414 | 2 aukštas
1888415 | 2 aukštas
1888416 | 2 aukštas
1888417 | 2 aukštas
1888418 | 2 aukštas
1888419 | 2 aukštas
1888420 | 2 aukštas
1888421 | 2 aukštas
1888422 | 2 aukštas
1888423 | 2 aukštas
1888424 | 2 aukštas
1888425 | 2 aukštas
1888426 | 2 aukštas
1888427 | 2 aukštas
1888428 | 2 aukštas
1889154 | 2 aukštas
1889257 | 2 aukštas
1889327 | 2 aukštas
1889375 | 2 aukštas
1889489 | 2 aukštas
1889637 | 2 aukštas
1889741 | 2 aukštas
1889797 | 2 aukštas
1889863 | 2 aukštas
1889983 | 2 aukštas
1890037 | 2 aukštas
1890195 | 2 aukštas
1890243 | 2 aukštas
1890367 | 2 aukštas
1890490 | 2 aukštas
1890616 | 2 aukštas
1890689 | 2 aukštas
1890831 | 2 aukštas
1890914 | 2 aukštas
1891237 | 2 aukštas
1891319 | 2 aukštas
1891377 | 2 aukštas
1891630 | 2 aukštas
1891698 | 2 aukštas
1891762 | 2 aukštas
1891830 | 2 aukštas
1891976 | 2 aukštas
1892098 | 2 aukštas
1892178 | 2 aukštas
1892262 | 2 aukštas
1892326 | 2 aukštas
1893059 | 3 aukštas
1893197 | 3 aukštas
1893323 | 3 aukštas
1893604 | 3 aukštas
1893792 | 3 aukštas
1893971 | 3 aukštas
1894126 | 3 aukštas
1894207 | 3 aukštas
1894558 | 3 aukštas
1894619 | 3 aukštas
1894719 | 3 aukštas
1894768 | 3 aukštas
1894909 | 3 aukštas
1894987 | 3 aukštas
1895103 | 3 aukštas
1895284 | 3 aukštas
1895433 | 3 aukštas
1895539 | 3 aukštas
1895719 | 3 aukštas
1895982 | 3 aukštas
1896090 | 3 aukštas
1896373 | 3 aukštas
1896588 | 3 aukštas
1896836 | 4 aukštas
1896949 | 4 aukštas
1897129 | 4 aukštas
1897221 | 4 aukštas
1897340 | 4 aukštas
1897430 | 4 aukštas
1898011 | 4 aukštas
1898121 | 4 aukštas
1898260 | 4 aukštas
1898310 | 4 aukštas
1898424 | 4 aukštas
1898558 | 4 aukštas
1898686 | 4 aukštas
1898798 | 4 aukštas
1898992 | 4 aukštas
1899098 | 4 aukštas
1899244 | 4 aukštas
1899416 | 4 aukštas
1899604 | 4 aukštas
1899891 | 4 aukštas
1899956 | 4 aukštas
1900199 | 4 aukštas
1900469 | 4 aukštas
1900580 | 4 aukštas
1900714 | 4 aukštas
1900879 | 4 aukštas
1902883 | 3 aukštas
1903533 | 4 aukštas

# IfcFlowController: AS_Neigaliuju valdymo pultas:AS_Personalo iškvietimo pultas (13)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: AS_Personalo iškvietimo pultas; sets with these values: 2
Name (AS_Neigaliuju valdymo pultas:AS_Personalo iškvietimo pultas:...) | In
1491134 | 2 aukštas
1491422 | 2 aukštas
1491517 | 2 aukštas
1491636 | 2 aukštas
1491670 | 3 aukštas
1491859 | 3 aukštas
1491985 | 3 aukštas
1492061 | 3 aukštas
1492123 | 4 aukštas
1493000 | 4 aukštas
1493001 | 4 aukštas
1493002 | 2 aukštas
2177551 | 1 aukštas

# IfcFlowController: AS_Neigaliuju valdymo pultas:AS_indikatorius su kontroleriu (30)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: AS_indikatorius su kontroleriu; sets with these values: 2
Name (AS_Neigaliuju valdymo pultas:AS_indikatorius su kontroleriu:...) | In
1888403 | 2 aukštas
1901477 | 2 aukštas
1901547 | 2 aukštas
1901610 | 2 aukštas
1901727 | 2 aukštas
1901836 | 2 aukštas
1902090 | 2 aukštas
1902203 | 2 aukštas
1902352 | 2 aukštas
1902585 | 2 aukštas
1902609 | 2 aukštas
1902652 | 1 aukštas
1902718 | 1 aukštas
1902798 | 3 aukštas
1903003 | 3 aukštas
1903083 | 3 aukštas
1903173 | 3 aukštas
1903235 | 3 aukštas
1903368 | 3 aukštas
1903448 | 4 aukštas
1903602 | 4 aukštas
1903673 | 4 aukštas
1903753 | 4 aukštas
1903846 | 4 aukštas
1903946 | 4 aukštas
1904051 | 4 aukštas
1904219 | 4 aukštas
1904286 | 4 aukštas
1904391 | 4 aukštas
1904443 | 5 aukštas

# IfcFlowController: AS_Pagalbos iškvietimo mygtukas sieninis:Mygtukas be virvutes (120)
Type - Material: Red, White
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: Mygtukas be virvutes; sets with these values: 2
Name (AS_Pagalbos iškvietimo mygtukas sieninis:Mygtukas be virvutes:...) | In
1440353 | 2 aukštas
1440355 | 2 aukštas
1440357 | 2 aukštas
1440358 | 2 aukštas
1440359 | 2 aukštas
1440360 | 2 aukštas
1440361 | 2 aukštas
1440362 | 2 aukštas
1440363 | 2 aukštas
1440364 | 2 aukštas
1440365 | 2 aukštas
1440366 | 2 aukštas
1440367 | 2 aukštas
1440368 | 2 aukštas
1440369 | 2 aukštas
1440370 | 2 aukštas
1440371 | 2 aukštas
1440372 | 2 aukštas
1440373 | 2 aukštas
1440374 | 2 aukštas
1440375 | 2 aukštas
1440376 | 2 aukštas
1440377 | 2 aukštas
1440378 | 2 aukštas
1440379 | 2 aukštas
1440380 | 2 aukštas
1440381 | 2 aukštas
1440382 | 2 aukštas
1440383 | 2 aukštas
1440384 | 2 aukštas
1440385 | 2 aukštas
1440386 | 2 aukštas
1440387 | 2 aukštas
1440388 | 2 aukštas
1440389 | 2 aukštas
1440396 | 2 aukštas
1440397 | 2 aukštas
1440402 | 2 aukštas
1440406 | 2 aukštas
1440411 | 2 aukštas
1440416 | 2 aukštas
1440417 | 2 aukštas
1440420 | 2 aukštas
1440427 | 2 aukštas
1462192 | 2 aukštas
1462193 | 2 aukštas
1462197 | 2 aukštas
1462199 | 2 aukštas
1462200 | 2 aukštas
1462203 | 2 aukštas
1462211 | 2 aukštas
1462229 | 3 aukštas
1462231 | 3 aukštas
1462232 | 3 aukštas
1462235 | 3 aukštas
1462242 | 3 aukštas
1462244 | 3 aukštas
1462250 | 3 aukštas
1462251 | 3 aukštas
1462252 | 3 aukštas
1462254 | 3 aukštas
1462255 | 3 aukštas
1462256 | 3 aukštas
1462259 | 3 aukštas
1462260 | 3 aukštas
1462261 | 3 aukštas
1462265 | 3 aukštas
1462266 | 3 aukštas
1462267 | 3 aukštas
1462270 | 3 aukštas
1462274 | 3 aukštas
1462277 | 3 aukštas
1462278 | 3 aukštas
1462281 | 3 aukštas
1462284 | 3 aukštas
1462289 | 4 aukštas
1462292 | 4 aukštas
1462295 | 4 aukštas
1462299 | 4 aukštas
1462301 | 4 aukštas
1462304 | 4 aukštas
1462308 | 4 aukštas
1462319 | 4 aukštas
1462329 | 4 aukštas
1462356 | 4 aukštas
1462357 | 4 aukštas
1462358 | 4 aukštas
1462359 | 4 aukštas
1462360 | 4 aukštas
1462361 | 4 aukštas
1462362 | 4 aukštas
1462363 | 4 aukštas
1462367 | 4 aukštas
1462379 | 4 aukštas
1462380 | 4 aukštas
1462381 | 4 aukštas
1462382 | 4 aukštas
1462383 | 4 aukštas
1462390 | 4 aukštas
1462398 | 4 aukštas
1462399 | 4 aukštas
1462403 | 4 aukštas
1462404 | 4 aukštas
1493004 | 2 aukštas
1493005 | 2 aukštas
1493009 | 2 aukštas
1493119 | 2 aukštas
1493574 | 2 aukštas
1493837 | 2 aukštas
1494116 | 2 aukštas
1494325 | 2 aukštas
1494577 | 2 aukštas
1494823 | 2 aukštas
1495071 | 2 aukštas
1495220 | 2 aukštas
1514011 | 2 aukštas
1514679 | 2 aukštas
1515341 | 2 aukštas
1515464 | 2 aukštas
1901942 | 2 aukštas

# IfcFlowController: AS_Pagalbos iškvietimo mygtukas su virvute sieninis:Mygtukas su virvute (61)
Type - Material: String - Red, Plastic - White (31)
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: Mygtukas su virvute; sets with these values: 2
Name (AS_Pagalbos iškvietimo mygtukas su virvute sieninis:Mygtukas su virvute:...) | In | Material
1440350 | 2 aukštas
1440356 | 2 aukštas | String - Red, Plastic - White
1440390 | 2 aukštas | String - Red, Plastic - White
1440391 | 2 aukštas | String - Red, Plastic - White
1440392 | 2 aukštas | String - Red, Plastic - White
1440393 | 2 aukštas | String - Red, Plastic - White
1440394 | 2 aukštas | String - Red, Plastic - White
1440395 | 2 aukštas | String - Red, Plastic - White
1440398 | 2 aukštas | String - Red, Plastic - White
1440399 | 2 aukštas | String - Red, Plastic - White
1440403 | 2 aukštas | String - Red, Plastic - White
1440408 | 2 aukštas | String - Red, Plastic - White
1440412 | 2 aukštas | String - Red, Plastic - White
1440423 | 2 aukštas | String - Red, Plastic - White
1440424 | 2 aukštas | String - Red, Plastic - White
1440425 | 2 aukštas | String - Red, Plastic - White
1440429 | 2 aukštas | String - Red, Plastic - White
1462204 | 2 aukštas | String - Red, Plastic - White
1462205 | 2 aukštas | String - Red, Plastic - White
1462206 | 2 aukštas | String - Red, Plastic - White
1462207 | 2 aukštas | String - Red, Plastic - White
1462208 | 2 aukštas | String - Red, Plastic - White
1462209 | 2 aukštas | String - Red, Plastic - White
1462210 | 2 aukštas | String - Red, Plastic - White
1462217 | 2 aukštas | String - Red, Plastic - White
1462218 | 2 aukštas | String - Red, Plastic - White
1462223 | 2 aukštas | String - Red, Plastic - White
1462226 | 2 aukštas | String - Red, Plastic - White
1462245 | 3 aukštas | String - Red, Plastic - White
1462290 | 4 aukštas | String - Red, Plastic - White
1462293 | 4 aukštas | String - Red, Plastic - White
1462297 | 4 aukštas | String - Red, Plastic - White
1462300 | 4 aukštas | String - Red, Plastic - White
1462302 | 4 aukštas | String - Red, Plastic - White
1462306 | 4 aukštas | String - Red, Plastic - White
1462307 | 4 aukštas | String - Red, Plastic - White
1462315 | 4 aukštas | String - Red, Plastic - White
1462318 | 4 aukštas | String - Red, Plastic - White
1462331 | 4 aukštas | String - Red, Plastic - White
1462340 | 4 aukštas | String - Red, Plastic - White
1462341 | 4 aukštas | String - Red, Plastic - White
1462342 | 4 aukštas | String - Red, Plastic - White
1462343 | 4 aukštas | String - Red, Plastic - White
1462344 | 4 aukštas | String - Red, Plastic - White
1462345 | 4 aukštas | String - Red, Plastic - White
1462346 | 4 aukštas | String - Red, Plastic - White
1462347 | 4 aukštas | String - Red, Plastic - White
1462364 | 4 aukštas | String - Red, Plastic - White
1462374 | 4 aukštas | String - Red, Plastic - White
1462375 | 4 aukštas | String - Red, Plastic - White
1462376 | 4 aukštas | String - Red, Plastic - White
1462377 | 4 aukštas | String - Red, Plastic - White
1462378 | 4 aukštas | String - Red, Plastic - White
1462395 | 4 aukštas | String - Red, Plastic - White
1462396 | 4 aukštas | String - Red, Plastic - White
1462397 | 4 aukštas | String - Red, Plastic - White
1462402 | 4 aukštas | String - Red, Plastic - White
1462406 | 4 aukštas | String - Red, Plastic - White
1462408 | 5 aukštas | String - Red, Plastic - White
1548493 | 1 aukštas | String - Red, Plastic - White
1548666 | 1 aukštas | String - Red, Plastic - White

# IfcFlowController: AS_Pagalbos_iskvietimo_atsaukimo_mygtukas:Pagalbos iškvietimo atsaukimo mygtukas (143)
Type - Material: Green, Red, White
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: Pagalbos iškvietimo atsaukimo mygtukas; sets with these values: 2
Name (AS_Pagalbos_iskvietimo_atsaukimo_mygtukas:Pagalbos iškvietimo atsaukimo mygtukas:...) | In
1440342 | 2 aukštas
1440345 | 2 aukštas
1440347 | 2 aukštas
1440349 | 2 aukštas
1440352 | 2 aukštas
1440354 | 2 aukštas
1440400 | 2 aukštas
1440401 | 2 aukštas
1440404 | 2 aukštas
1440407 | 2 aukštas
1440413 | 2 aukštas
1440415 | 2 aukštas
1440418 | 2 aukštas
1440419 | 2 aukštas
1440426 | 2 aukštas
1462191 | 2 aukštas
1462194 | 2 aukštas
1462196 | 2 aukštas
1462198 | 2 aukštas
1462201 | 2 aukštas
1462212 | 2 aukštas
1462213 | 2 aukštas
1462215 | 2 aukštas
1462219 | 2 aukštas
1462221 | 2 aukštas
1462224 | 2 aukštas
1462228 | 3 aukštas
1462230 | 3 aukštas
1462233 | 3 aukštas
1462234 | 3 aukštas
1462241 | 3 aukštas
1462243 | 3 aukštas
1462247 | 3 aukštas
1462249 | 3 aukštas
1462262 | 3 aukštas
1462263 | 3 aukštas
1462268 | 3 aukštas
1462271 | 3 aukštas
1462273 | 3 aukštas
1462276 | 3 aukštas
1462279 | 3 aukštas
1462282 | 3 aukštas
1462285 | 3 aukštas
1462288 | 4 aukštas
1462291 | 4 aukštas
1462296 | 4 aukštas
1462298 | 4 aukštas
1462303 | 4 aukštas
1462305 | 4 aukštas
1462309 | 4 aukštas
1462316 | 4 aukštas
1462320 | 4 aukštas
1462330 | 4 aukštas
1462348 | 4 aukštas
1462349 | 4 aukštas
1462350 | 4 aukštas
1462351 | 4 aukštas
1462352 | 4 aukštas
1462353 | 4 aukštas
1462354 | 4 aukštas
1462355 | 4 aukštas
1462366 | 4 aukštas
1462384 | 4 aukštas
1462385 | 4 aukštas
1462386 | 4 aukštas
1462387 | 4 aukštas
1462388 | 4 aukštas
1462389 | 4 aukštas
1462393 | 4 aukštas
1462394 | 4 aukštas
1462401 | 4 aukštas
1462405 | 4 aukštas
1462410 | 5 aukštas
1493003 | 2 aukštas
1493008 | 2 aukštas
1493118 | 2 aukštas
1493573 | 2 aukštas
1493807 | 2 aukštas
1494115 | 2 aukštas
1494395 | 2 aukštas
1494634 | 2 aukštas
1494824 | 2 aukštas
1495140 | 2 aukštas
1495190 | 2 aukštas
1495402 | 2 aukštas
1514012 | 2 aukštas
1514630 | 2 aukštas
1515273 | 2 aukštas
1515463 | 2 aukštas
1548491 | 1 aukštas
1548664 | 1 aukštas
1888351 | 2 aukštas
1888352 | 2 aukštas
1888353 | 2 aukštas
1888354 | 2 aukštas
1888355 | 2 aukštas
1888356 | 2 aukštas
1888357 | 2 aukštas
1888358 | 2 aukštas
1888359 | 2 aukštas
1888360 | 2 aukštas
1888361 | 2 aukštas
1888362 | 2 aukštas
1888363 | 2 aukštas
1888364 | 2 aukštas
1888365 | 2 aukštas
1888366 | 2 aukštas
1888367 | 2 aukštas
1888368 | 2 aukštas
1888369 | 2 aukštas
1888370 | 2 aukštas
1888371 | 2 aukštas
1888372 | 2 aukštas
1888373 | 2 aukštas
1888374 | 2 aukštas
1888375 | 4 aukštas
1888376 | 4 aukštas
1888377 | 4 aukštas
1888378 | 4 aukštas
1888379 | 4 aukštas
1888380 | 4 aukštas
1888381 | 4 aukštas
1888382 | 4 aukštas
1888383 | 4 aukštas
1888384 | 4 aukštas
1888385 | 4 aukštas
1888386 | 4 aukštas
1888387 | 4 aukštas
1888388 | 4 aukštas
1888389 | 4 aukštas
1888390 | 4 aukštas
1888391 | 4 aukštas
1888392 | 4 aukštas
1888393 | 4 aukštas
1888394 | 4 aukštas
1888395 | 4 aukštas
1888396 | 4 aukštas
1888397 | 4 aukštas
1888398 | 4 aukštas
1888399 | 4 aukštas
1888400 | 4 aukštas
1888401 | 4 aukštas
1888402 | 4 aukštas

# IfcFlowController: AS_WC_bukles_indikatorius:AS_WC_bukles_indikatorius (64)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Nurse Call Devices
Pset_DistributionFlowElementCommon - Reference: AS_WC_bukles_indikatorius; sets with these values: 2
Name (AS_WC_bukles_indikatorius:AS_WC_bukles_indikatorius:...) | In
1440405 | 2 aukštas
1440409 | 2 aukštas
1440414 | 2 aukštas
1440421 | 2 aukštas
1440422 | 2 aukštas
1440428 | 2 aukštas
1462202 | 2 aukštas
1462214 | 2 aukštas
1462216 | 2 aukštas
1462220 | 2 aukštas
1462222 | 2 aukštas
1462225 | 2 aukštas
1462236 | 3 aukštas
1462237 | 3 aukštas
1462238 | 3 aukštas
1462239 | 3 aukštas
1462246 | 3 aukštas
1462253 | 3 aukštas
1462264 | 3 aukštas
1462272 | 3 aukštas
1462275 | 3 aukštas
1462280 | 3 aukštas
1462286 | 3 aukštas
1462294 | 4 aukštas
1462310 | 4 aukštas
1462312 | 4 aukštas
1462313 | 4 aukštas
1462317 | 4 aukštas
1462332 | 4 aukštas
1462333 | 4 aukštas
1462335 | 4 aukštas
1462336 | 4 aukštas
1462337 | 4 aukštas
1462338 | 4 aukštas
1462368 | 4 aukštas
1462369 | 4 aukštas
1462370 | 4 aukštas
1462372 | 4 aukštas
1462373 | 4 aukštas
1462392 | 4 aukštas
1493006 | 2 aukštas
1493010 | 2 aukštas
1493120 | 2 aukštas
1493121 | 2 aukštas
1493575 | 2 aukštas
1493576 | 2 aukštas
1493903 | 2 aukštas
1493904 | 2 aukštas
1494002 | 2 aukštas
1494003 | 2 aukštas
1494238 | 2 aukštas
1494239 | 2 aukštas
1494479 | 2 aukštas
1494822 | 2 aukštas
1494973 | 2 aukštas
1495277 | 2 aukštas
1495372 | 2 aukštas
1514587 | 2 aukštas
1514736 | 2 aukštas
1514801 | 2 aukštas
1515137 | 2 aukštas
1515437 | 2 aukštas
1999194 | 4 aukštas
1999198 | 4 aukštas

# IfcFlowTerminal: AS_Telefonspynė:Telefonspynė (43)
Type - Material: <Unnamed>, Color RGB 095-095-095, Color RGB 192-192-192, Default, Color RGB 041-000-083, Color RGB 159-181-168
Type - Pset_ProductRequirements - Category: Security Devices
Pset_DistributionFlowElementCommon - Reference: Telefonspynė; sets with these values: 2
Name (AS_Telefonspynė:Telefonspynė:...) | In
1765707 | 4 aukštas
1765791 | 4 aukštas
1765917 | 4 aukštas
1766012 | 4 aukštas
1766119 | 4 aukštas
1766245 | 4 aukštas
1766424 | 4 aukštas
1783441 | 4 aukštas
1783655 | 4 aukštas
1783753 | 4 aukštas
1787194 | 5 aukštas
1787260 | 5 aukštas
1820010 | 2 aukštas
1820160 | 2 aukštas
1820373 | 2 aukštas
1820470 | 2 aukštas
1820575 | 2 aukštas
1820727 | 2 aukštas
1820839 | 2 aukštas
1820928 | 2 aukštas
1821018 | 2 aukštas
1821110 | 2 aukštas
1821167 | 2 aukštas
1821274 | 2 aukštas
1821431 | 2 aukštas
1821534 | 2 aukštas
1821585 | 2 aukštas
1821728 | 2 aukštas
1821877 | 2 aukštas
1836896 | 1 aukštas
1837020 | 1 aukštas
1837213 | 1 aukštas
1837346 | 1 aukštas
1837459 | 1 aukštas
1837529 | 1 aukštas
1837611 | 1 aukštas
1837668 | 1 aukštas
1837749 | 1 aukštas
1844658 | Rūsys
1844783 | Rūsys
1845429 | Rūsys
1845520 | Rūsys
1992482 | 2 aukštas

# IfcFlowTerminal: AS_Telefonspynės ragelis:Telefonspynės ragelis (16)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_DistributionFlowElementCommon - Reference: Telefonspynės ragelis; sets with these values: 2
Name (AS_Telefonspynės ragelis:Telefonspynės ragelis:...) | In | Material
1766674 | 4 aukštas
1766748 | 4 aukštas | <Unnamed>
1767058 | 4 aukštas | <Unnamed>
1800104 | 5 aukštas | <Unnamed>
1827412 | 2 aukštas | <Unnamed>
1828076 | 2 aukštas | <Unnamed>
1828266 | 2 aukštas | <Unnamed>
1828518 | 2 aukštas | <Unnamed>
1829288 | 2 aukštas | <Unnamed>
1835447 | 2 aukštas | <Unnamed>
1855952 | 2 aukštas | <Unnamed>
1856876 | 1 aukštas | <Unnamed>
1868077 | Rūsys | <Unnamed>
1868078 | Rūsys | <Unnamed>
1868079 | Rūsys | <Unnamed>
1868080 | 2 aukštas | <Unnamed>

# IfcFlowTerminal: ER_Kabelio_rezervas:Kabelio_rezervas_su_dezute (58)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: Kabelio_rezervas_su_dezute; sets with these values: 2
Name (ER_Kabelio_rezervas:Kabelio_rezervas_su_dezute:...) | In
1848597 | 4 aukštas
1848762 | 4 aukštas
1848859 | 4 aukštas
1849008 | 4 aukštas
1849012 | 4 aukštas
1849058 | 4 aukštas
1849062 | 4 aukštas
1849164 | 4 aukštas
1849437 | 4 aukštas
1849545 | 4 aukštas
1849648 | 4 aukštas
1849716 | 4 aukštas
1849795 | 4 aukštas
1849927 | 4 aukštas
1850089 | 4 aukštas
1850194 | 4 aukštas
1850281 | 4 aukštas
1850388 | 4 aukštas
1850469 | 4 aukštas
1850728 | 4 aukštas
1850802 | 4 aukštas
1850908 | 4 aukštas
1851009 | 4 aukštas
1851069 | 4 aukštas
1851102 | 4 aukštas
1851195 | 4 aukštas
1851247 | 4 aukštas
1851335 | 4 aukštas
1851535 | 3 aukštas
1851593 | 3 aukštas
1851677 | 3 aukštas
1851799 | 3 aukštas
1851869 | 3 aukštas
1851993 | 3 aukštas
1852083 | 3 aukštas
1852485 | 3 aukštas
1852613 | 3 aukštas
1852701 | 3 aukštas
1852741 | 3 aukštas
1852841 | 3 aukštas
1853218 | 3 aukštas
1855954 | 3 aukštas
1855955 | 3 aukštas
1855956 | 3 aukštas
1855958 | 2 aukštas
1855959 | 2 aukštas
1855960 | 2 aukštas
1855961 | 2 aukštas
1855962 | 2 aukštas
1855963 | 2 aukštas
1855964 | 2 aukštas
1855965 | 2 aukštas
1855966 | 2 aukštas
1855967 | 2 aukštas
1855977 | 2 aukštas
1856209 | 2 aukštas
1856263 | 2 aukštas
1856333 | 2 aukštas
