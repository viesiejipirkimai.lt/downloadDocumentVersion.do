Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 22.612096
Time: 2023-07-27T13:56:26
Author: UAB "Projectum", mindaugas@projectum.lt
Written by: ODA IFC SDK 22.8
Made in: 22.1.40.58 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcProject, 22.612096
LongName: Gydymo paskirties pastato Santariškių g. 2, Vilniuje, statybos projektas; Phase: TP

# IfcSite, Santariškių g. 2, Vilnius
RefLatitude: 54, 45, 7, 339197; RefLongitude: 25, 16, 31, 313663; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 6
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (6)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Rūsys | Rūsys | 149080
1 aukštas | 1 aukštas | 152840
2 aukštas | 2 aukštas | 157340
3 aukštas | 3 aukštas | 162140
4 aukštas | 4 aukštas | 166640
5 aukštas | 5 aukštas | 171140

# IfcBuildingElementProxy: AS_Avarinis_duru_atblokavimo_mygtukas:Avarinis durų atidarymo mygtukas, AS_Avarinis_duru_atblokavimo_mygtukas:Avarinis durų atidarymo mygtukas:2206271
In: 1 aukštas
Type - Material: White, Green
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Avarinis durų atidarymo mygtukas; sets with these values: 2

# IfcBuildingElementProxy: AS_Centrale:Apsauginės signalizacijos centralė (2)
In: 1 aukštas
Type - Material: White
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Apsauginės signalizacijos centralė; sets with these values: 2
Pset_ProvisionForVoid - Width: 450 mm; Height: 185 mm; Depth: 960 mm
Name (AS_Centrale:Apsauginės signalizacijos centralė:...)
1493239
2001331

# IfcBuildingElementProxy: AS_Deze_kontroleriams:Dėžė AC moduliams (11)
Type - Material: White
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Dėžė AC moduliams; sets with these values: 2
Pset_ProvisionForVoid - Width: 320 mm; Height: 120 mm; Depth: 400 mm
Name (AS_Deze_kontroleriams:Dėžė AC moduliams:...) | In
1998663 | 1 aukštas
1998832 | 1 aukštas
1998868 | Rūsys
1998890 | Rūsys
1998949 | 2 aukštas
1998998 | 2 aukštas
1999021 | 3 aukštas
1999043 | 3 aukštas
1999092 | 4 aukštas
1999141 | 4 aukštas
1999164 | 5 aukštas

# IfcBuildingElementProxy: AS_Deze_kontroleriams:Dėžė durų kontroleriams (11)
Type - Material: White
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Dėžė durų kontroleriams; sets with these values: 2
Pset_ProvisionForVoid - Width: 320 mm; Height: 120 mm; Depth: 400 mm
Name (AS_Deze_kontroleriams:Dėžė durų kontroleriams:...) | In
1994335 | Rūsys
1994665 | Rūsys
1994728 | 1 aukštas
1994804 | 1 aukštas
1994868 | 2 aukštas
1994870 | 2 aukštas
1994878 | 3 aukštas
1994880 | 3 aukštas
1994883 | 4 aukštas
1994885 | 4 aukštas
1994897 | 5 aukštas

# IfcBuildingElementProxy: AS_Duru_spyna:Elektromagnetinė sklendė (132)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Elektromagnetinė sklendė; sets with these values: 2
Pset_ProvisionForVoid - Width: 32 mm; Height: 41 mm; Depth: 124 mm
Name (AS_Duru_spyna:Elektromagnetinė sklendė:...) | In
1774909 | 4 aukštas
1775403 | 4 aukštas
1775478 | 4 aukštas
1775628 | 4 aukštas
1775707 | 4 aukštas
1775812 | 4 aukštas
1776004 | 4 aukštas
1776287 | 4 aukštas
1776391 | 4 aukštas
1777414 | 4 aukštas
1777520 | 4 aukštas
1777688 | 4 aukštas
1777791 | 4 aukštas
1777999 | 4 aukštas
1778346 | 4 aukštas
1778435 | 4 aukštas
1778466 | 4 aukštas
1778577 | 4 aukštas
1778669 | 4 aukštas
1778783 | 4 aukštas
1778837 | 4 aukštas
1778956 | 4 aukštas
1779076 | 4 aukštas
1784475 | 4 aukštas
1784570 | 4 aukštas
1788452 | 5 aukštas
1788481 | 5 aukštas
1788583 | 5 aukštas
1788819 | 5 aukštas
1789030 | 5 aukštas
1789200 | 5 aukštas
1789330 | 5 aukštas
1789412 | 5 aukštas
1789488 | 5 aukštas
1789575 | 5 aukštas
1789668 | 5 aukštas
1790184 | 5 aukštas
1790266 | 5 aukštas
1790350 | 5 aukštas
1790388 | 5 aukštas
1804626 | 3 aukštas
1804732 | 3 aukštas
1804872 | 3 aukštas
1805004 | 3 aukštas
1805056 | 3 aukštas
1805112 | 3 aukštas
1805206 | 3 aukštas
1805265 | 3 aukštas
1805453 | 3 aukštas
1805533 | 3 aukštas
1805591 | 3 aukštas
1805620 | 3 aukštas
1805770 | 3 aukštas
1805867 | 3 aukštas
1805959 | 3 aukštas
1806012 | 3 aukštas
1813571 | 2 aukštas
1813572 | 2 aukštas
1823111 | 2 aukštas
1823411 | 2 aukštas
1823589 | 2 aukštas
1823889 | 2 aukštas
1823980 | 2 aukštas
1824115 | 2 aukštas
1824261 | 2 aukštas
1824286 | 2 aukštas
1824371 | 2 aukštas
1824493 | 2 aukštas
1824497 | 2 aukštas
1824501 | 2 aukštas
1824554 | 2 aukštas
1824675 | 2 aukštas
1824736 | 2 aukštas
1824827 | 2 aukštas
1824919 | 2 aukštas
1825013 | 2 aukštas
1825181 | 2 aukštas
1825199 | 2 aukštas
1825229 | 2 aukštas
1825281 | 2 aukštas
1825285 | 2 aukštas
1825345 | 2 aukštas
1825587 | 2 aukštas
1825749 | 2 aukštas
1825895 | 2 aukštas
1825963 | 2 aukštas
1826040 | 2 aukštas
1826079 | 2 aukštas
1826153 | 2 aukštas
1826208 | 2 aukštas
1826292 | 2 aukštas
1826364 | 2 aukštas
1826397 | 2 aukštas
1826637 | 2 aukštas
1826675 | 2 aukštas
1826697 | 2 aukštas
1826736 | 2 aukštas
1838259 | 1 aukštas
1838405 | 1 aukštas
1838493 | 1 aukštas
1838659 | 1 aukštas
1838733 | 1 aukštas
1838807 | 1 aukštas
1838872 | 1 aukštas
1839005 | 1 aukštas
1839009 | 1 aukštas
1839108 | 1 aukštas
1839234 | 1 aukštas
1839274 | 1 aukštas
1839394 | 1 aukštas
1839777 | 3 aukštas
1840075 | 2 aukštas
1840140 | 2 aukštas
1840586 | 1 aukštas
1840672 | 1 aukštas
1846359 | Rūsys
1846485 | Rūsys
1846642 | Rūsys
1846786 | Rūsys
1846855 | Rūsys
1846909 | Rūsys
1847030 | Rūsys
1847177 | Rūsys
1847279 | Rūsys
1847389 | Rūsys
1847513 | Rūsys
1887426 | Rūsys
1887720 | 2 aukštas
1970186 | Rūsys
1993243 | 2 aukštas
1993303 | 2 aukštas
2186175 | 4 aukštas

# IfcBuildingElementProxy: AS_Duru_spyna:Elektromechaninė durų spyna 5 klasės (61)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Elektromechaninė durų spyna 5 klasės; sets with these values: 2
Pset_ProvisionForVoid - Width: 32 mm; Height: 41 mm; Depth: 124 mm
Name (AS_Duru_spyna:Elektromechaninė durų spyna 5 klasės:...) | In
1779318 | 4 aukštas
1781076 | 4 aukštas
1781306 | 4 aukštas
1781380 | 4 aukštas
1781510 | 4 aukštas
1781635 | 4 aukštas
1781671 | 4 aukštas
1781797 | 4 aukštas
1781921 | 4 aukštas
1782002 | 4 aukštas
1782154 | 4 aukštas
1787610 | 5 aukštas
1787695 | 5 aukštas
1787800 | 5 aukštas
1787912 | 5 aukštas
1789092 | 5 aukštas
1813573 | 2 aukštas
1822601 | 2 aukštas
1824505 | 2 aukštas
1826481 | 2 aukštas
1829830 | 2 aukštas
1830021 | 2 aukštas
1830193 | 2 aukštas
1830249 | 2 aukštas
1830299 | 2 aukštas
1830344 | 2 aukštas
1830402 | 2 aukštas
1830454 | 2 aukštas
1830569 | 2 aukštas
1830646 | 2 aukštas
1830729 | 2 aukštas
1830779 | 2 aukštas
1830856 | 2 aukštas
1835602 | 1 aukštas
1835734 | 1 aukštas
1835893 | 1 aukštas
1836021 | 1 aukštas
1836073 | 1 aukštas
1836120 | 1 aukštas
1836209 | 1 aukštas
1836289 | 1 aukštas
1836357 | 1 aukštas
1836539 | 1 aukštas
1836671 | 1 aukštas
1845599 | Rūsys
1845731 | Rūsys
1845898 | Rūsys
1846006 | Rūsys
1846080 | Rūsys
1886625 | Rūsys
1886699 | Rūsys
1886797 | Rūsys
1886867 | Rūsys
1887017 | Rūsys
1887119 | Rūsys
1909162 | 5 aukštas
1989286 | 5 aukštas
2177562 | Rūsys
2177564 | Rūsys
2192375 | 1 aukštas
2192376 | 1 aukštas

# IfcBuildingElementProxy: AS_Lauko sirena:AS_Lauko sirena, AS_Lauko sirena:AS_Lauko sirena:1998155
In: 1 aukštas
Type - Material: nbl_ConceptWhite
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: AS_Lauko sirena; sets with these values: 2

# IfcBuildingElementProxy: AS_Video_kamera:Lauko kamera (37)
Type - Material: Plastic - Samsung - Clear, Steel - Samsung - Dark Gray (4)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Lauko kamera; sets with these values: 2
Name (AS_Video_kamera:Lauko kamera:...) | In | Material
1731737 | Rūsys
1732113 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1732443 | Rūsys
1733242 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1733571 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1733762 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1733877 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1734079 | Rūsys
1734216 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1737078 | 1 aukštas
1737108 | 1 aukštas
1737570 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1737735 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1737772 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1737896 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1738230 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1738346 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1738384 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1738659 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1738706 | 1 aukštas
1738890 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1739149 | 1 aukštas
1739277 | 1 aukštas
1739386 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1739542 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1747966 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1748306 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1748428 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1748545 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1748679 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1752477 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1752534 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1752682 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1752811 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756157 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756932 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1757034 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray

# IfcBuildingElementProxy: AS_Video_kamera:Lauko kamera lubinė (3)
Type - Material: Plastic - Samsung - Clear, Steel - Samsung - Dark Gray (4)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Lauko kamera lubinė; sets with these values: 2
Name (AS_Video_kamera:Lauko kamera lubinė:...) | In
1732977 | Rūsys
1734458 | Rūsys | Material: Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1748120 | 2 aukštas

# IfcBuildingElementProxy: AS_Video_kamera:Vidaus kamera (40)
Type - Material: Plastic - Samsung - Clear, Steel - Samsung - Dark Gray (3)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Vidaus kamera; sets with these values: 2
Name (AS_Video_kamera:Vidaus kamera:...) | In | Material
1735223 | Rūsys
1735320 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1735440 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1735608 | Rūsys
1735762 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1735836 | Rūsys | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1740665 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1740800 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1741004 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1741167 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1742089 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1742221 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1747928 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1749562 | 2 aukštas
1749701 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1749893 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1749979 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750128 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750286 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750506 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750632 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750690 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750874 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750914 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1753252 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1753669 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1754345 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1754452 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1754579 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756298 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756350 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756628 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756662 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756710 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758038 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758318 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758468 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758502 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758542 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758576 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray

# IfcBuildingElementProxy: AS_Video_kamera:Vidaus kamera (pacientams) (4)
In: 2 aukštas
Type - Material: Plastic - Samsung - Clear, Steel - Samsung - Dark Gray (3)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Vidaus kamera (pacientams); sets with these values: 2
Name (AS_Video_kamera:Vidaus kamera (pacientams):...) | Material
1847747
1847762 | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1847886 | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1847944 | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray

# IfcBuildingElementProxy: AS_Video_kamera:Vidaus kamera lubinė (25)
Type - Material: Plastic - Samsung - Clear, Steel - Samsung - Dark Gray (3)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: Vidaus kamera lubinė; sets with these values: 2
Name (AS_Video_kamera:Vidaus kamera lubinė:...) | In | Material
1741454 | 1 aukštas
1741605 | 1 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1741931 | 1 aukštas
1749426 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750189 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750334 | 2 aukštas
1750432 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750782 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1750818 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1751164 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1753408 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1753480 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1753789 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1754006 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1754132 | 3 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756091 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756238 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756452 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756490 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756570 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756778 | 4 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1756840 | 4 aukštas
1758376 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1758420 | 5 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray
1887831 | 2 aukštas | Plastic - Samsung - Clear, Steel - Samsung - Dark Gray

# IfcBuildingElementProxy: AS_Vidine sirena:AS_Vidine sirena, AS_Vidine sirena:AS_Vidine sirena:1998388
In: 1 aukštas
Type - Material: nbl_ConceptWhite
Type - Pset_ProductRequirements - Category: Security Devices
Pset_BuildingElementProxyCommon - Reference: AS_Vidine sirena; sets with these values: 2

# IfcBuildingElementProxy: E_Kompiuteris:E_Kompiuteris (3)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: E_Kompiuteris; sets with these values: 2
Pset_ProvisionForVoid - Width: 450 mm; Height: 210 mm; Depth: 450 mm
Name (E_Kompiuteris:E_Kompiuteris:...) | In
1744534 | 1 aukštas
1848351 | 2 aukštas
1979310 | 1 aukštas

# IfcBuildingElementProxy: E_Monitorius:E_Monitorius (3)
In: 1 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: E_Monitorius; sets with these values: 2
Name (E_Monitorius:E_Monitorius:...)
1747018
1747079
1979309

# IfcBuildingElementProxy: E_Monitorius:E_Monitorius, E_Monitorius:E_Monitorius:1848352
In: 2 aukštas
Type - Material: <Unnamed> (5)
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_BuildingElementProxyCommon - Reference: E_Monitorius; sets with these values: 2

# IfcDistributionControlElement: AS_Klaviatura:AS_Klaviatura (25)
Type - Material: nbl_ConceptWhite
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: AS_Klaviatura
Name (AS_Klaviatura:AS_Klaviatura:...) | In
1440316 | Rūsys
1440317 | Rūsys
1440318 | 1 aukštas
1440319 | 1 aukštas
1440320 | 1 aukštas
1440321 | 1 aukštas
1440322 | 2 aukštas
1440323 | 2 aukštas
1440324 | 2 aukštas
1440325 | 2 aukštas
1440326 | 2 aukštas
1440327 | 2 aukštas
1440328 | 3 aukštas
1440329 | 3 aukštas
1440330 | 3 aukštas
1440331 | 3 aukštas
1440332 | 4 aukštas
1440333 | 4 aukštas
1440334 | 4 aukštas
1440335 | 4 aukštas
1440336 | 5 aukštas
1440337 | 5 aukštas
1440338 | 5 aukštas
1440339 | 1 aukštas
1467748 | 2 aukštas

# IfcDistributionControlElement: AS_Kortelių skaitytuvas:AS Kortelių skaitytuvas (263)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: AS Kortelių skaitytuvas
Name (AS_Kortelių skaitytuvas:AS Kortelių skaitytuvas:...) | In
1440340 | Rūsys
1767128 | 4 aukštas
1767288 | 4 aukštas
1767348 | 4 aukštas
1767475 | 4 aukštas
1767581 | 4 aukštas
1767715 | 4 aukštas
1767945 | 4 aukštas
1768065 | 4 aukštas
1768244 | 4 aukštas
1768355 | 4 aukštas
1768431 | 4 aukštas
1768556 | 4 aukštas
1768668 | 4 aukštas
1768768 | 4 aukštas
1768861 | 4 aukštas
1768986 | 4 aukštas
1769093 | 4 aukštas
1769274 | 4 aukštas
1769602 | 4 aukštas
1769757 | 4 aukštas
1769996 | 4 aukštas
1770350 | 4 aukštas
1770625 | 4 aukštas
1770678 | 4 aukštas
1770826 | 4 aukštas
1770830 | 4 aukštas
1770946 | 4 aukštas
1771001 | 4 aukštas
1771086 | 4 aukštas
1771362 | 4 aukštas
1771494 | 4 aukštas
1771591 | 4 aukštas
1771676 | 4 aukštas
1771721 | 4 aukštas
1771989 | 4 aukštas
1772049 | 4 aukštas
1772151 | 4 aukštas
1772279 | 4 aukštas
1772354 | 4 aukštas
1772429 | 4 aukštas
1772459 | 4 aukštas
1772545 | 4 aukštas
1772578 | 4 aukštas
1772828 | 4 aukštas
1772882 | 4 aukštas
1773008 | 4 aukštas
1773047 | 4 aukštas
1773130 | 4 aukštas
1773164 | 4 aukštas
1773213 | 4 aukštas
1773217 | 4 aukštas
1773411 | 4 aukštas
1773500 | 4 aukštas
1773504 | 4 aukštas
1773756 | 4 aukštas
1773814 | 4 aukštas
1773951 | 4 aukštas
1774011 | 4 aukštas
1774108 | 4 aukštas
1774247 | 4 aukštas
1774301 | 4 aukštas
1774390 | 4 aukštas
1774427 | 4 aukštas
1774556 | 4 aukštas
1774603 | 4 aukštas
1774693 | 4 aukštas
1784312 | 4 aukštas
1784683 | 4 aukštas
1785755 | 5 aukštas
1785756 | 5 aukštas
1785757 | 5 aukštas
1785758 | 5 aukštas
1785759 | 5 aukštas
1785760 | 5 aukštas
1785761 | 5 aukštas
1785835 | 5 aukštas
1785901 | 5 aukštas
1786208 | 5 aukštas
1786445 | 5 aukštas
1786511 | 5 aukštas
1786719 | 5 aukštas
1790535 | 5 aukštas
1790651 | 5 aukštas
1790723 | 5 aukštas
1790811 | 5 aukštas
1800207 | 5 aukštas
1802071 | 3 aukštas
1802205 | 3 aukštas
1802335 | 3 aukštas
1802508 | 3 aukštas
1802891 | 3 aukštas
1802951 | 3 aukštas
1803032 | 3 aukštas
1803134 | 3 aukštas
1803195 | 3 aukštas
1803392 | 3 aukštas
1803437 | 3 aukštas
1803499 | 3 aukštas
1803565 | 3 aukštas
1803684 | 3 aukštas
1803776 | 3 aukštas
1803861 | 3 aukštas
1803971 | 3 aukštas
1804066 | 3 aukštas
1804315 | 3 aukštas
1804361 | 3 aukštas
1813574 | 2 aukštas
1813575 | 2 aukštas
1813576 | 2 aukštas
1813577 | 2 aukštas
1813578 | 2 aukštas
1813579 | 2 aukštas
1813580 | 2 aukštas
1813581 | 2 aukštas
1813582 | 2 aukštas
1813583 | 2 aukštas
1813584 | 2 aukštas
1813585 | 2 aukštas
1813586 | 2 aukštas
1813587 | 2 aukštas
1813588 | 2 aukštas
1813589 | 2 aukštas
1813590 | 2 aukštas
1813591 | 2 aukštas
1813592 | 2 aukštas
1813593 | 2 aukštas
1813594 | 2 aukštas
1813595 | 2 aukštas
1813596 | 2 aukštas
1813597 | 2 aukštas
1813598 | 2 aukštas
1813599 | 2 aukštas
1813600 | 2 aukštas
1813601 | 2 aukštas
1813602 | 2 aukštas
1813603 | 2 aukštas
1813605 | 2 aukštas
1813606 | 2 aukštas
1813607 | 2 aukštas
1813608 | 2 aukštas
1813609 | 2 aukštas
1813891 | 2 aukštas
1814000 | 2 aukštas
1814061 | 2 aukštas
1814065 | 2 aukštas
1814171 | 2 aukštas
1814229 | 2 aukštas
1814284 | 2 aukštas
1814489 | 2 aukštas
1814587 | 2 aukštas
1814621 | 2 aukštas
1814731 | 2 aukštas
1815226 | 2 aukštas
1815333 | 2 aukštas
1815445 | 2 aukštas
1815597 | 2 aukštas
1815703 | 2 aukštas
1815796 | 2 aukštas
1815916 | 2 aukštas
1816028 | 2 aukštas
1816138 | 2 aukštas
1816142 | 2 aukštas
1816415 | 2 aukštas
1816473 | 2 aukštas
1816505 | 2 aukštas
1816543 | 2 aukštas
1816547 | 2 aukštas
1816599 | 2 aukštas
1816767 | 2 aukštas
1817062 | 2 aukštas
1817183 | 2 aukštas
1817325 | 2 aukštas
1817481 | 2 aukštas
1817581 | 2 aukštas
1817707 | 2 aukštas
1817877 | 2 aukštas
1817949 | 2 aukštas
1818233 | 2 aukštas
1818310 | 2 aukštas
1818421 | 2 aukštas
1818542 | 2 aukštas
1818636 | 2 aukštas
1818722 | 2 aukštas
1819028 | 2 aukštas
1819156 | 2 aukštas
1819284 | 2 aukštas
1819360 | 2 aukštas
1819463 | 2 aukštas
1819519 | 2 aukštas
1819687 | 2 aukštas
1819750 | 2 aukštas
1819792 | 2 aukštas
1823513 | 2 aukštas
1831521 | 1 aukštas
1831736 | 1 aukštas
1831932 | 1 aukštas
1832017 | 1 aukštas
1832117 | 1 aukštas
1832293 | 1 aukštas
1832475 | 1 aukštas
1832552 | 1 aukštas
1832698 | 1 aukštas
1832855 | 1 aukštas
1832919 | 1 aukštas
1832962 | 1 aukštas
1833005 | 1 aukštas
1833084 | 1 aukštas
1833153 | 1 aukštas
1833267 | 1 aukštas
1833403 | 1 aukštas
1833606 | 1 aukštas
1833762 | 1 aukštas
1833969 | 1 aukštas
1834034 | 1 aukštas
1834086 | 1 aukštas
1834294 | 1 aukštas
1834405 | 1 aukštas
1834491 | 1 aukštas
1834534 | 1 aukštas
1834813 | 1 aukštas
1834912 | 1 aukštas
1835312 | 1 aukštas
1839967 | 2 aukštas
1840321 | 2 aukštas
1840387 | 1 aukštas
1840489 | 1 aukštas
1842851 | Rūsys
1842944 | Rūsys
1843170 | Rūsys
1843289 | Rūsys
1843470 | Rūsys
1843508 | Rūsys
1843635 | Rūsys
1843687 | Rūsys
1843871 | Rūsys
1843940 | Rūsys
1843980 | Rūsys
1844107 | Rūsys
1844231 | Rūsys
1844394 | Rūsys
1845072 | Rūsys
1845199 | Rūsys
1845264 | Rūsys
1870209 | 4 aukštas
1871263 | 1 aukštas
1885143 | Rūsys
1885233 | Rūsys
1885291 | Rūsys
1885381 | Rūsys
1885477 | Rūsys
1885674 | Rūsys
1885723 | Rūsys
1887621 | 2 aukštas
1908909 | 5 aukštas
1989189 | 5 aukštas
1992664 | 2 aukštas
1992736 | 2 aukštas
1992855 | 2 aukštas
2177561 | Rūsys
2177733 | Rūsys
2192373 | 1 aukštas
2192374 | 1 aukštas

# IfcDistributionControlElement: AS_Magnetinis_kontaktas:AS Magnetinis kontaktas (445)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: AS Magnetinis kontaktas
Name (AS_Magnetinis_kontaktas:AS Magnetinis kontaktas:...) | In
1343430 | Rūsys
1344084 | Rūsys
1344085 | Rūsys
1344148 | Rūsys
1344149 | Rūsys
1344176 | Rūsys
1344177 | Rūsys
1344193 | Rūsys
1344194 | Rūsys
1344241 | Rūsys
1344494 | Rūsys
1344495 | Rūsys
1344573 | Rūsys
1344630 | Rūsys
1344656 | Rūsys
1344657 | Rūsys
1344690 | Rūsys
1344691 | Rūsys
1344716 | Rūsys
1344809 | Rūsys
1344855 | Rūsys
1344856 | Rūsys
1344910 | Rūsys
1345193 | Rūsys
1345238 | Rūsys
1345239 | Rūsys
1345254 | Rūsys
1345337 | Rūsys
1345399 | Rūsys
1345450 | Rūsys
1345485 | Rūsys
1345527 | Rūsys
1345586 | Rūsys
1345947 | 1 aukštas
1346202 | 1 aukštas
1346203 | 1 aukštas
1346225 | 1 aukštas
1346226 | 1 aukštas
1346269 | 1 aukštas
1346270 | 1 aukštas
1346284 | 1 aukštas
1346285 | 1 aukštas
1346348 | 1 aukštas
1346349 | 1 aukštas
1346490 | 1 aukštas
1346601 | 1 aukštas
1346638 | 1 aukštas
1346680 | 1 aukštas
1346733 | 1 aukštas
1348435 | 1 aukštas
1348524 | 1 aukštas
1348603 | 1 aukštas
1348665 | 1 aukštas
1348769 | 1 aukštas
1348770 | 1 aukštas
1348786 | 1 aukštas
1348787 | 1 aukštas
1348822 | 1 aukštas
1348823 | 1 aukštas
1348869 | 1 aukštas
1348870 | 1 aukštas
1348928 | 1 aukštas
1348929 | 1 aukštas
1349036 | 1 aukštas
1349173 | 1 aukštas
1349232 | 1 aukštas
1349291 | 1 aukštas
1349333 | 1 aukštas
1349412 | 1 aukštas
1349413 | 1 aukštas
1349538 | 1 aukštas
1350086 | 1 aukštas
1350163 | 1 aukštas
1350259 | 1 aukštas
1350293 | 1 aukštas
1350448 | 1 aukštas
1350847 | 2 aukštas
1350914 | 2 aukštas
1350950 | 2 aukštas
1350990 | 2 aukštas
1351039 | 2 aukštas
1351093 | 2 aukštas
1351105 | 2 aukštas
1351113 | 2 aukštas
1351121 | 2 aukštas
1351224 | 2 aukštas
1351263 | 2 aukštas
1351271 | 2 aukštas
1351279 | 2 aukštas
1351291 | 2 aukštas
1351409 | 2 aukštas
1351429 | 2 aukštas
1351524 | 2 aukštas
1351567 | 2 aukštas
1351610 | 2 aukštas
1351640 | 2 aukštas
1351648 | 2 aukštas
1351656 | 2 aukštas
1351772 | 2 aukštas
1351840 | 2 aukštas
1351880 | 2 aukštas
1351948 | 2 aukštas
1352032 | 2 aukštas
1352111 | 2 aukštas
1352151 | 2 aukštas
1352193 | 2 aukštas
1352312 | 2 aukštas
1352365 | 2 aukštas
1352438 | 2 aukštas
1352493 | 2 aukštas
1352642 | 2 aukštas
1352650 | 2 aukštas
1352761 | 2 aukštas
1352833 | 2 aukštas
1352903 | 2 aukštas
1352973 | 2 aukštas
1353017 | 2 aukštas
1353080 | 2 aukštas
1353104 | 2 aukštas
1353165 | 2 aukštas
1353216 | 2 aukštas
1353310 | 2 aukštas
1353336 | 2 aukštas
1353470 | 2 aukštas
1353534 | 2 aukštas
1353544 | 2 aukštas
1353623 | 2 aukštas
1353673 | 2 aukštas
1353727 | 2 aukštas
1353799 | 2 aukštas
1353872 | 2 aukštas
1353909 | 2 aukštas
1353941 | 2 aukštas
1354011 | 2 aukštas
1354053 | 2 aukštas
1354097 | 2 aukštas
1354136 | 2 aukštas
1354171 | 2 aukštas
1354172 | 2 aukštas
1354224 | 2 aukštas
1354300 | 2 aukštas
1354341 | 2 aukštas
1354414 | 2 aukštas
1354450 | 2 aukštas
1354500 | 2 aukštas
1354542 | 2 aukštas
1354576 | 2 aukštas
1354651 | 2 aukštas
1354708 | 2 aukštas
1354766 | 2 aukštas
1354801 | 2 aukštas
1354854 | 2 aukštas
1354922 | 2 aukštas
1358967 | 2 aukštas
1358968 | 2 aukštas
1358969 | 2 aukštas
1358970 | 2 aukštas
1358971 | 2 aukštas
1358972 | 2 aukštas
1358973 | 2 aukštas
1358974 | 2 aukštas
1358975 | 2 aukštas
1358976 | 2 aukštas
1358977 | 2 aukštas
1358978 | 2 aukštas
1358979 | 2 aukštas
1358980 | 2 aukštas
1358981 | 2 aukštas
1358982 | 2 aukštas
1358983 | 2 aukštas
1358984 | 2 aukštas
1358985 | 2 aukštas
1358986 | 2 aukštas
1358987 | 2 aukštas
1358988 | 2 aukštas
1358989 | 2 aukštas
1358990 | 2 aukštas
1358991 | 2 aukštas
1358993 | 2 aukštas
1358994 | 2 aukštas
1358995 | 2 aukštas
1358996 | 3 aukštas
1358997 | 3 aukštas
1358998 | 3 aukštas
1358999 | 3 aukštas
1359000 | 3 aukštas
1359001 | 3 aukštas
1359002 | 3 aukštas
1359003 | 3 aukštas
1359004 | 3 aukštas
1359005 | 3 aukštas
1359006 | 3 aukštas
1359007 | 3 aukštas
1359008 | 3 aukštas
1359009 | 3 aukštas
1359010 | 3 aukštas
1359011 | 3 aukštas
1359012 | 3 aukštas
1359013 | 3 aukštas
1359014 | 3 aukštas
1359015 | 3 aukštas
1359016 | 3 aukštas
1359017 | 3 aukštas
1359018 | 3 aukštas
1359019 | 3 aukštas
1359020 | 3 aukštas
1359021 | 3 aukštas
1359022 | 3 aukštas
1359023 | 3 aukštas
1359024 | 3 aukštas
1359087 | 3 aukštas
1359134 | 3 aukštas
1359227 | 3 aukštas
1359266 | 3 aukštas
1359320 | 3 aukštas
1359380 | 3 aukštas
1359429 | 3 aukštas
1359474 | 3 aukštas
1359526 | 3 aukštas
1359561 | 3 aukštas
1359604 | 3 aukštas
1359664 | 3 aukštas
1359718 | 3 aukštas
1359788 | 3 aukštas
1359839 | 3 aukštas
1360213 | 3 aukštas
1360266 | 3 aukštas
1360325 | 3 aukštas
1360363 | 3 aukštas
1360414 | 3 aukštas
1360477 | 3 aukštas
1360558 | 3 aukštas
1360631 | 3 aukštas
1360662 | 3 aukštas
1360711 | 3 aukštas
1360763 | 3 aukštas
1360790 | 3 aukštas
1360845 | 3 aukštas
1360898 | 3 aukštas
1360942 | 3 aukštas
1361105 | 3 aukštas
1361161 | 4 aukštas
1361437 | 4 aukštas
1361517 | 4 aukštas
1361559 | 4 aukštas
1361624 | 4 aukštas
1361666 | 4 aukštas
1361736 | 4 aukštas
1361791 | 4 aukštas
1361840 | 4 aukštas
1361915 | 4 aukštas
1361968 | 4 aukštas
1362021 | 4 aukštas
1362089 | 4 aukštas
1362131 | 4 aukštas
1362196 | 4 aukštas
1362230 | 4 aukštas
1362259 | 4 aukštas
1362294 | 4 aukštas
1362333 | 4 aukštas
1362386 | 4 aukštas
1362427 | 4 aukštas
1362491 | 4 aukštas
1362537 | 4 aukštas
1362611 | 4 aukštas
1362658 | 4 aukštas
1362724 | 4 aukštas
1362784 | 4 aukštas
1362829 | 4 aukštas
1362861 | 4 aukštas
1362922 | 4 aukštas
1362978 | 4 aukštas
1363034 | 4 aukštas
1363066 | 4 aukštas
1363175 | 4 aukštas
1363205 | 4 aukštas
1363277 | 4 aukštas
1363360 | 4 aukštas
1363394 | 4 aukštas
1363451 | 4 aukštas
1363495 | 4 aukštas
1363548 | 4 aukštas
1363589 | 4 aukštas
1363651 | 4 aukštas
1363701 | 4 aukštas
1363745 | 4 aukštas
1363798 | 4 aukštas
1363851 | 4 aukštas
1363917 | 4 aukštas
1363971 | 4 aukštas
1364028 | 4 aukštas
1364072 | 4 aukštas
1364124 | 4 aukštas
1364162 | 4 aukštas
1364219 | 4 aukštas
1364307 | 4 aukštas
1364357 | 4 aukštas
1364410 | 4 aukštas
1364461 | 4 aukštas
1364512 | 4 aukštas
1364555 | 4 aukštas
1364631 | 4 aukštas
1364682 | 4 aukštas
1364823 | 4 aukštas
1364874 | 4 aukštas
1364928 | 4 aukštas
1364998 | 4 aukštas
1365131 | 4 aukštas
1365189 | 4 aukštas
1365258 | 4 aukštas
1365322 | 4 aukštas
1365396 | 4 aukštas
1365441 | 4 aukštas
1365506 | 4 aukštas
1365596 | 4 aukštas
1366014 | 5 aukštas
1366095 | 5 aukštas
1366139 | 5 aukštas
1366171 | 5 aukštas
1366213 | 5 aukštas
1366255 | 5 aukštas
1366301 | 5 aukštas
1366345 | 5 aukštas
1366396 | 5 aukštas
1366458 | 5 aukštas
1366544 | 5 aukštas
1366636 | 5 aukštas
1366689 | 5 aukštas
1366750 | 5 aukštas
1366792 | 5 aukštas
1366841 | 5 aukštas
1366894 | 5 aukštas
1366943 | 5 aukštas
1366994 | 5 aukštas
1367024 | 5 aukštas
1367049 | 5 aukštas
1367092 | 5 aukštas
1367154 | 5 aukštas
1367287 | 5 aukštas
1367366 | 5 aukštas
1367466 | 5 aukštas
1367506 | 5 aukštas
1367548 | 5 aukštas
1367605 | 5 aukštas
1367670 | 5 aukštas
1367721 | 5 aukštas
1367774 | 5 aukštas
1367825 | 5 aukštas
1367874 | 5 aukštas
1400815 | 1 aukštas
1532603 | 1 aukštas
1532783 | 1 aukštas
1532845 | 1 aukštas
1532890 | 1 aukštas
1533015 | 1 aukštas
1533056 | 1 aukštas
1533066 | 1 aukštas
1533076 | 1 aukštas
1533088 | 1 aukštas
1533125 | 2 aukštas
1533218 | 2 aukštas
1533250 | 2 aukštas
1533298 | 2 aukštas
1533416 | 2 aukštas
1533455 | 2 aukštas
1533499 | 2 aukštas
1533533 | 2 aukštas
1533572 | 2 aukštas
1533613 | 2 aukštas
1533643 | 2 aukštas
1533713 | 2 aukštas
1533725 | 2 aukštas
1533733 | 2 aukštas
1533809 | 2 aukštas
1533948 | 3 aukštas
1534077 | 3 aukštas
1534176 | 3 aukštas
1534340 | 3 aukštas
1534364 | 3 aukštas
1534380 | 3 aukštas
1534392 | 3 aukštas
1534433 | 3 aukštas
1534503 | 3 aukštas
1534587 | 3 aukštas
1534595 | 3 aukštas
1534603 | 3 aukštas
1534611 | 3 aukštas
1534621 | 3 aukštas
1534711 | 4 aukštas
1534772 | 4 aukštas
1534788 | 4 aukštas
1534800 | 4 aukštas
1534853 | 4 aukštas
1535087 | 4 aukštas
1535167 | 4 aukštas
1535215 | 4 aukštas
1535223 | 4 aukštas
1535305 | 5 aukštas
1535373 | 5 aukštas
1535451 | 5 aukštas
1535536 | 5 aukštas
1535544 | 5 aukštas
1535552 | 5 aukštas
1535560 | 5 aukštas
1535568 | 5 aukštas
1535743 | Rūsys
1535799 | Rūsys
1535907 | 1 aukštas
1535959 | 1 aukštas
1536069 | 1 aukštas
1536206 | 2 aukštas
1536342 | 3 aukštas
1536407 | 3 aukštas
1536793 | 5 aukštas
1536852 | 5 aukštas
1536914 | 5 aukštas
1548462 | 5 aukštas
1548464 | 5 aukštas
1548465 | 5 aukštas
1548466 | 5 aukštas
1548468 | 5 aukštas
1548470 | Rūsys
1548472 | Rūsys
1548478 | 1 aukštas
1548479 | 1 aukštas
1548480 | 1 aukštas
1549912 | 3 aukštas
1985919 | Rūsys
1985983 | Rūsys
1986226 | 1 aukštas
1986348 | 1 aukštas
1986819 | 2 aukštas
1986883 | 2 aukštas
1986973 | 2 aukštas
1987317 | 2 aukštas
1987439 | 2 aukštas
1987487 | 2 aukštas
1987545 | 2 aukštas
1988028 | 2 aukštas
1988683 | 5 aukštas
1988759 | 5 aukštas
2205894 | Rūsys
2205895 | Rūsys
2205896 | Rūsys
2205924 | 3 aukštas

# IfcDistributionControlElement: AS_Magnetinis_kontaktas:PK Magnetinis kontaktas (168)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: PK Magnetinis kontaktas
Name (AS_Magnetinis_kontaktas:PK Magnetinis kontaktas:...) | In
1909617 | 1 aukštas
1909825 | Rūsys
1910393 | Rūsys
1910836 | Rūsys
1911132 | Rūsys
1911263 | Rūsys
1911397 | Rūsys
1911777 | Rūsys
1911925 | Rūsys
1912015 | Rūsys
1912351 | Rūsys
1912431 | Rūsys
1915201 | Rūsys
1915298 | Rūsys
1916409 | 1 aukštas
1917234 | 1 aukštas
1923143 | 1 aukštas
1923401 | 1 aukštas
1923888 | 1 aukštas
1923986 | 1 aukštas
1924078 | 1 aukštas
1929036 | 2 aukštas
1929233 | 2 aukštas
1929953 | 2 aukštas
1930102 | 2 aukštas
1930262 | 2 aukštas
1930406 | 2 aukštas
1930517 | 2 aukštas
1930647 | 2 aukštas
1930875 | 2 aukštas
1931073 | 2 aukštas
1931286 | 2 aukštas
1931412 | 2 aukštas
1931556 | 2 aukštas
1931668 | 2 aukštas
1931804 | 2 aukštas
1932361 | 2 aukštas
1932417 | 2 aukštas
1932467 | 2 aukštas
1932615 | 2 aukštas
1932710 | 2 aukštas
1932828 | 2 aukštas
1933135 | 2 aukštas
1933265 | 2 aukštas
1933377 | 2 aukštas
1933511 | 2 aukštas
1933659 | 2 aukštas
1933816 | 2 aukštas
1934122 | 2 aukštas
1934215 | 2 aukštas
1934340 | 2 aukštas
1934634 | 2 aukštas
1934839 | 2 aukštas
1934925 | 2 aukštas
1934926 | 2 aukštas
1935370 | 2 aukštas
1935531 | 2 aukštas
1935789 | 2 aukštas
1935908 | 2 aukštas
1936220 | 2 aukštas
1936467 | 2 aukštas
1937060 | 2 aukštas
1937180 | 2 aukštas
1937419 | 2 aukštas
1937533 | 2 aukštas
1937667 | 2 aukštas
1937817 | 2 aukštas
1938007 | 2 aukštas
1938085 | 2 aukštas
1938223 | 2 aukštas
1938343 | 2 aukštas
1938400 | 2 aukštas
1939849 | 3 aukštas
1940019 | 3 aukštas
1940103 | 3 aukštas
1940432 | 3 aukštas
1940499 | 3 aukštas
1940674 | 3 aukštas
1940923 | 3 aukštas
1940970 | 3 aukštas
1941051 | 3 aukštas
1941199 | 3 aukštas
1941264 | 3 aukštas
1941367 | 3 aukštas
1943516 | 4 aukštas
1943686 | 4 aukštas
1943767 | 4 aukštas
1943925 | 4 aukštas
1944387 | 4 aukštas
1944548 | 4 aukštas
1944693 | 4 aukštas
1945159 | 4 aukštas
1945266 | 4 aukštas
1945416 | 4 aukštas
1945545 | 4 aukštas
1945922 | 4 aukštas
1946040 | 4 aukštas
1946233 | 4 aukštas
1946359 | 4 aukštas
1946492 | 4 aukštas
1946716 | 4 aukštas
1946844 | 4 aukštas
1947018 | 4 aukštas
1947269 | 4 aukštas
1947360 | 4 aukštas
1947584 | 4 aukštas
1947722 | 4 aukštas
1947817 | 4 aukštas
1947971 | 4 aukštas
1948109 | 4 aukštas
1948308 | 4 aukštas
1948573 | 4 aukštas
1948805 | 4 aukštas
1949453 | 4 aukštas
1949736 | 5 aukštas
1949854 | 5 aukštas
1950123 | 5 aukštas
1950561 | 5 aukštas
1950652 | 5 aukštas
1950770 | 5 aukštas
1950840 | 5 aukštas
1951134 | 5 aukštas
1951655 | 5 aukštas
1951836 | 5 aukštas
1952051 | 5 aukštas
1952822 | 5 aukštas
1953000 | 5 aukštas
1953192 | 5 aukštas
1953561 | 5 aukštas
1953836 | 5 aukštas
1989377 | 5 aukštas
1989577 | 4 aukštas
1989794 | 4 aukštas
1989836 | 4 aukštas
1989922 | 4 aukštas
1989970 | 4 aukštas
1990034 | 4 aukštas
1990076 | 4 aukštas
1990170 | 4 aukštas
1990210 | 4 aukštas
1990274 | 4 aukštas
1990425 | 4 aukštas
1990475 | 4 aukštas
1990641 | 4 aukštas
1991034 | 2 aukštas
1991143 | 2 aukštas
1991193 | 2 aukštas
1991249 | 2 aukštas
1991385 | 2 aukštas
1991423 | 2 aukštas
1991455 | 2 aukštas
1991513 | 2 aukštas
1991553 | 2 aukštas
1991637 | 2 aukštas
1991831 | 2 aukštas
1991875 | 2 aukštas
1991939 | 2 aukštas
1991975 | 2 aukštas
1992131 | 2 aukštas
1993020 | 2 aukštas
1993108 | 2 aukštas
1993140 | 2 aukštas
2001888 | 3 aukštas
2177920 | Rūsys
2184127 | 3 aukštas
2192370 | 4 aukštas
2192378 | 1 aukštas
2205910 | 3 aukštas

# IfcDistributionControlElement: AS_Magnetinis_kontaktas:PK Magnetinis kontaktas dvigubas (55)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: PK Magnetinis kontaktas dvigubas
Name (AS_Magnetinis_kontaktas:PK Magnetinis kontaktas dvigubas:...) | In | Material
1909370 | 1 aukštas
1910120 | Rūsys | <Unnamed>
1912526 | Rūsys | <Unnamed>
1913150 | Rūsys | <Unnamed>
1913234 | Rūsys | <Unnamed>
1913336 | Rūsys | <Unnamed>
1913653 | Rūsys | <Unnamed>
1913762 | Rūsys | <Unnamed>
1913904 | Rūsys | <Unnamed>
1914112 | Rūsys | <Unnamed>
1914351 | Rūsys | <Unnamed>
1914629 | Rūsys | <Unnamed>
1917517 | 1 aukštas | <Unnamed>
1917980 | 1 aukštas | <Unnamed>
1918279 | 1 aukštas | <Unnamed>
1918399 | 1 aukštas | <Unnamed>
1918670 | 1 aukštas | <Unnamed>
1918943 | 1 aukštas | <Unnamed>
1919133 | 1 aukštas | <Unnamed>
1919351 | 1 aukštas | <Unnamed>
1919573 | 1 aukštas | <Unnamed>
1919808 | 1 aukštas | <Unnamed>
1920131 | 1 aukštas | <Unnamed>
1920501 | 1 aukštas | <Unnamed>
1920993 | 1 aukštas | <Unnamed>
1921574 | 1 aukštas | <Unnamed>
1921989 | 1 aukštas | <Unnamed>
1922853 | 1 aukštas
1925405 | 1 aukštas | <Unnamed>
1925755 | 2 aukštas | <Unnamed>
1925944 | 2 aukštas | <Unnamed>
1926076 | 2 aukštas | <Unnamed>
1926389 | 2 aukštas | <Unnamed>
1927080 | 2 aukštas | <Unnamed>
1927351 | 2 aukštas | <Unnamed>
1927742 | 2 aukštas | <Unnamed>
1927982 | 2 aukštas | <Unnamed>
1928289 | 2 aukštas | <Unnamed>
1934536 | 2 aukštas | <Unnamed>
1938929 | 3 aukštas | <Unnamed>
1938975 | 3 aukštas | <Unnamed>
1939075 | 3 aukštas | <Unnamed>
1939328 | 3 aukštas | <Unnamed>
1941796 | 3 aukštas | <Unnamed>
1941952 | 4 aukštas | <Unnamed>
1942040 | 4 aukštas | <Unnamed>
1942845 | 4 aukštas | <Unnamed>
1943194 | 4 aukštas | <Unnamed>
1943363 | 4 aukštas | <Unnamed>
1944234 | 4 aukštas | <Unnamed>
1949735 | 5 aukštas | <Unnamed>
1953351 | 5 aukštas | <Unnamed>
1989506 | 4 aukštas | <Unnamed>
2177563 | Rūsys | <Unnamed>
2192377 | 1 aukštas | <Unnamed>

# IfcDistributionControlElement: AS_judesio_jutiklis:AS judesio jutiklis IR spindulių (409)
Type - Material: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Generic
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: AS judesio jutiklis IR spindulių
Name (AS_judesio_jutiklis:AS judesio jutiklis IR spindulių:...) | In
1369134 | Rūsys
1369158 | Rūsys
1369199 | Rūsys
1375703 | Rūsys
1375772 | Rūsys
1375804 | Rūsys
1375844 | Rūsys
1375898 | Rūsys
1375956 | Rūsys
1375989 | Rūsys
1376057 | Rūsys
1376088 | Rūsys
1376170 | Rūsys
1376672 | Rūsys
1376787 | Rūsys
1376830 | Rūsys
1376899 | Rūsys
1376994 | Rūsys
1377050 | Rūsys
1377086 | Rūsys
1377139 | Rūsys
1377342 | Rūsys
1377377 | Rūsys
1377452 | Rūsys
1377495 | Rūsys
1377533 | Rūsys
1377595 | Rūsys
1377623 | Rūsys
1377651 | Rūsys
1377693 | Rūsys
1377723 | Rūsys
1378011 | 1 aukštas
1378273 | 1 aukštas
1378567 | 1 aukštas
1378602 | 1 aukštas
1378671 | 1 aukštas
1378703 | 1 aukštas
1378749 | 1 aukštas
1378779 | 1 aukštas
1378838 | 1 aukštas
1378897 | 1 aukštas
1378944 | 1 aukštas
1378982 | 1 aukštas
1379026 | 1 aukštas
1379152 | 1 aukštas
1379186 | 1 aukštas
1379218 | 1 aukštas
1379250 | 1 aukštas
1379284 | 1 aukštas
1379324 | 1 aukštas
1379366 | 1 aukštas
1379458 | 1 aukštas
1379560 | 1 aukštas
1379754 | 1 aukštas
1379788 | 1 aukštas
1379843 | 1 aukštas
1379899 | 1 aukštas
1380056 | 1 aukštas
1380090 | 1 aukštas
1380124 | 1 aukštas
1380157 | 1 aukštas
1380203 | 1 aukštas
1380253 | 1 aukštas
1380331 | 1 aukštas
1380367 | 1 aukštas
1380411 | 1 aukštas
1380530 | 1 aukštas
1380803 | 1 aukštas
1381085 | 1 aukštas
1381145 | 1 aukštas
1381179 | 1 aukštas
1381244 | 2 aukštas
1383244 | 2 aukštas
1383329 | 2 aukštas
1383423 | 2 aukštas
1383495 | 2 aukštas
1383537 | 2 aukštas
1383592 | 2 aukštas
1383655 | 2 aukštas
1383695 | 2 aukštas
1383741 | 2 aukštas
1383787 | 2 aukštas
1383823 | 2 aukštas
1383878 | 2 aukštas
1383910 | 2 aukštas
1383944 | 2 aukštas
1383982 | 2 aukštas
1384014 | 2 aukštas
1384040 | 2 aukštas
1384090 | 2 aukštas
1384118 | 2 aukštas
1384174 | 2 aukštas
1384211 | 2 aukštas
1384243 | 2 aukštas
1384279 | 2 aukštas
1384311 | 2 aukštas
1384348 | 2 aukštas
1384374 | 2 aukštas
1384404 | 2 aukštas
1384487 | 2 aukštas
1384540 | 2 aukštas
1384950 | 2 aukštas
1384987 | 2 aukštas
1385032 | 2 aukštas
1385080 | 2 aukštas
1385108 | 2 aukštas
1385142 | 2 aukštas
1385309 | 2 aukštas
1385340 | 2 aukštas
1385419 | 2 aukštas
1385495 | 2 aukštas
1385576 | 2 aukštas
1385613 | 2 aukštas
1385665 | 2 aukštas
1385701 | 2 aukštas
1385735 | 2 aukštas
1385848 | 2 aukštas
1385904 | 2 aukštas
1386004 | 2 aukštas
1386042 | 2 aukštas
1386094 | 2 aukštas
1386138 | 2 aukštas
1386197 | 2 aukštas
1386246 | 2 aukštas
1386278 | 2 aukštas
1386316 | 2 aukštas
1386346 | 2 aukštas
1386377 | 2 aukštas
1386413 | 2 aukštas
1386453 | 2 aukštas
1386485 | 2 aukštas
1386515 | 2 aukštas
1386549 | 2 aukštas
1386593 | 2 aukštas
1386625 | 2 aukštas
1386659 | 2 aukštas
1386847 | 2 aukštas
1386891 | 2 aukštas
1386943 | 2 aukštas
1386983 | 2 aukštas
1387015 | 2 aukštas
1387057 | 2 aukštas
1387107 | 2 aukštas
1387155 | 2 aukštas
1387197 | 2 aukštas
1387232 | 2 aukštas
1387270 | 2 aukštas
1387304 | 2 aukštas
1387342 | 2 aukštas
1387378 | 2 aukštas
1387410 | 2 aukštas
1387456 | 2 aukštas
1387489 | 2 aukštas
1387545 | 2 aukštas
1387581 | 2 aukštas
1387636 | 2 aukštas
1387668 | 2 aukštas
1387704 | 2 aukštas
1387746 | 2 aukštas
1387801 | 2 aukštas
1387860 | 2 aukštas
1387909 | 2 aukštas
1387954 | 2 aukštas
1387994 | 2 aukštas
1388026 | 2 aukštas
1388067 | 2 aukštas
1388138 | 2 aukštas
1388170 | 2 aukštas
1388206 | 2 aukštas
1388240 | 2 aukštas
1388347 | 2 aukštas
1388377 | 2 aukštas
1388439 | 2 aukštas
1388504 | 2 aukštas
1388750 | 2 aukštas
1388941 | 2 aukštas
1388979 | 2 aukštas
1389067 | 2 aukštas
1389103 | 2 aukštas
1389169 | 2 aukštas
1389193 | 2 aukštas
1389256 | 2 aukštas
1389286 | 2 aukštas
1389338 | 2 aukštas
1389388 | 2 aukštas
1389449 | 3 aukštas
1389754 | 3 aukštas
1389835 | 3 aukštas
1389884 | 3 aukštas
1389923 | 3 aukštas
1389967 | 3 aukštas
1389993 | 3 aukštas
1390021 | 3 aukštas
1390049 | 3 aukštas
1390077 | 3 aukštas
1390109 | 3 aukštas
1390155 | 3 aukštas
1390197 | 3 aukštas
1390249 | 3 aukštas
1390307 | 3 aukštas
1390375 | 3 aukštas
1390455 | 3 aukštas
1390492 | 3 aukštas
1390532 | 3 aukštas
1390562 | 3 aukštas
1390626 | 3 aukštas
1390660 | 3 aukštas
1390684 | 3 aukštas
1390712 | 3 aukštas
1390740 | 3 aukštas
1390764 | 3 aukštas
1390801 | 3 aukštas
1390837 | 3 aukštas
1390895 | 3 aukštas
1390929 | 3 aukštas
1390964 | 3 aukštas
1391082 | 3 aukštas
1391120 | 3 aukštas
1391234 | 3 aukštas
1391373 | 3 aukštas
1391533 | 3 aukštas
1391595 | 3 aukštas
1391695 | 3 aukštas
1391723 | 3 aukštas
1391749 | 3 aukštas
1391779 | 3 aukštas
1391805 | 3 aukštas
1391837 | 3 aukštas
1391869 | 3 aukštas
1391929 | 3 aukštas
1391965 | 3 aukštas
1392006 | 3 aukštas
1392034 | 3 aukštas
1392066 | 3 aukštas
1392096 | 3 aukštas
1392134 | 3 aukštas
1392162 | 3 aukštas
1392190 | 3 aukštas
1392220 | 3 aukštas
1392261 | 3 aukštas
1392299 | 3 aukštas
1392348 | 3 aukštas
1392431 | 3 aukštas
1392459 | 3 aukštas
1392513 | 3 aukštas
1392535 | 3 aukštas
1392565 | 3 aukštas
1392593 | 3 aukštas
1392617 | 3 aukštas
1392637 | 3 aukštas
1392659 | 3 aukštas
1392719 | 3 aukštas
1392818 | 3 aukštas
1392867 | 3 aukštas
1392945 | 3 aukštas
1392975 | 3 aukštas
1393008 | 2 aukštas
1393036 | 2 aukštas
1393073 | 2 aukštas
1393222 | 4 aukštas
1393464 | 4 aukštas
1393496 | 4 aukštas
1393712 | 4 aukštas
1393772 | 4 aukštas
1393796 | 4 aukštas
1393866 | 4 aukštas
1393904 | 4 aukštas
1393928 | 4 aukštas
1393958 | 4 aukštas
1393987 | 4 aukštas
1394017 | 4 aukštas
1394035 | 4 aukštas
1394061 | 4 aukštas
1394091 | 4 aukštas
1394121 | 4 aukštas
1394209 | 4 aukštas
1394249 | 4 aukštas
1394289 | 4 aukštas
1394365 | 4 aukštas
1394417 | 4 aukštas
1394465 | 4 aukštas
1394505 | 4 aukštas
1394539 | 4 aukštas
1394565 | 4 aukštas
1394593 | 4 aukštas
1394623 | 4 aukštas
1394653 | 4 aukštas
1394687 | 4 aukštas
1394722 | 4 aukštas
1394758 | 4 aukštas
1394786 | 4 aukštas
1394820 | 4 aukštas
1394866 | 4 aukštas
1394894 | 4 aukštas
1394942 | 4 aukštas
1394976 | 4 aukštas
1395004 | 4 aukštas
1395036 | 4 aukštas
1395074 | 4 aukštas
1395106 | 4 aukštas
1395154 | 4 aukštas
1395233 | 4 aukštas
1395283 | 4 aukštas
1395307 | 4 aukštas
1395362 | 4 aukštas
1395402 | 4 aukštas
1395448 | 4 aukštas
1395480 | 4 aukštas
1395518 | 4 aukštas
1395565 | 4 aukštas
1395597 | 4 aukštas
1395647 | 4 aukštas
1395681 | 4 aukštas
1395707 | 4 aukštas
1395743 | 4 aukštas
1395777 | 4 aukštas
1395841 | 4 aukštas
1395869 | 4 aukštas
1395942 | 4 aukštas
1395988 | 4 aukštas
1396022 | 4 aukštas
1396059 | 4 aukštas
1396105 | 4 aukštas
1396146 | 4 aukštas
1396199 | 4 aukštas
1396223 | 4 aukštas
1396245 | 4 aukštas
1396265 | 4 aukštas
1396289 | 4 aukštas
1396309 | 4 aukštas
1396329 | 4 aukštas
1396347 | 4 aukštas
1396369 | 4 aukštas
1396389 | 4 aukštas
1396732 | 4 aukštas
1396766 | 4 aukštas
1396792 | 4 aukštas
1396820 | 4 aukštas
1396852 | 4 aukštas
1396872 | 5 aukštas
1397275 | 5 aukštas
1397309 | 5 aukštas
1397337 | 5 aukštas
1397371 | 5 aukštas
1397409 | 5 aukštas
1397455 | 5 aukštas
1397485 | 5 aukštas
1397519 | 5 aukštas
1397543 | 5 aukštas
1397589 | 5 aukštas
1397623 | 5 aukštas
1397667 | 5 aukštas
1397713 | 5 aukštas
1397739 | 5 aukštas
1397775 | 5 aukštas
1397801 | 5 aukštas
1397823 | 5 aukštas
1397845 | 5 aukštas
1397897 | 5 aukštas
1397919 | 5 aukštas
1397939 | 5 aukštas
1397973 | 5 aukštas
1397999 | 5 aukštas
1398021 | 5 aukštas
1398076 | 5 aukštas
1398108 | 5 aukštas
1398142 | 5 aukštas
1398202 | 5 aukštas
1398230 | 5 aukštas
1398258 | 5 aukštas
1398288 | 5 aukštas
1398314 | 5 aukštas
1398348 | 5 aukštas
1398377 | 5 aukštas
1398413 | 5 aukštas
1398441 | 5 aukštas
1398509 | 5 aukštas
1398537 | 5 aukštas
1398566 | 5 aukštas
1398593 | 5 aukštas
1398617 | 5 aukštas
1398639 | 5 aukštas
1398663 | 5 aukštas
1398715 | 5 aukštas
1400854 | 1 aukštas
1536495 | 5 aukštas
1536521 | 5 aukštas
1536529 | 5 aukštas
1536537 | 5 aukštas
1548467 | 5 aukštas
1548473 | 1 aukštas
1548474 | 1 aukštas
1548482 | 1 aukštas
1549410 | Rūsys
1550981 | 2 aukštas
1551027 | 2 aukštas
1551205 | 5 aukštas
1985815 | Rūsys
1985894 | Rūsys
1985899 | Rūsys
1986558 | 3 aukštas
1986717 | 2 aukštas
1987997 | 2 aukštas
1988164 | 2 aukštas
1988202 | 2 aukštas
1988341 | 4 aukštas
1988420 | 4 aukštas
1988914 | 5 aukštas
2205923 | 3 aukštas

# IfcDistributionControlElement: AS_stiklo_duzio_detektorius:AS Stiklo dūžio detektorius (50)
Type - Material: White
Type - Pset_ProductRequirements - Category: Security Devices
Pset_QuantityTakeOff - Reference: AS Stiklo dūžio detektorius
Name (AS_stiklo_duzio_detektorius:AS Stiklo dūžio detektorius:...) | In
1398842 | 1 aukštas
1399251 | 1 aukštas
1399261 | 1 aukštas
1399269 | 1 aukštas
1399279 | 1 aukštas
1399354 | 1 aukštas
1399477 | 1 aukštas
1399633 | 1 aukštas
1399787 | 1 aukštas
1399914 | 1 aukštas
1400046 | 1 aukštas
1400157 | 1 aukštas
1400244 | 1 aukštas
1400280 | 1 aukštas
1400411 | 1 aukštas
1400528 | 1 aukštas
1400938 | 1 aukštas
1401020 | 1 aukštas
1401344 | 1 aukštas
1401666 | 1 aukštas
1401882 | 1 aukštas
1402517 | 2 aukštas
1402651 | 2 aukštas
1402766 | 2 aukštas
1403061 | 2 aukštas
1403144 | 2 aukštas
1403181 | 2 aukštas
1403215 | 2 aukštas
1403253 | 2 aukštas
1403363 | 2 aukštas
1403395 | 2 aukštas
1403429 | 2 aukštas
1403439 | 2 aukštas
1403449 | 2 aukštas
1403517 | 2 aukštas
1403630 | 2 aukštas
1403640 | 2 aukštas
1403737 | 2 aukštas
1403745 | 2 aukštas
1548475 | 1 aukštas
1548476 | 1 aukštas
1548477 | 1 aukštas
1550437 | 1 aukštas
1550445 | 1 aukštas
1550549 | 1 aukštas
1550559 | 1 aukštas
2205897 | 1 aukštas
2205905 | 1 aukštas
2205906 | 1 aukštas
2205907 | 1 aukštas

# IfcDistributionPort (2401)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_1343430
Port_1344084
Port_1344085
Port_1344148
Port_1344149
Port_1344176
Port_1344177
Port_1344193
Port_1344194
Port_1344241
Port_1344494
Port_1344495
Port_1344573
Port_1344630
Port_1344656
Port_1344657
Port_1344690
Port_1344691
Port_1344716
Port_1344809
Port_1344855
Port_1344856
Port_1344910
Port_1345193
Port_1345238
Port_1345239
Port_1345254
Port_1345337
Port_1345399
Port_1345450
Port_1345485
Port_1345527
Port_1345586
Port_1345947
Port_1346202
Port_1346203
Port_1346225
Port_1346226
Port_1346269
Port_1346270
Port_1346284
Port_1346285
Port_1346348
Port_1346349
Port_1346490
Port_1346601
Port_1346638
Port_1346680
Port_1346733
Port_1348435
Port_1348524
Port_1348603
Port_1348665
Port_1348769
Port_1348770
Port_1348786
Port_1348787
Port_1348822
Port_1348823
Port_1348869
Port_1348870
Port_1348928
Port_1348929
Port_1349036
Port_1349173
Port_1349232
Port_1349291
Port_1349333
Port_1349412
Port_1349413
Port_1349538
Port_1350086
Port_1350163
Port_1350259
Port_1350293
Port_1350448
Port_1350847
Port_1350914
Port_1350950
Port_1350990
Port_1351039
Port_1351093
Port_1351105
Port_1351113
Port_1351121
Port_1351224
Port_1351263
Port_1351271
Port_1351279
Port_1351291
Port_1351409
Port_1351429
Port_1351524
Port_1351567
Port_1351610
Port_1351640
Port_1351648
Port_1351656
Port_1351772
Port_1351840
Port_1351880
Port_1351948
Port_1352032
Port_1352111
Port_1352151
Port_1352193
Port_1352312
Port_1352365
Port_1352438
Port_1352493
Port_1352642
Port_1352650
Port_1352761
Port_1352833
Port_1352903
Port_1352973
Port_1353017
Port_1353080
Port_1353104
Port_1353165
Port_1353216
Port_1353310
Port_1353336
Port_1353470
Port_1353534
Port_1353544
Port_1353623
Port_1353673
Port_1353727
Port_1353799
Port_1353872
Port_1353909
Port_1353941
Port_1354011
Port_1354053
Port_1354097
Port_1354136
Port_1354171
Port_1354172
Port_1354224
Port_1354300
Port_1354341
Port_1354414
Port_1354450
Port_1354500
Port_1354542
Port_1354576
Port_1354651
Port_1354708
Port_1354766
Port_1354801
Port_1354854
Port_1354922
Port_1358967
Port_1358968
Port_1358969
Port_1358970
Port_1358971
Port_1358972
Port_1358973
Port_1358974
Port_1358975
Port_1358976
Port_1358977
Port_1358978
Port_1358979
Port_1358980
Port_1358981
Port_1358982
Port_1358983
Port_1358984
Port_1358985
Port_1358986
Port_1358987
Port_1358988
Port_1358989
Port_1358990
Port_1358991
Port_1358993
Port_1358994
Port_1358995
Port_1358996
Port_1358997
Port_1358998
Port_1358999
Port_1359000
Port_1359001
Port_1359002
Port_1359003
Port_1359004
Port_1359005
Port_1359006
Port_1359007
Port_1359008
Port_1359009
Port_1359010
Port_1359011
Port_1359012
Port_1359013
Port_1359014
Port_1359015
Port_1359016
Port_1359017
Port_1359018
Port_1359019
Port_1359020
Port_1359021
Port_1359022
Port_1359023
Port_1359024
Port_1359087
Port_1359134
Port_1359227
Port_1359266
Port_1359320
Port_1359380
Port_1359429
Port_1359474
Port_1359526
Port_1359561
Port_1359604
Port_1359664
Port_1359718
Port_1359788
Port_1359839
Port_1360213
Port_1360266
Port_1360325
Port_1360363
Port_1360414
Port_1360477
Port_1360558
Port_1360631
Port_1360662
Port_1360711
Port_1360763
Port_1360790
Port_1360845
Port_1360898
Port_1360942
Port_1361105
Port_1361161
Port_1361437
Port_1361517
Port_1361559
Port_1361624
Port_1361666
Port_1361736
Port_1361791
Port_1361840
Port_1361915
Port_1361968
Port_1362021
Port_1362089
Port_1362131
Port_1362196
Port_1362230
Port_1362259
Port_1362294
Port_1362333
Port_1362386
Port_1362427
Port_1362491
Port_1362537
Port_1362611
Port_1362658
Port_1362724
Port_1362784
Port_1362829
Port_1362861
Port_1362922
Port_1362978
Port_1363034
Port_1363066
Port_1363175
Port_1363205
Port_1363277
Port_1363360
Port_1363394
Port_1363451
Port_1363495
Port_1363548
Port_1363589
Port_1363651
Port_1363701
Port_1363745
Port_1363798
Port_1363851
Port_1363917
Port_1363971
Port_1364028
Port_1364072
Port_1364124
Port_1364162
Port_1364219
Port_1364307
Port_1364357
Port_1364410
Port_1364461
Port_1364512
Port_1364555
Port_1364631
Port_1364682
Port_1364823
Port_1364874
Port_1364928
Port_1364998
Port_1365131
Port_1365189
Port_1365258
Port_1365322
Port_1365396
Port_1365441
Port_1365506
Port_1365596
Port_1366014
Port_1366095
Port_1366139
Port_1366171
Port_1366213
Port_1366255
Port_1366301
Port_1366345
Port_1366396
Port_1366458
Port_1366544
Port_1366636
Port_1366689
Port_1366750
Port_1366792
Port_1366841
Port_1366894
Port_1366943
Port_1366994
Port_1367024
Port_1367049
Port_1367092
Port_1367154
Port_1367287
Port_1367366
Port_1367466
Port_1367506
Port_1367548
Port_1367605
Port_1367670
Port_1367721
Port_1367774
Port_1367825
Port_1367874
Port_1369134
Port_1369158
Port_1369199
Port_1375703
Port_1375772
Port_1375804
Port_1375844
Port_1375898
Port_1375956
Port_1375989
Port_1376057
Port_1376088
Port_1376170
Port_1376672
Port_1376787
Port_1376830
Port_1376899
Port_1376994
Port_1377050
Port_1377086
Port_1377139
Port_1377342
Port_1377377
Port_1377452
Port_1377495
Port_1377533
Port_1377595
Port_1377623
Port_1377651
Port_1377693
Port_1377723
Port_1378011
Port_1378273
Port_1378567
Port_1378602
Port_1378671
Port_1378703
Port_1378749
Port_1378779
Port_1378838
Port_1378897
Port_1378944
Port_1378982
Port_1379026
Port_1379152
Port_1379186
Port_1379218
Port_1379250
Port_1379284
Port_1379324
Port_1379366
Port_1379458
Port_1379560
Port_1379754
Port_1379788
Port_1379843
Port_1379899
Port_1380056
Port_1380090
Port_1380124
Port_1380157
Port_1380203
Port_1380253
Port_1380331
Port_1380367
Port_1380411
Port_1380530
Port_1380803
Port_1381085
Port_1381145
Port_1381179
Port_1381244
Port_1383244
Port_1383329
Port_1383423
Port_1383495
Port_1383537
Port_1383592
Port_1383655
Port_1383695
Port_1383741
Port_1383787
Port_1383823
Port_1383878
Port_1383910
Port_1383944
Port_1383982
Port_1384014
Port_1384040
Port_1384090
Port_1384118
Port_1384174
Port_1384211
Port_1384243
Port_1384279
Port_1384311
Port_1384348
Port_1384374
Port_1384404
Port_1384487
Port_1384540
Port_1384950
Port_1384987
Port_1385032
Port_1385080
Port_1385108
Port_1385142
Port_1385309
Port_1385340
Port_1385419
Port_1385495
Port_1385576
Port_1385613
Port_1385665
Port_1385701
Port_1385735
Port_1385848
Port_1385904
Port_1386004
Port_1386042
Port_1386094
Port_1386138
Port_1386197
Port_1386246
Port_1386278
Port_1386316
Port_1386346
Port_1386377
Port_1386413
Port_1386453
Port_1386485
Port_1386515
Port_1386549
Port_1386593
Port_1386625
Port_1386659
Port_1386847
Port_1386891
Port_1386943
Port_1386983
Port_1387015
Port_1387057
Port_1387107
Port_1387155
Port_1387197
Port_1387232
Port_1387270
Port_1387304
Port_1387342
Port_1387378
Port_1387410
Port_1387456
Port_1387489
Port_1387545
Port_1387581
Port_1387636
Port_1387668
Port_1387704
Port_1387746
Port_1387801
Port_1387860
Port_1387909
Port_1387954
Port_1387994
Port_1388026
Port_1388067
Port_1388138
Port_1388170
Port_1388206
Port_1388240
Port_1388347
Port_1388377
Port_1388439
Port_1388504
Port_1388750
Port_1388941
Port_1388979
Port_1389067
Port_1389103
Port_1389169
Port_1389193
Port_1389256
Port_1389286
Port_1389338
Port_1389388
Port_1389449
Port_1389754
Port_1389835
Port_1389884
Port_1389923
Port_1389967
Port_1389993
Port_1390021
Port_1390049
Port_1390077
Port_1390109
Port_1390155
Port_1390197
Port_1390249
Port_1390307
Port_1390375
Port_1390455
Port_1390492
Port_1390532
Port_1390562
Port_1390626
Port_1390660
Port_1390684
Port_1390712
Port_1390740
Port_1390764
Port_1390801
Port_1390837
Port_1390895
Port_1390929
Port_1390964
Port_1391082
Port_1391120
Port_1391234
Port_1391373
Port_1391533
Port_1391595
Port_1391695
Port_1391723
Port_1391749
Port_1391779
Port_1391805
Port_1391837
Port_1391869
Port_1391929
Port_1391965
Port_1392006
Port_1392034
Port_1392066
Port_1392096
Port_1392134
Port_1392162
Port_1392190
Port_1392220
Port_1392261
Port_1392299
Port_1392348
Port_1392431
Port_1392459
Port_1392513
Port_1392535
Port_1392565
Port_1392593
Port_1392617
Port_1392637
Port_1392659
Port_1392719
Port_1392818
Port_1392867
Port_1392945
Port_1392975
Port_1393008
Port_1393036
Port_1393073
Port_1393222
Port_1393464
Port_1393496
Port_1393712
Port_1393772
Port_1393796
Port_1393866
Port_1393904
Port_1393928
Port_1393958
Port_1393987
Port_1394017
Port_1394035
Port_1394061
Port_1394091
Port_1394121
Port_1394209
Port_1394249
Port_1394289
Port_1394365
Port_1394417
Port_1394465
Port_1394505
Port_1394539
Port_1394565
Port_1394593
Port_1394623
Port_1394653
Port_1394687
Port_1394722
Port_1394758
Port_1394786
Port_1394820
Port_1394866
Port_1394894
Port_1394942
Port_1394976
Port_1395004
Port_1395036
Port_1395074
Port_1395106
Port_1395154
Port_1395233
Port_1395283
Port_1395307
Port_1395362
Port_1395402
Port_1395448
Port_1395480
Port_1395518
Port_1395565
Port_1395597
Port_1395647
Port_1395681
Port_1395707
Port_1395743
Port_1395777
Port_1395841
Port_1395869
Port_1395942
Port_1395988
Port_1396022
Port_1396059
Port_1396105
Port_1396146
Port_1396199
Port_1396223
Port_1396245
Port_1396265
Port_1396289
Port_1396309
Port_1396329
Port_1396347
Port_1396369
Port_1396389
Port_1396732
Port_1396766
Port_1396792
Port_1396820
Port_1396852
Port_1396872
Port_1397275
Port_1397309
Port_1397337
Port_1397371
Port_1397409
Port_1397455
Port_1397485
Port_1397519
Port_1397543
Port_1397589
Port_1397623
Port_1397667
Port_1397713
Port_1397739
Port_1397775
Port_1397801
Port_1397823
Port_1397845
Port_1397897
Port_1397919
Port_1397939
Port_1397973
Port_1397999
Port_1398021
Port_1398076
Port_1398108
Port_1398142
Port_1398202
Port_1398230
Port_1398258
Port_1398288
Port_1398314
Port_1398348
Port_1398377
Port_1398413
Port_1398441
Port_1398509
Port_1398537
Port_1398566
Port_1398593
Port_1398617
Port_1398639
Port_1398663
Port_1398715
Port_1398842
Port_1399251
Port_1399261
Port_1399269
Port_1399279
Port_1399354
Port_1399477
Port_1399633
Port_1399787
Port_1399914
Port_1400046
Port_1400157
Port_1400244
Port_1400280
Port_1400411
Port_1400528
Port_1400815
Port_1400854
Port_1400938
Port_1401020
Port_1401344
Port_1401666
Port_1401882
Port_1402517
Port_1402651
Port_1402766
Port_1403061
Port_1403144
Port_1403181
Port_1403215
Port_1403253
Port_1403363
Port_1403395
Port_1403429
Port_1403439
Port_1403449
Port_1403517
Port_1403630
Port_1403640
Port_1403737
Port_1403745
Port_1440316
Port_1440317
Port_1440318
Port_1440319
Port_1440320
Port_1440321
Port_1440322
Port_1440323
Port_1440324
Port_1440325
Port_1440326
Port_1440327
Port_1440328
Port_1440329
Port_1440330
Port_1440331
Port_1440332
Port_1440333
Port_1440334
Port_1440335
Port_1440336
Port_1440337
Port_1440338
Port_1440339
Port_1440340
Port_1440342
Port_1440345
Port_1440347
Port_1440349
Port_1440350
Port_1440352
Port_1440353
Port_1440354
Port_1440355
Port_1440356
Port_1440357
Port_1440358
Port_1440359
Port_1440360
Port_1440361
Port_1440362
Port_1440363
Port_1440364
Port_1440365
Port_1440366
Port_1440367
Port_1440368
Port_1440369
Port_1440370
Port_1440371
Port_1440372
Port_1440373
Port_1440374
Port_1440375
Port_1440376
Port_1440377
Port_1440378
Port_1440379
Port_1440380
Port_1440381
Port_1440382
Port_1440383
Port_1440384
Port_1440385
Port_1440386
Port_1440387
Port_1440388
Port_1440389
Port_1440390
Port_1440391
Port_1440392
Port_1440393
Port_1440394
Port_1440395
Port_1440396
Port_1440397
Port_1440398
Port_1440399
Port_1440400
