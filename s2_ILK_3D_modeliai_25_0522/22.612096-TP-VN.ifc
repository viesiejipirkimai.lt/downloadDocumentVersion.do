Properties of the parts of a building model (IFC2X3), part 35 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1487309_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487317_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487309_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487319_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487365_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487319_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487361_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487363_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487361_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487383_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487391_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487383_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487438_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487391_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487467_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487391_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487392_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487395_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487442_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487395_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487436_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487438_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487436_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487458_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487466_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487458_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487466_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487467_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487470_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487512_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487470_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487506_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487508_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487512_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487548_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487549_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487548_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487608_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487608_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487658_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487662_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487656_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487658_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487656_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487662_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487678_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487678_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487696_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487686_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487687_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487686_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488389_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487690_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487696_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487690_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487706_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487698_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487840_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487698_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487714_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487706_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488014_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487708_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487714_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487716_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487814_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487716_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487810_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487810_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487830_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487840_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487830_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487885_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487840_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487841_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487841_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487915_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487844_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487889_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487844_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487883_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487885_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487883_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487889_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487915_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487974_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487915_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487916_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487916_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488013_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487919_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487980_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487919_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487972_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487976_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487972_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487974_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487976_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487999_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488122_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487999_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488013_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488014_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488013_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488123_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488017_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488025_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488017_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488027_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488093_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488089_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488091_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488093_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488111_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488126_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488120_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488122_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488120_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488126_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488122_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488123_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488142_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488154_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488142_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488154_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488155_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488158_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488200_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488158_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488196_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488198_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488196_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488200_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488216_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488226_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488216_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488273_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488226_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488227_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488275_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488271_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488273_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488271_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488275_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488291_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488301_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488291_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488355_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488301_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488302_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488302_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488388_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488305_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488357_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488305_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488353_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488355_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488353_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488380_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488388_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488380_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488444_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488388_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488389_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488392_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488446_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488392_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488442_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488444_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488446_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488573_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488581_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488573_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488597_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488583_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488641_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488583_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488607_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488597_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488642_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488599_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488607_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488599_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488633_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488641_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488633_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488654_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488641_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488642_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488645_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488654_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488645_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488664_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488656_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488664_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488656_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488690_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488701_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488779_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488726_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488737_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488737_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488804_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488771_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488779_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488771_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488836_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488794_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488804_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488794_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488812_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488806_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488812_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488806_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490093_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488830_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488836_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488830_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489210_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489198_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490004_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489198_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489220_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489208_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489210_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489208_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490005_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489214_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489220_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489214_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489234_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489222_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489832_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489222_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489242_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489234_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489236_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489262_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489242_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489673_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489244_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489351_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489244_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489277_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489262_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489264_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489264_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489352_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489268_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489277_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489317_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489279_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489319_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489315_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489317_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489315_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489319_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489343_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489351_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489343_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489351_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489352_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489355_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489408_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489355_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489402_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489404_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489402_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489408_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489434_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489442_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489434_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489442_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489443_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489443_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489446_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489487_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489446_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489481_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489483_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489481_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489512_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489522_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489512_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489567_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489522_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489523_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489523_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489672_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489526_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489571_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489526_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489565_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489567_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489565_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489590_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489600_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489590_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489600_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489604_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489645_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489604_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489639_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489641_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489639_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489645_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489664_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489750_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489664_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489682_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489672_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489673_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489672_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489751_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489676_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489682_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489676_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489720_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489684_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489722_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489684_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489718_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489720_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489718_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489722_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489740_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489750_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489740_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489800_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489750_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489751_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489754_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489804_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489754_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489798_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489800_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489798_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489820_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489832_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489820_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489872_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489832_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489833_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489906_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489836_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489876_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489836_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489870_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489872_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489870_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489876_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489894_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489906_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489894_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489954_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489906_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489910_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489958_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489910_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489952_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489954_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489952_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489994_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490004_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1489994_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490004_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490005_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490008_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490053_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490008_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490047_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490049_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490047_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490053_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1490085_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490093_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490085_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490119_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490095_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490119_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490095_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490129_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490121_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490129_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490121_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490139_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490131_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490139_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490131_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490149_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490141_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490149_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490141_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490163_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490171_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490181_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490171_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490172_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490175_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490181_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490175_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490236_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490183_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490238_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490234_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490236_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
InPort_1490291_3 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1490283_0 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1490283_1 | SINK | vanduo karštas tiekiamasis - T3 14
OutPort_1490316_1 | SOURCE | vanduo karštas tiekiamasis - T3 14
Port_1490291_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490292_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490292_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490559_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
InPort_1490316_2 | SINK | vanduo karštas tiekiamasis - T3 14
OutPort_1490298_0 | SOURCE | vanduo karštas tiekiamasis - T3 14
InPort_1490298_1 | SINK | vanduo karštas tiekiamasis - T3 14
OutPort_1490511_1 | SOURCE | vanduo karštas tiekiamasis - T3 14
InPort_1490511_2 | SINK | vanduo karštas tiekiamasis - T3 14
OutPort_1490501_0 | SOURCE | vanduo karštas tiekiamasis - T3 14
InPort_1490501_1 | SINK | vanduo karštas tiekiamasis - T3 14
OutPort_1490523_1 | SOURCE | vanduo karštas tiekiamasis - T3 14
InPort_1490523_2 | SINK | vanduo karštas tiekiamasis - T3 14
OutPort_1490515_0 | SOURCE | vanduo karštas tiekiamasis - T3 14
InPort_1490515_1 | SINK | vanduo karštas tiekiamasis - T3 14
Port_1490525_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490525_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490781_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490551_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490559_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490551_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490589_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490559_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490560_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490565_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490589_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490565_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490621_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490593_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490621_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490593_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490631_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490623_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490631_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490623_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490643_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490635_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490643_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490635_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490654_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490645_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490654_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490645_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490707_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490691_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490707_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490691_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490769_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491135_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490800_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490781_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491706_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490783_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490783_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490812_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490800_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490802_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490802_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490901_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490812_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490858_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490814_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490860_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490856_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490858_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490860_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490890_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490900_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490890_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490954_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490900_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490901_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490904_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490958_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490904_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491060_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490952_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490954_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490952_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1490978_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490986_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490978_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491029_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490986_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490990_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491033_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490990_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491027_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491029_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491027_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491033_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491049_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491062_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491107_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491058_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491060_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491058_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491062_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491066_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491111_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491066_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491105_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491107_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491105_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491127_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491135_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491127_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491147_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491135_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491136_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491136_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491220_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491139_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491147_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491139_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491149_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491196_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491149_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491192_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491194_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491192_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491212_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491220_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491212_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491220_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491221_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491221_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491385_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491224_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491269_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491224_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491263_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491265_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491263_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491269_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491294_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491302_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491294_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491302_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491386_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491302_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491303_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491458_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491306_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491361_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491306_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491355_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491357_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491355_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491361_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491377_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491385_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491377_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491430_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491385_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491386_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491389_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491432_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491389_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491428_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491430_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491432_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491450_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491537_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491450_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491473_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491458_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491459_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491458_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491538_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491459_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491638_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491462_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491475_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491462_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491473_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491475_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491479_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491513_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491479_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491509_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491511_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491509_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491513_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
InPort_1491529_0 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491537_3 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491549_1 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491529_1 | SOURCE | vanduo karštas tiekiamasis - T3 13
Port_1491537_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
InPort_1491541_0 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491549_2 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491602_1 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491541_1 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491617_2 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491551_0 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491551_1 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491621_2 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491598_0 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491600_2 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491621_1 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491598_1 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491600_1 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491602_2 | SOURCE | vanduo karštas tiekiamasis - T3 13
InPort_1491613_3 | SINK | vanduo šaltas - V1 2
OutPort_1491611_0 | SOURCE | vanduo šaltas - V1 2
InPort_1491611_1 | SINK | vanduo karštas tiekiamasis - T3 13
OutPort_1491617_1 | SOURCE | vanduo karštas tiekiamasis - T3 13
Port_1491613_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491614_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491630_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491638_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491630_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491677_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491638_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491639_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491639_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491705_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491642_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491681_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491642_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491675_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491677_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491681_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491697_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491705_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491715_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491705_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491706_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491709_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491715_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491744_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491717_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491786_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491717_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491742_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491744_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491742_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491786_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 13
Port_1491824_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491835_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491835_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491850_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491856_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491901_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491892_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491900_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491892_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491912_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491900_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491901_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491904_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491912_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491904_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491998_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 15
Port_1491998_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 15
InPort_1492088_3 | SINK | vanduo karštas tiekiamasis - T3 1
OutPort_1492086_0 | SOURCE | vanduo karštas tiekiamasis - T3 1
InPort_1492086_1 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1492100_1 | SOURCE | vanduo karštas apytakinis - T4 1
Port_1492088_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492089_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492177_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492119_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1492120_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1492119_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1493415_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1492167_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492177_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492167_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492177_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492178_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492201_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492322_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492201_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492238_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492656_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492244_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492254_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492244_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492292_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492252_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492254_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492258_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492296_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492258_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492290_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492292_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492290_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492296_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492322_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492322_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492323_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492323_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492426_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492326_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492332_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492396_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492334_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492400_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492334_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492394_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492396_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492394_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492400_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492418_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492426_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492418_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492436_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492426_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492427_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492427_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492521_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492430_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492436_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492430_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492477_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492438_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492481_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492438_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492475_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492477_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492475_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492481_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492513_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492521_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492513_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492539_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492521_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492522_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492743_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492525_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492541_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492525_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492539_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492541_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492545_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492631_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492545_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492625_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492627_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492631_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492647_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492655_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492647_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492655_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492744_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492655_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492656_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492659_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492703_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492695_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492699_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492695_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492703_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492697_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492735_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492863_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492735_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492753_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492743_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492744_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492743_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1493068_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492747_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492747_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492755_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492765_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492755_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492835_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492763_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492769_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492839_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492833_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492835_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492839_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492855_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492855_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492913_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492863_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492864_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492863_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492944_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492864_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1493067_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492867_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492917_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492867_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492909_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492911_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492909_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492917_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492911_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492913_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492933_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492943_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492933_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492955_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492943_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492944_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492947_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492955_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492947_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492965_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492957_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492965_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492957_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1493010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492967_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
