Properties of the parts of a building model (IFC2X3), part 50 of 57

# IfcFlowSegment: Pipe Types:Wavin AS+ (socket end) OD (3301)
Name (Pipe Types:Wavin AS+ (socket end) OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1266659 | 2 a | 203.784 | 4929.46 | Ūkio-buities nuotekos - F1 71
1266670 | 2 a | 660.999 | 4173.85 | Ūkio-buities nuotekos - F1 71
1266917 | 2 a | 246.915 | 3133.24 | Ūkio-buities nuotekos - F1 71
1266926 | 2 a | 70.1994 | 2898.94 | Ūkio-buities nuotekos - F1 71
1267000 | 2 a | 5080.67 | 3135.82 | Ūkio-buities nuotekos - F1 71
1267017 | 2 a | 285.105 | 3125.07 | Ūkio-buities nuotekos - F1 71
1267024 | 2 a | 151.764 | 3241.19 | Ūkio-buities nuotekos - F1 71
1267076 | 2 a | 277.298 | 3341.07 | Ūkio-buities nuotekos - F1 71
1267090 | 2 a | 1212.3 | 3712.98 | Ūkio-buities nuotekos - F1 71
1267154 | 2 a | 146.982 | 4929.46 | Ūkio-buities nuotekos - F1 71
1267165 | 2 a | 1000.78 | 3834.07 | Ūkio-buities nuotekos - F1 71
1267207 | 2 a | 56.7531 | 3141.95 | Ūkio-buities nuotekos - F1 71
1267270 | 2 a | 3474.25 | -797.49 | Ūkio-buities nuotekos - F1 71
1267436 | 2 a | 806.419 | 2970.24 | Ūkio-buities nuotekos - F1 71
1267444 | 2 a | 850.142 | 3024.33 | Ūkio-buities nuotekos - F1 71
1267501 | 2 a | 1217.45 | 3209.37 | Ūkio-buities nuotekos - F1 71
1267553 | 2 a | 981.372 | 3006.91 | Ūkio-buities nuotekos - F1 71
1267562 | 2 a | 194.863 | 2992.07 | Ūkio-buities nuotekos - F1 71
1267569 | 2 a | 128.693 | 4752.62 | Ūkio-buities nuotekos - F1 71
1267638 | 2 a | 1436.94 | 3194.87 | Ūkio-buities nuotekos - F1 71
1267802 | 2 a | 167.705 | 3034.08 | Ūkio-buities nuotekos - F1 71
1267822 | 2 a | 1079.65 | 3207.35 | Ūkio-buities nuotekos - F1 71
1267833 | 2 a | 548.395 | 3000.41 | Ūkio-buities nuotekos - F1 71
1267879 | 2 a | 1089.73 | 3055.38 | Ūkio-buities nuotekos - F1 71
1267888 | 2 a | 333.02 | 3014.86 | Ūkio-buities nuotekos - F1 71
1267992 | 2 a | 211.936 | 3081.02 | Ūkio-buities nuotekos - F1 71
1268039 | 2 a | 172.246 | 4929.46 | Ūkio-buities nuotekos - F1 71
1268082 | 2 a | 1652.74 | 3182.11 | Ūkio-buities nuotekos - F1 71
1268113 | 2 a | 5430.31 | 2962.95 | Ūkio-buities nuotekos - F1 71
1268132 | 2 a | 2984.94 | 2869.3 | Ūkio-buities nuotekos - F1 71
1268141 | 2 a | 147.533 | 4929.46 | Ūkio-buities nuotekos - F1 71
1268182 | 2 a | 1666.47 | 3168.38 | Ūkio-buities nuotekos - F1 71
1268254 | 2 a | 1867.95 | 3065.02 | Ūkio-buities nuotekos - F1 71
1268269 | 2 a | 1781.68 | 2931.8 | Ūkio-buities nuotekos - F1 71
1268278 | 2 a | 347.026 | 4929.46 | Ūkio-buities nuotekos - F1 71
1268324 | 2 a | 1635.63 | 3199.22 | Ūkio-buities nuotekos - F1 71
1268364 | 2 a | 1940.58 | 3067.6 | Ūkio-buities nuotekos - F1 71
1268373 | 2 a | 3058.98 | 3001.39 | Ūkio-buities nuotekos - F1 71
1268380 | 2 a | 237.11 | 4929.46 | Ūkio-buities nuotekos - F1 71
1268451 | 2 a | 1631.59 | 3203.25 | Ūkio-buities nuotekos - F1 71
1268497 | 2 a | 5896.17 | 3784.29 | Ūkio-buities nuotekos - F1 72
1268592 | 2 a | 4435.7 | 3183.97 | Ūkio-buities nuotekos - F1 72
1268931 | 2 a | 249.665 | 3023.77 | Ūkio-buities nuotekos - F1 72
1268939 | 2 a | 95.2385 | 3004.76 | Ūkio-buities nuotekos - F1 72
1269000 | 2 a | 7785.71 | -4849.92 | Ūkio-buities nuotekos - F1 72
1269109 | 2 a | 61.4969 | 3784.21 | Ūkio-buities nuotekos - F1 72
1269118 | 2 a | 69.2406 | 3492.84 | Ūkio-buities nuotekos - F1 72
1269159 | 2 a | 497.916 | 3953.78 | Ūkio-buities nuotekos - F1 72
1269197 | 2 a | 164.769 | 4752.62 | Ūkio-buities nuotekos - F1 72
1269212 | 2 a | 619.169 | 4012.64 | Ūkio-buities nuotekos - F1 72
1269215 | 2 a | 447.752 | 3760.32 | Ūkio-buities nuotekos - F1 72
1269263 | 2 a | 384.184 | 3773.72 | Ūkio-buities nuotekos - F1 72
1269298 | 2 a | 889.029 | 3950.42 | Ūkio-buities nuotekos - F1 72
1269301 | 2 a | 362.132 | 3815.36 | Ūkio-buities nuotekos - F1 72
1269491 | 2 a | 1004 | 3825.06 | Ūkio-buities nuotekos - F1 72
1269499 | 2 a | 167.497 | 4929.46 | Ūkio-buities nuotekos - F1 72
1269535 | 2 a | 892.86 | 3941.99 | Ūkio-buities nuotekos - F1 72
1269593 | 2 a | 474.153 | 3805.46 | Ūkio-buities nuotekos - F1 72
1269608 | 2 a | 110.671 | 3754.63 | Ūkio-buities nuotekos - F1 72
1269697 | 2 a | 532.579 | 3936.54 | Ūkio-buities nuotekos - F1 72
1269751 | 2 a | 552.42 | 3958.91 | Ūkio-buities nuotekos - F1 72
1269790 | 2 a | 255.046 | 3779.55 | Ūkio-buities nuotekos - F1 72
1270002 | 2 a | 238.333 | 3820.29 | Ūkio-buities nuotekos - F1 72
1270063 | 2 a | 745.674 | 3787.95 | Ūkio-buities nuotekos - F1 72
1270072 | 2 a | 1959.07 | 3829.03 | Ūkio-buities nuotekos - F1 72
1270086 | 2 a | 101.822 | 3871.98 | Ūkio-buities nuotekos - F1 72
1270100 | 2 a | 17.5029 | 4929.46 | Ūkio-buities nuotekos - F1 72
1270135 | 2 a | 863.984 | 3970.86 | Ūkio-buities nuotekos - F1 72
1270221 | 2 a | 389.885 | 3191.77 | Ūkio-buities nuotekos - F1 72
1270238 | 2 a | 396.309 | 3170.14 | Ūkio-buities nuotekos - F1 72
1270320 | 2 a | 1194.62 | 3321.16 | Ūkio-buities nuotekos - F1 72
1270436 | 2 a | 901.316 | 3158.12 | Ūkio-buities nuotekos - F1 72
1270449 | 2 a | 254.904 | 3151.52 | Ūkio-buities nuotekos - F1 72
1270454 | 2 a | 208.542 | 4752.62 | Ūkio-buities nuotekos - F1 72
1270494 | 2 a | 1287.33 | 3344.48 | Ūkio-buities nuotekos - F1 72
1270547 | 2 a | 428.833 | 3155.89 | Ūkio-buities nuotekos - F1 72
1270560 | 2 a | 529.706 | 3127.15 | Ūkio-buities nuotekos - F1 72
1270569 | 2 a | 491.804 | 3168.24 | Ūkio-buities nuotekos - F1 72
1270583 | 2 a | 108.49 | 4929.46 | Ūkio-buities nuotekos - F1 72
1270639 | 2 a | 1559.92 | 3274.93 | Ūkio-buities nuotekos - F1 72
1270671 | 2 a | 299.244 | 3169.3 | Ūkio-buities nuotekos - F1 72
1270688 | 2 a | 326.345 | 3140.55 | Ūkio-buities nuotekos - F1 72
1270740 | 2 a | 1562.72 | 3272.13 | Ūkio-buities nuotekos - F1 72
1270971 | 2 a | 778.755 | 3190.58 | Ūkio-buities nuotekos - F1 72
1270986 | 2 a | 361.532 | 3159.43 | Ūkio-buities nuotekos - F1 72
1270995 | 2 a | 351.732 | 3209.92 | Ūkio-buities nuotekos - F1 72
1271009 | 2 a | 37.5229 | 4929.46 | Ūkio-buities nuotekos - F1 72
1271039 | 2 a | 1521.04 | 3313.81 | Ūkio-buities nuotekos - F1 72
1271156 | 2 a | 532.784 | 3114.96 | Ūkio-buities nuotekos - F1 72
1271167 | 2 a | 173.87 | 3033.2 | Ūkio-buities nuotekos - F1 72
1271627 | 2 a | 373.147 | 3171.36 | Ūkio-buities nuotekos - F1 72
1271825 | 2 a | 1099.65 | 3347.16 | Ūkio-buities nuotekos - F1 72
1271897 | 2 a | 289.937 | 3190.59 | Ūkio-buities nuotekos - F1 72
1271916 | 2 a | 49.0276 | 3131.31 | Ūkio-buities nuotekos - F1 72
1271971 | 2 a | 1132.98 | 3317.98 | Ūkio-buities nuotekos - F1 72
1272119 | 2 a | 264.789 | 4752.62 | Ūkio-buities nuotekos - F1 72
1272130 | 2 a | 1232.91 | 3398.91 | Ūkio-buities nuotekos - F1 72
1272133 | 2 a | 485.039 | 3158.18 | Ūkio-buities nuotekos - F1 72
1272220 | 2 a | 390.981 | 3199.96 | Ūkio-buities nuotekos - F1 72
1272233 | 2 a | 343.611 | 3146.87 | Ūkio-buities nuotekos - F1 72
1272273 | 2 a | 1530.33 | 3304.82 | Ūkio-buities nuotekos - F1 72
1272435 | 2 a | 296.249 | 4751.99 | Ūkio-buities nuotekos - F1 72
1272446 | 2 a | 1255.61 | 3374.03 | Ūkio-buities nuotekos - F1 72
1272449 | 2 a | 366.208 | 3136.73 | Ūkio-buities nuotekos - F1 72
1272547 | 2 a | 9.14021 | 3131.78 | Ūkio-buities nuotekos - F1 72
1272558 | 2 a | 3259.04 | 3046.31 | Ūkio-buities nuotekos - F1 72
1272567 | 2 a | 598.053 | 3145.22 | Ūkio-buities nuotekos - F1 72
1272869 | 2 a | 1211.88 | 3278.77 | Ūkio-buities nuotekos - F1 72
1272935 | 2 a | 182.284 | 3200.14 | Ūkio-buities nuotekos - F1 72
1272944 | 2 a | 975.248 | 3178.01 | Ūkio-buities nuotekos - F1 72
1272975 | 2 a | 2111.69 | 3207.56 | Ūkio-buities nuotekos - F1 72
1272989 | 2 a | 129.096 | 3253.56 | Ūkio-buities nuotekos - F1 72
1273040 | 2 a | 1481.85 | 3352.99 | Ūkio-buities nuotekos - F1 72
1273184 | 2 a | 65.6712 | 3158.05 | Ūkio-buities nuotekos - F1 72
1273197 | 2 a | 312.038 | 3136.37 | Ūkio-buities nuotekos - F1 72
1273206 | 2 a | 413.943 | 3163.14 | Ūkio-buities nuotekos - F1 72
1273220 | 2 a | 109.232 | 3175.19 | Ūkio-buities nuotekos - F1 72
1273275 | 2 a | 1560.63 | 3274.22 | Ūkio-buities nuotekos - F1 72
1273333 | 2 a | 901.328 | 3074.32 | Ūkio-buities nuotekos - F1 72
1273350 | 2 a | 596.542 | 3070.12 | Ūkio-buities nuotekos - F1 72
1273355 | 2 a | 155.498 | 4752.62 | Ūkio-buities nuotekos - F1 72
1273409 | 2 a | 1371.13 | 3260.69 | Ūkio-buities nuotekos - F1 72
1273438 | 2 a | 420.95 | 3138.11 | Ūkio-buities nuotekos - F1 72
1273449 | 2 a | 1973.86 | 3084.87 | Ūkio-buities nuotekos - F1 72
1273464 | 2 a | 436.97 | 3171.6 | Ūkio-buities nuotekos - F1 72
1273511 | 2 a | 124.195 | 4929.46 | Ūkio-buities nuotekos - F1 72
1273564 | 2 a | 1557.67 | 3277.18 | Ūkio-buities nuotekos - F1 72
1273717 | 2 a | 60.2015 | 3142.42 | Ūkio-buities nuotekos - F1 72
1273728 | 2 a | 246.09 | 3116.04 | Ūkio-buities nuotekos - F1 72
1273759 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 72
1273857 | 2 a | 1594.38 | 3240.47 | Ūkio-buities nuotekos - F1 72
1273888 | 2 a | 389.997 | 3071.4 | Ūkio-buities nuotekos - F1 72
1273903 | 2 a | 715.329 | 3051.38 | Ūkio-buities nuotekos - F1 72
1274017 | 2 a | 1314.98 | 3200.8 | Ūkio-buities nuotekos - F1 72
1274085 | 2 a | 149.949 | 3065.53 | Ūkio-buities nuotekos - F1 72
1274100 | 2 a | 231.072 | 3038.2 | Ūkio-buities nuotekos - F1 72
1274256 | 2 a | 1325.65 | 3190.13 | Ūkio-buities nuotekos - F1 72
1274332 | 2 a | 41.1842 | 3016.1 | Ūkio-buities nuotekos - F1 72
1274343 | 2 a | 358.33 | 3011.1 | Ūkio-buities nuotekos - F1 72
1274371 | 2 a | 486.127 | 3185.27 | Ūkio-buities nuotekos - F1 72
1274385 | 2 a | 15.3692 | 3792.19 | Ūkio-buities nuotekos - F1 72
1274595 | 2 a | 350.419 | 3801.15 | Ūkio-buities nuotekos - F1 72
1274915 | 2 a | 145.116 | 4752.62 | Ūkio-buities nuotekos - F1 72
1274928 | 2 a | 655.321 | 3976.49 | Ūkio-buities nuotekos - F1 72
1275045 | 2 a | 338.633 | 3041.12 | Ūkio-buities nuotekos - F1 72
1275050 | 2 a | 404.762 | 3052.02 | Ūkio-buities nuotekos - F1 72
1275131 | 2 a | 869.174 | 3083.16 | Ūkio-buities nuotekos - F1 72
1275140 | 2 a | 178.985 | 3045.62 | Ūkio-buities nuotekos - F1 72
1275209 | 2 a | 448.698 | 3197.39 | Ūkio-buities nuotekos - F1 72
1275223 | 2 a | 451.164 | 3753.12 | Ūkio-buities nuotekos - F1 72
1275315 | 2 a | 975.863 | 3858.99 | Ūkio-buities nuotekos - F1 72
1275329 | 2 a | 147.469 | 4929.46 | Ūkio-buities nuotekos - F1 72
1275386 | 2 a | 280.246 | 3753.3 | Ūkio-buities nuotekos - F1 72
1275403 | 2 a | 214.344 | 3746.36 | Ūkio-buities nuotekos - F1 72
1275410 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 72
1275482 | 2 a | 979.098 | 3855.75 | Ūkio-buities nuotekos - F1 72
1275608 | 2 a | 302.356 | 3748.94 | Ūkio-buities nuotekos - F1 72
1275621 | 2 a | 160.203 | 3740.69 | Ūkio-buities nuotekos - F1 72
1275628 | 2 a | 292.731 | 3759.06 | Ūkio-buities nuotekos - F1 72
1275675 | 2 a | 593.979 | 3768.69 | Ūkio-buities nuotekos - F1 72
1275689 | 2 a | 69.2242 | 3784.34 | Ūkio-buities nuotekos - F1 72
1275703 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 72
1275732 | 2 a | 952.271 | 3882.58 | Ūkio-buities nuotekos - F1 72
1275966 | 2 a | 15.0788 | 3704.75 | Ūkio-buities nuotekos - F1 75
1276068 | 2 a | 307.978 | 3692.89 | Ūkio-buities nuotekos - F1 75
1276138 | 2 a | 62.725 | 3561.2 | Ūkio-buities nuotekos - F1 75
1276727 | 2 a | 21.9133 | 3347.71 | Ūkio-buities nuotekos - F1 75
1276755 | 2 a | 79.8044 | -5339.01 | Ūkio-buities nuotekos - F1 75
1277095 | 2 a | 441.702 | 4177.38 | Ūkio-buities nuotekos - F1 75
1277104 | 2 a | 55.7601 | 4113.02 | Ūkio-buities nuotekos - F1 75
1277172 | 2 a | 197.981 | 4361.22 | Ūkio-buities nuotekos - F1 75
1277181 | 2 a | 5498.01 | 4342.9 | Ūkio-buities nuotekos - F1 75
1277401 | 2 a | 1027.63 | 4341.46 | Ūkio-buities nuotekos - F1 75
1277412 | 2 a | 258.4 | 4329.8 | Ūkio-buities nuotekos - F1 75
1277461 | 2 a | 32.164 | 4483.6 | Ūkio-buities nuotekos - F1 75
1277621 | 2 a | 449.157 | 4349.63 | Ūkio-buities nuotekos - F1 75
1277693 | 2 a | 365.03 | 4471.82 | Ūkio-buities nuotekos - F1 75
1277869 | 2 a | 108.271 | 4364.46 | Ūkio-buities nuotekos - F1 75
1277882 | 2 a | 438.04 | 4338.27 | Ūkio-buities nuotekos - F1 75
1277891 | 2 a | 449.059 | 4378.4 | Ūkio-buities nuotekos - F1 75
1277905 | 2 a | 124.862 | 4929.46 | Ūkio-buities nuotekos - F1 75
1277938 | 2 a | 350.618 | 4484.23 | Ūkio-buities nuotekos - F1 75
1277991 | 2 a | 100.448 | 4354.54 | Ūkio-buities nuotekos - F1 75
1278044 | 2 a | 287.455 | 4177.82 | Ūkio-buities nuotekos - F1 75
1278055 | 2 a | 104.522 | 4143.21 | Ūkio-buities nuotekos - F1 75
1278122 | 2 a | 129.609 | 4352.08 | Ūkio-buities nuotekos - F1 75
1278165 | 2 a | 338.742 | 4199.44 | Ūkio-buities nuotekos - F1 75
1278182 | 2 a | 21.5483 | 4173.91 | Ūkio-buities nuotekos - F1 75
1278191 | 2 a | 236.038 | 4210.62 | Ūkio-buities nuotekos - F1 75
1278275 | 2 a | 28.8388 | 4336.52 | Ūkio-buities nuotekos - F1 75
1278388 | 2 a | 348.968 | 4210.82 | Ūkio-buities nuotekos - F1 75
1278399 | 2 a | 645.383 | 4161.66 | Ūkio-buities nuotekos - F1 75
1278408 | 2 a | 1742.99 | 4226.16 | Ūkio-buities nuotekos - F1 75
1278468 | 2 a | 476.989 | 4357.86 | Ūkio-buities nuotekos - F1 75
1278525 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 75
1278536 | 2 a | 479.141 | 4355.71 | Ūkio-buities nuotekos - F1 75
1278539 | 2 a | 105.902 | 4221.57 | Ūkio-buities nuotekos - F1 75
1278743 | 2 a | 189.367 | 4180.5 | Ūkio-buities nuotekos - F1 75
1278758 | 2 a | 656.304 | 4156.34 | Ūkio-buities nuotekos - F1 75
1278830 | 2 a | 353.887 | 4395.11 | Ūkio-buities nuotekos - F1 75
1278839 | 2 a | 11.7569 | 4149.74 | Ūkio-buities nuotekos - F1 75
1279166 | 2 a | 310.069 | 4180.88 | Ūkio-buities nuotekos - F1 75
1279175 | 2 a | 188.159 | 4154.42 | Ūkio-buities nuotekos - F1 75
1279289 | 2 a | 185.469 | 4308.63 | Ūkio-buities nuotekos - F1 75
1279356 | 2 a | 2249.14 | 4174.35 | Ūkio-buities nuotekos - F1 75
1279369 | 2 a | 2550.29 | 4089.4 | Ūkio-buities nuotekos - F1 75
1279378 | 2 a | 552.12 | 4223.1 | Ūkio-buities nuotekos - F1 75
1279392 | 2 a | 147.493 | 4929.46 | Ūkio-buities nuotekos - F1 75
1279444 | 2 a | 503.861 | 4330.99 | Ūkio-buities nuotekos - F1 75
1279645 | 2 a | 5049.17 | 3856.62 | Ūkio-buities nuotekos - F1 71
1279658 | 2 a | 297.073 | 3816.72 | Ūkio-buities nuotekos - F1 71
1279667 | 2 a | 2412.28 | 3961.36 | Ūkio-buities nuotekos - F1 71
1279681 | 2 a | 387.541 | 4929.46 | Ūkio-buities nuotekos - F1 71
1279745 | 2 a | 728.399 | 4106.45 | Ūkio-buities nuotekos - F1 71
1281143 | 2 a | 7272.04 | -3873.24 | Lietaus nuotekos - L1 20
1281150 | 2 a | 263.236 | 7788.09 | Lietaus nuotekos - L1 20
1281242 | 3 a | 11.0963 | 7780.59 | Lietaus nuotekos - L1 20
1281362 | 3 a | 3921.96 | 3780.76 | Lietaus nuotekos - L1 20
1282134 | 2 a | 263.12 | 3541.35 | Lietaus nuotekos - L1 20
1282229 | 2 a | 11.0963 | 3553.89 | Lietaus nuotekos - L1 20
1282321 | 2 a | 424.67 | -5537.32 | nuotekos ūkio-buities - F1 1
1282442 | 2 a | 216.627 | 8925.59 | nuotekos ūkio-buities - F1 1
1282453 | 2 a | 604.382 | 9150.11 | nuotekos ūkio-buities - F1 1
1282458 | 2 a | 806.527 | 8050.11 | nuotekos ūkio-buities - F1 1
1282470 | 2 a | 194.104 | 7826.04 | nuotekos ūkio-buities - F1 1
1282543 | 2 a | 96.9222 | 4108.58 | nuotekos ūkio-buities - F1 1
1282552 | 2 a | 3302.81 | 4330.7 | nuotekos ūkio-buities - F1 1
1282569 | 2 a | 74.0802 | 3484.03 | nuotekos ūkio-buities - F1 1
1282958 | 2 a | 420.04 | 3854.71 | nuotekos ūkio-buities - F1 1
1282967 | 2 a | 173.653 | 3865.96 | nuotekos ūkio-buities - F1 1
1283219 | 2 a | 422.695 | 4031.45 | nuotekos ūkio-buities - F1 1
1283267 | 2 a | 100.932 | 3881.31 | nuotekos ūkio-buities - F1 1
1283278 | 2 a | 367.454 | 3842.92 | nuotekos ūkio-buities - F1 1
1283291 | 2 a | 1227.04 | 3884.38 | nuotekos ūkio-buities - F1 1
1283313 | 2 a | 264.789 | 4752.62 | nuotekos ūkio-buities - F1 1
1283348 | 2 a | 554.554 | 4077.26 | nuotekos ūkio-buities - F1 1
1283377 | 2 a | 113.802 | 3847.12 | nuotekos ūkio-buities - F1 1
1283390 | 2 a | 108.783 | 3836.3 | nuotekos ūkio-buities - F1 1
1283431 | 2 a | 859.153 | 3939.19 | nuotekos ūkio-buities - F1 1
1283502 | 2 a | 342.665 | 4124.71 | nuotekos ūkio-buities - F1 1
1283560 | 2 a | 8.75401 | 3990.05 | nuotekos ūkio-buities - F1 1
1283571 | 2 a | 3983.37 | 3855.1 | nuotekos ūkio-buities - F1 1
1283616 | 2 a | 258.249 | 4158.56 | nuotekos ūkio-buities - F1 1
1283664 | 2 a | 1522.4 | 4380.98 | Ūkio-buities nuotekos - F1 75
1283673 | 2 a | 277.021 | 4370.4 | Ūkio-buities nuotekos - F1 75
1283686 | 2 a | 1527.57 | 4416.75 | Ūkio-buities nuotekos - F1 75
1283733 | 2 a | 207.505 | 4929.46 | Ūkio-buities nuotekos - F1 75
1283767 | 2 a | 290.705 | 4544.14 | Ūkio-buities nuotekos - F1 75
1283797 | 2 a | 178.504 | 4929.46 | Ūkio-buities nuotekos - F1 75
1283806 | 2 a | 290.947 | 4543.9 | Ūkio-buities nuotekos - F1 75
1283809 | 2 a | 378.74 | 4406.71 | Ūkio-buities nuotekos - F1 75
1283844 | 2 a | 73.226 | 4092.59 | Ūkio-buities nuotekos - F1 75
1283853 | 2 a | 77.1869 | 4083.41 | Ūkio-buities nuotekos - F1 75
1283866 | 2 a | 173.186 | 4094.39 | Ūkio-buities nuotekos - F1 75
1283888 | 2 a | 83.3982 | 4752.62 | Ūkio-buities nuotekos - F1 75
1284077 | 2 a | 365.62 | 4266.19 | Ūkio-buities nuotekos - F1 75
1284132 | 2 a | 528.797 | 3912.46 | nuotekos ūkio-buities - F1 1
1284141 | 2 a | 530.895 | 3867.89 | nuotekos ūkio-buities - F1 1
1284150 | 2 a | 330.665 | 3931.62 | nuotekos ūkio-buities - F1 1
1284164 | 2 a | 312.05 | 3942.01 | nuotekos ūkio-buities - F1 1
1284211 | 2 a | 187.501 | 4929.46 | nuotekos ūkio-buities - F1 1
1284237 | 2 a | 789.767 | 4045.08 | nuotekos ūkio-buities - F1 1
1284365 | 2 a | 127.489 | 4929.46 | nuotekos ūkio-buities - F1 1
1284374 | 2 a | 774.073 | 4060.78 | nuotekos ūkio-buities - F1 1
1284377 | 2 a | 117.538 | 3926.81 | nuotekos ūkio-buities - F1 1
1284553 | 2 a | 590.025 | 3889.1 | nuotekos ūkio-buities - F1 1
1284570 | 2 a | 154.92 | 3861.31 | nuotekos ūkio-buities - F1 1
1284673 | 2 a | 493.275 | 4022.5 | nuotekos ūkio-buities - F1 1
1284803 | 2 a | 286.49 | 4023.59 | nuotekos ūkio-buities - F1 1
1284816 | 2 a | 183.626 | 3983.56 | nuotekos ūkio-buities - F1 1
1284825 | 2 a | 89.3942 | 4033.1 | nuotekos ūkio-buities - F1 1
1284881 | 2 a | 703.116 | 4131.73 | nuotekos ūkio-buities - F1 1
1285239 | 2 a | 287.761 | 4002.79 | nuotekos ūkio-buities - F1 1
1285256 | 2 a | 528.327 | 3969.52 | nuotekos ūkio-buities - F1 1
1285290 | 2 a | 385.635 | 4130.14 | nuotekos ūkio-buities - F1 1
1285398 | 2 a | 259.563 | 4752.32 | nuotekos ūkio-buities - F1 1
1285407 | 2 a | 420.593 | 4209.21 | nuotekos ūkio-buities - F1 1
1285410 | 2 a | 334.733 | 3958.38 | nuotekos ūkio-buities - F1 1
1285438 | 2 a | 223.891 | 4752.31 | nuotekos ūkio-buities - F1 1
1285447 | 2 a | 442.042 | 4187.76 | nuotekos ūkio-buities - F1 1
1285450 | 2 a | 11.445 | 3943.39 | nuotekos ūkio-buities - F1 1
1285574 | 2 a | 375.211 | 3948.07 | nuotekos ūkio-buities - F1 1
1285635 | 2 a | 1747.01 | 4020.79 | nuotekos ūkio-buities - F1 1
1285641 | 2 a | 147.493 | 4929.46 | nuotekos ūkio-buities - F1 1
1285677 | 2 a | 682.265 | 4152.58 | nuotekos ūkio-buities - F1 1
1285819 | 2 a | 147.493 | 4929.46 | nuotekos ūkio-buities - F1 1
1285828 | 2 a | 686.908 | 4147.94 | nuotekos ūkio-buities - F1 1
1285831 | 2 a | 1439.57 | 3989.53 | nuotekos ūkio-buities - F1 1
1286019 | 2 a | 216.627 | 9032.82 | nuotekos ūkio-buities - F1 4
1286028 | 2 a | 470.055 | 9257.34 | nuotekos ūkio-buities - F1 4
1286033 | 2 a | 586.527 | 8377.34 | nuotekos ūkio-buities - F1 4
1286045 | 2 a | 194.104 | 8153.28 | nuotekos ūkio-buities - F1 4
1286108 | 2 a | 276.639 | 4405.99 | nuotekos ūkio-buities - F1 4
1286117 | 2 a | 3329.03 | 4631.7 | nuotekos ūkio-buities - F1 4
1286134 | 2 a | 140.559 | 3578.68 | nuotekos ūkio-buities - F1 4
1286368 | 1 a +-152.84 | 581.406 | 3561.35 | nuotekos ūkio-buities - F1 4
1286436 | 1 a +-152.84 | 610.337 | -5334.09 | nuotekos ūkio-buities - F1 4
1286533 | 2 a | 773.595 | 3840.85 | nuotekos ūkio-buities - F1 4
1286542 | 2 a | 473.452 | 3863.57 | nuotekos ūkio-buities - F1 4
1286726 | 2 a | 5.99691 | 3938.23 | nuotekos ūkio-buities - F1 4
1286746 | 2 a | 284.319 | 4752.62 | nuotekos ūkio-buities - F1 4
1286837 | 2 a | 525.121 | 4106.69 | nuotekos ūkio-buities - F1 4
1286970 | 2 a | 256.238 | 3964.05 | nuotekos ūkio-buities - F1 4
1286979 | 2 a | 3637.22 | 3862.02 | nuotekos ūkio-buities - F1 4
1286988 | 2 a | 483.455 | 3973.58 | nuotekos ūkio-buities - F1 4
1287004 | 2 a | 143.845 | 4153.15 | nuotekos ūkio-buities - F1 4
1287042 | 2 a | 79.3878 | 3959.85 | nuotekos ūkio-buities - F1 4
1287221 | 2 a | 1832.76 | 4015.19 | nuotekos ūkio-buities - F1 4
1287229 | 2 a | 689.647 | 4055.61 | nuotekos ūkio-buities - F1 4
1287243 | 2 a | 192.5 | 4929.46 | nuotekos ūkio-buities - F1 4
1287272 | 2 a | 668.598 | 4166.25 | nuotekos ūkio-buities - F1 4
1287377 | 2 a | 680.624 | 4017.77 | nuotekos ūkio-buities - F1 4
1287388 | 2 a | 1593.04 | 3980.87 | nuotekos ūkio-buities - F1 4
1287395 | 2 a | 172.496 | 4929.46 | nuotekos ūkio-buities - F1 4
1287429 | 2 a | 706.62 | 4128.23 | nuotekos ūkio-buities - F1 4
1287466 | 2 a | 261.897 | 3892.58 | nuotekos ūkio-buities - F1 4
1287489 | 2 a | 206.178 | 3833.92 | nuotekos ūkio-buities - F1 4
1287498 | 2 a | 88.7544 | 3901.6 | nuotekos ūkio-buities - F1 4
1287724 | 2 a | 6.55173 | 3907.14 | nuotekos ūkio-buities - F1 4
1287732 | 2 a | 212.416 | 4929.46 | nuotekos ūkio-buities - F1 4
1287805 | 2 a | 830.724 | 4004.12 | nuotekos ūkio-buities - F1 4
1287972 | 2 a | 519.199 | 3895.16 | nuotekos ūkio-buities - F1 4
1287981 | 2 a | 520.387 | 3879.71 | nuotekos ūkio-buities - F1 4
1287994 | 2 a | 147.493 | 4929.46 | nuotekos ūkio-buities - F1 4
1288038 | 2 a | 834.956 | 3999.89 | nuotekos ūkio-buities - F1 4
1288198 | 2 a | 562.242 | 3882.29 | nuotekos ūkio-buities - F1 4
1288207 | 2 a | 262.625 | 3872 | nuotekos ūkio-buities - F1 4
1288220 | 2 a | 429.289 | 3889.11 | nuotekos ūkio-buities - F1 4
1288267 | 2 a | 127.489 | 4929.46 | nuotekos ūkio-buities - F1 4
1288302 | 2 a | 840.306 | 3994.54 | nuotekos ūkio-buities - F1 4
1288808 | 4 a V1 | 355.838 | 7572.65 | Ūkio-buities nuotekos - F1 16
1288864 | 3 a | 115.801 | 7564.63 | Ūkio-buities nuotekos - F1 16
1289817 | 3 a | 74.5616 | 4384.14 | Ūkio-buities nuotekos - F1 16
1289826 | 3 a | 2892.83 | 4602.85 | Ūkio-buities nuotekos - F1 16
1289831 | 3 a | 18.1456 | 3952.51 | Ūkio-buities nuotekos - F1 16
1289843 | 3 a | 44.5927 | 3531.77 | Ūkio-buities nuotekos - F1 16
1290191 | 2 a | 8.87166 | 3520.68 | Ūkio-buities nuotekos - F1 16
1290448 | 3 a | 240 | 4074.46 | Ūkio-buities nuotekos - F1 16
1291396 | 2 a | 1762.89 | 3529.37 | Ūkio-buities nuotekos - F1 16
1291411 | 2 a | 38.4666 | 3525.3 | Ūkio-buities nuotekos - F1 16
1291754 | 2 a | 395.298 | 3671.6 | Ūkio-buities nuotekos - F1 16
1291786 | 2 a | 170.068 | 3724.12 | Ūkio-buities nuotekos - F1 16
1291800 | 2 a | 199.195 | 4752.62 | Ūkio-buities nuotekos - F1 16
1291870 | 2 a | 735.948 | 3895.86 | Ūkio-buities nuotekos - F1 16
1291934 | 2 a | 88.7085 | 3755.27 | Ūkio-buities nuotekos - F1 16
1291943 | 2 a | 496.385 | 3711.39 | Ūkio-buities nuotekos - F1 16
1291952 | 2 a | 472.847 | 3805.6 | Ūkio-buities nuotekos - F1 16
1291966 | 2 a | 147.162 | 4929.46 | Ūkio-buities nuotekos - F1 16
1292035 | 2 a | 922.945 | 3911.9 | Ūkio-buities nuotekos - F1 16
1292064 | 2 a | 87.2295 | 4929.46 | Ūkio-buities nuotekos - F1 16
1292073 | 2 a | 900.2 | 3934.65 | Ūkio-buities nuotekos - F1 16
1292076 | 2 a | 2116.31 | 3760.82 | Ūkio-buities nuotekos - F1 16
1292224 | 2 a | 158.858 | 3732.5 | Ūkio-buities nuotekos - F1 16
1292233 | 2 a | 1135.27 | 3685.2 | Ūkio-buities nuotekos - F1 16
1292242 | 2 a | 2111.41 | 3740.09 | Ūkio-buities nuotekos - F1 16
1292302 | 2 a | 611.869 | 3903.9 | Ūkio-buities nuotekos - F1 16
1292372 | 2 a | 3149.92 | 3704.24 | Ūkio-buities nuotekos - F1 16
1292385 | 2 a | 1881.26 | 3631.17 | Ūkio-buities nuotekos - F1 16
1292394 | 2 a | 207.505 | 4929.46 | Ūkio-buities nuotekos - F1 16
1292453 | 2 a | 970.775 | 3864.07 | Ūkio-buities nuotekos - F1 16
1292482 | 2 a | 138.034 | 3649.69 | Ūkio-buities nuotekos - F1 16
1292495 | 2 a | 704.883 | 3589.29 | Ūkio-buities nuotekos - F1 16
1292502 | 2 a | 405.953 | 4752.62 | Ūkio-buities nuotekos - F1 16
1292531 | 2 a | 811.024 | 3820.79 | Ūkio-buities nuotekos - F1 16
1292689 | 2 a | 1009.88 | 3824.97 | Ūkio-buities nuotekos - F1 16
1292692 | 2 a | 983.68 | 3614.43 | Ūkio-buities nuotekos - F1 16
1292728 | 2 a | 404.3 | 3668.91 | Ūkio-buities nuotekos - F1 16
1292737 | 2 a | 464.947 | 3636.91 | Ūkio-buities nuotekos - F1 16
1292854 | 2 a | 725.926 | 3790.09 | Ūkio-buities nuotekos - F1 16
1293029 | 2 a | 1489.06 | 3620.04 | Ūkio-buities nuotekos - F1 16
1293042 | 2 a | 849.169 | 3569.5 | Ūkio-buities nuotekos - F1 16
1293051 | 2 a | 211.968 | 3653.59 | Ūkio-buities nuotekos - F1 16
1293065 | 2 a | 141.899 | 4929.46 | Ūkio-buities nuotekos - F1 16
1293139 | 2 a | 1080.18 | 3754.67 | Ūkio-buities nuotekos - F1 16
1293213 | 2 a | 889.973 | 3597.59 | Ūkio-buities nuotekos - F1 16
1293227 | 2 a | 42.8495 | 3621.08 | Ūkio-buities nuotekos - F1 16
1293241 | 2 a | 204.308 | 4752.62 | Ūkio-buities nuotekos - F1 16
1293268 | 2 a | 841.533 | 3790.28 | Ūkio-buities nuotekos - F1 16
1293299 | 2 a | 129.203 | 3628.73 | Ūkio-buities nuotekos - F1 16
1293308 | 2 a | 696.229 | 3580.85 | Ūkio-buities nuotekos - F1 16
1293317 | 2 a | 176.226 | 4929.46 | Ūkio-buities nuotekos - F1 16
1293351 | 2 a | 1106.69 | 3728.16 | Ūkio-buities nuotekos - F1 16
1293382 | 2 a | 1449.46 | 3600.08 | Ūkio-buities nuotekos - F1 16
1293395 | 2 a | 483.403 | 3567.7 | Ūkio-buities nuotekos - F1 16
1293404 | 2 a | 387.874 | 3647.32 | Ūkio-buities nuotekos - F1 16
1293481 | 2 a | 739.104 | 3776.67 | Ūkio-buities nuotekos - F1 16
1293547 | 2 a | 277.718 | 3637.77 | Ūkio-buities nuotekos - F1 16
1293562 | 2 a | 483.359 | 3617.06 | Ūkio-buities nuotekos - F1 16
1293836 | 2 a | 219.315 | 3683.66 | Ūkio-buities nuotekos - F1 16
1293866 | 2 a | 62.3723 | 3872.37 | Ūkio-buities nuotekos - F1 16
1294140 | 2 a | 589.859 | 4041.95 | Ūkio-buities nuotekos - F1 16
1294280 | 2 a | 389.374 | 3891.59 | Ūkio-buities nuotekos - F1 16
1294289 | 2 a | 471.753 | 3859.45 | Ūkio-buities nuotekos - F1 16
1294298 | 2 a | 580.495 | 3903.78 | Ūkio-buities nuotekos - F1 16
1294339 | 2 a | 478.786 | 4036.98 | Ūkio-buities nuotekos - F1 16
1294532 | 2 a | 291.341 | 3890.6 | Ūkio-buities nuotekos - F1 16
1294541 | 2 a | 559.175 | 3845.46 | Ūkio-buities nuotekos - F1 16
1294550 | 2 a | 1687.26 | 3918.24 | Ūkio-buities nuotekos - F1 16
1294564 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 16
1294587 | 2 a | 786.019 | 4048.83 | Ūkio-buities nuotekos - F1 16
1294616 | 2 a | 171.27 | 4929.46 | Ūkio-buities nuotekos - F1 16
1294627 | 2 a | 789.454 | 4045.39 | Ūkio-buities nuotekos - F1 16
1294630 | 2 a | 779.173 | 3900.2 | Ūkio-buities nuotekos - F1 16
1294658 | 2 a | 260.448 | 3636.28 | Ūkio-buities nuotekos - F1 16
1294677 | 2 a | 287.509 | 3607.83 | Ūkio-buities nuotekos - F1 16
1294725 | 2 a | 3.30011 | 3671.82 | Ūkio-buities nuotekos - F1 16
1294790 | 2 a | 596.799 | 3813.95 | Ūkio-buities nuotekos - F1 16
1294902 | 2 a | 555.077 | 3947.49 | Ūkio-buities nuotekos - F1 16
1294972 | 2 a | 431.13 | 3817.15 | Ūkio-buities nuotekos - F1 16
1294981 | 2 a | 4656.13 | 3717.55 | Ūkio-buities nuotekos - F1 16
1294988 | 2 a | 3180.91 | 3830.18 | Ūkio-buities nuotekos - F1 16
1295002 | 2 a | 204.573 | 4917.7 | Ūkio-buities nuotekos - F1 16
1295037 | 2 a | 800.391 | 4015.39 | Ūkio-buities nuotekos - F1 16
1295079 | 3 a | 305.484 | 3537.11 | Ūkio-buities nuotekos - F1 16
1295193 | 2 a | 320.803 | 3554.74 | Ūkio-buities nuotekos - F1 16
1295202 | 2 a | 7.25568 | 3541.31 | Ūkio-buities nuotekos - F1 16
1295380 | 2 a | 10.1303 | 3550.1 | Ūkio-buities nuotekos - F1 16
1295555 | 2 a | 441.104 | 3795.46 | Ūkio-buities nuotekos - F1 16
1295563 | 2 a | 236.631 | 4357.37 | Ūkio-buities nuotekos - F1 16
1295577 | 2 a | 86.1266 | 4530.44 | Ūkio-buities nuotekos - F1 16
1295607 | 2 a | 164.769 | 4737.37 | Ūkio-buities nuotekos - F1 16
1295689 | 2 a | 25.0579 | 3729.5 | Ūkio-buities nuotekos - F1 16
1295785 | 2 a | 405.581 | 3895.16 | Ūkio-buities nuotekos - F1 16
1295793 | 2 a | 836.222 | 3908.97 | Ūkio-buities nuotekos - F1 16
1295807 | 2 a | 133.205 | 4752.62 | Ūkio-buities nuotekos - F1 16
1295840 | 2 a | 537.778 | 4094.04 | Ūkio-buities nuotekos - F1 16
1295869 | 2 a | 791.389 | 3912.79 | Ūkio-buities nuotekos - F1 16
1295886 | 2 a | 173.645 | 3875.36 | Ūkio-buities nuotekos - F1 16
1295895 | 2 a | 399.835 | 3940.17 | Ūkio-buities nuotekos - F1 16
1295909 | 2 a | 150.325 | 4929.46 | Ūkio-buities nuotekos - F1 16
1295957 | 2 a | 789.83 | 4045.02 | Ūkio-buities nuotekos - F1 16
1295988 | 2 a | 1520.12 | 3942.75 | Ūkio-buities nuotekos - F1 16
1295999 | 2 a | 266.267 | 3932.38 | Ūkio-buities nuotekos - F1 16
1296012 | 2 a | 57.4749 | 4932.06 | Ūkio-buities nuotekos - F1 16
1296035 | 2 a | 773.028 | 4064.42 | Ūkio-buities nuotekos - F1 16
1296097 | 2 a | 49.3061 | 3914.39 | Ūkio-buities nuotekos - F1 16
1296120 | 2 a | 502.14 | 3881.64 | Ūkio-buities nuotekos - F1 16
1296129 | 2 a | 454.91 | 3928.69 | Ūkio-buities nuotekos - F1 16
1296268 | 2 a | 456.393 | 4059.38 | Ūkio-buities nuotekos - F1 16
1296346 | 2 a | 68.1893 | 3962.19 | Ūkio-buities nuotekos - F1 16
1296359 | 2 a | 315.173 | 3919.78 | Ūkio-buities nuotekos - F1 16
1296374 | 2 a | 640.969 | 3977.29 | Ūkio-buities nuotekos - F1 16
1296435 | 2 a | 99.2543 | 3993.88 | Ūkio-buities nuotekos - F1 16
1296441 | 2 a | 227.509 | 4929.46 | Ūkio-buities nuotekos - F1 16
1296509 | 2 a | 742.136 | 4092.71 | Ūkio-buities nuotekos - F1 16
1296544 | 2 a | 99.4007 | 3961.73 | Ūkio-buities nuotekos - F1 16
1296553 | 2 a | 384.125 | 3953.04 | Ūkio-buities nuotekos - F1 16
1296627 | 2 a | 778.355 | 4056.49 | Ūkio-buities nuotekos - F1 16
1296912 | 2 a | 82.2799 | 3979.87 | Ūkio-buities nuotekos - F1 16
1296927 | 2 a | 469.964 | 3965.43 | Ūkio-buities nuotekos - F1 16
1296934 | 2 a | 329.276 | 3985.29 | Ūkio-buities nuotekos - F1 16
1296948 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 16
1297013 | 2 a | 746.127 | 4088.72 | Ūkio-buities nuotekos - F1 16
1297074 | 2 a | 505.761 | 3662.15 | Ūkio-buities nuotekos - F1 16
1297087 | 2 a | 562.393 | 3633.47 | Ūkio-buities nuotekos - F1 16
1297096 | 2 a | 1472.1 | 3676.11 | Ūkio-buities nuotekos - F1 16
1297143 | 2 a | 187.501 | 4929.46 | Ūkio-buities nuotekos - F1 16
1297175 | 2 a | 1032.45 | 3802.4 | Ūkio-buities nuotekos - F1 16
1297260 | 4 a V1 | 190.601 | 3612.41 | Ūkio-buities nuotekos - F1 19
1297269 | 4 a V1 | 8719.84 | -5299.97 | Ūkio-buities nuotekos - F1 19
1297400 | 2 a | 24.734 | 3669.66 | Ūkio-buities nuotekos - F1 19
1297459 | 2 a | 419.123 | 3713.43 | Ūkio-buities nuotekos - F1 19
1297537 | 2 a | 2815.84 | 3771.85 | Ūkio-buities nuotekos - F1 19
1297651 | 2 a | 566.018 | 3949.76 | Ūkio-buities nuotekos - F1 19
1297758 | 2 a | 2142.5 | 3715.24 | Ūkio-buities nuotekos - F1 19
1297767 | 2 a | 340.292 | 3697.33 | Ūkio-buities nuotekos - F1 19
1297774 | 2 a | 134.093 | 4752.62 | Ūkio-buities nuotekos - F1 19
1297836 | 2 a | 705.387 | 3926.43 | Ūkio-buities nuotekos - F1 19
1297865 | 2 a | 4191.04 | 3730.08 | Ūkio-buities nuotekos - F1 19
1297884 | 2 a | 242.189 | 3689.68 | Ūkio-buities nuotekos - F1 19
1297951 | 2 a | 924.117 | 3910.73 | Ūkio-buities nuotekos - F1 19
1297987 | 2 a | 1942.46 | 3696.11 | Ūkio-buities nuotekos - F1 19
1297998 | 2 a | 469.174 | 3675.85 | Ūkio-buities nuotekos - F1 19
1298005 | 2 a | 184.58 | 4902.62 | Ūkio-buities nuotekos - F1 19
1298059 | 2 a | 878.52 | 3903.29 | Ūkio-buities nuotekos - F1 19
1298130 | 2 a | 28.5566 | 3649.5 | Ūkio-buities nuotekos - F1 19
1298141 | 2 a | 148.436 | 3621.92 | Ūkio-buities nuotekos - F1 19
1298156 | 2 a | 672.38 | 3661.46 | Ūkio-buities nuotekos - F1 19
1298236 | 2 a | 719.27 | 3796.48 | Ūkio-buities nuotekos - F1 19
1298569 | 2 a | 20.021 | 3708.58 | Ūkio-buities nuotekos - F1 19
1298742 | 2 a | 440.795 | 3768.4 | Ūkio-buities nuotekos - F1 19
1298750 | 2 a | 43.0263 | 3781.22 | Ūkio-buities nuotekos - F1 19
1298799 | 2 a | 681.389 | 3950.42 | Ūkio-buities nuotekos - F1 19
1298871 | 2 a | 380.602 | 3774.83 | Ūkio-buities nuotekos - F1 19
1298880 | 2 a | 257.463 | 3747.08 | Ūkio-buities nuotekos - F1 19
1298889 | 2 a | 253.28 | 3788.4 | Ūkio-buities nuotekos - F1 19
1298936 | 2 a | 670.011 | 3961.8 | Ūkio-buities nuotekos - F1 19
1298991 | 2 a | 349.726 | 3780.62 | Ūkio-buities nuotekos - F1 19
1299006 | 2 a | 1332.41 | 3717.63 | Ūkio-buities nuotekos - F1 19
1299015 | 2 a | 107.485 | 4929.46 | Ūkio-buities nuotekos - F1 19
1299047 | 2 a | 950.383 | 3884.47 | Ūkio-buities nuotekos - F1 19
1299266 | 2 a | 40.3143 | 3673.86 | Ūkio-buities nuotekos - F1 19
1299277 | 2 a | 1842.65 | 3628.37 | Ūkio-buities nuotekos - F1 19
1299284 | 2 a | 512.139 | 3719.64 | Ūkio-buities nuotekos - F1 19
1299298 | 2 a | 184.773 | 4752.62 | Ūkio-buities nuotekos - F1 19
1299328 | 2 a | 733.588 | 3898.22 | Ūkio-buities nuotekos - F1 19
1299382 | 2 a | 184.773 | 4752.62 | Ūkio-buities nuotekos - F1 19
1299393 | 2 a | 680.257 | 3951.56 | Ūkio-buities nuotekos - F1 19
1299396 | 2 a | 526.484 | 3695.86 | Ūkio-buities nuotekos - F1 19
1299502 | 2 a | 2449.18 | 3727.01 | Ūkio-buities nuotekos - F1 19
1299513 | 2 a | 634.265 | 3680.37 | Ūkio-buities nuotekos - F1 19
1299522 | 2 a | 752.016 | 3779.75 | Ūkio-buities nuotekos - F1 19
1299536 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 19
1299569 | 2 a | 943.208 | 3891.64 | Ūkio-buities nuotekos - F1 19
1299629 | 2 a | 831.449 | 3750.79 | Ūkio-buities nuotekos - F1 19
1299640 | 2 a | 299.984 | 3710.83 | Ūkio-buities nuotekos - F1 19
1299649 | 2 a | 3549.92 | 3771.19 | Ūkio-buities nuotekos - F1 19
1299696 | 2 a | 140.684 | 4929.46 | Ūkio-buities nuotekos - F1 19
1299727 | 2 a | 895.816 | 3939.03 | Ūkio-buities nuotekos - F1 19
1299869 | 2 a | 7.70195 | 3996.17 | Ūkio-buities nuotekos - F1 81
1300186 | 2 a | 4617.51 | 3683.65 | Ūkio-buities nuotekos - F1 81
1300194 | 2 a | 8216.53 | -4601.83 | Ūkio-buities nuotekos - F1 81
1300324 | 2 a | 33.4744 | 4196.63 | Ūkio-buities nuotekos - F1 81
1300333 | 2 a | 5601.91 | 4226.07 | Ūkio-buities nuotekos - F1 81
1300459 | 2 a | 434.481 | 4248.62 | Ūkio-buities nuotekos - F1 81
1300650 | 2 a | 182.924 | 4263 | Ūkio-buities nuotekos - F1 81
1300666 | 2 a | 117.913 | 4752.62 | Ūkio-buities nuotekos - F1 81
1300697 | 2 a | 197.038 | 4434.78 | Ūkio-buities nuotekos - F1 81
1300981 | 2 a | 61.1882 | 4229.2 | Ūkio-buities nuotekos - F1 81
1300990 | 2 a | 889.325 | 4203 | Ūkio-buities nuotekos - F1 81
1300997 | 2 a | 17.9652 | 4752.62 | Ūkio-buities nuotekos - F1 81
1301027 | 2 a | 233.046 | 4398.77 | Ūkio-buities nuotekos - F1 81
1301122 | 2 a | 382.979 | 4274.33 | Ūkio-buities nuotekos - F1 81
1301133 | 2 a | 15.627 | 4244.82 | Ūkio-buities nuotekos - F1 81
1301142 | 2 a | 1942.01 | 4301.27 | Ūkio-buities nuotekos - F1 81
1301156 | 2 a | 1405.78 | 4359.6 | Ūkio-buities nuotekos - F1 81
1301205 | 2 a | 6.46564 | 4509.31 | Ūkio-buities nuotekos - F1 81
1301375 | 2 a | 272.089 | 4416.93 | Ūkio-buities nuotekos - F1 19
1301384 | 2 a | 406.758 | 4351.83 | Ūkio-buities nuotekos - F1 81
1301393 | 2 a | 309.272 | 4426.14 | Ūkio-buities nuotekos - F1 19
1301407 | 2 a | 147.493 | 4929.46 | Ūkio-buities nuotekos - F1 19
1301448 | 2 a | 305.674 | 4529.18 | Ūkio-buities nuotekos - F1 19
1301477 | 2 a | 3923.03 | 4419.51 | Ūkio-buities nuotekos - F1 19
1301495 | 2 a | 609.332 | 4501.73 | Ūkio-buities nuotekos - F1 19
1301509 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 19
1301538 | 2 a | 224.088 | 4610.76 | Ūkio-buities nuotekos - F1 19
1301678 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 81
1301689 | 2 a | 329.899 | 4504.95 | Ūkio-buities nuotekos - F1 81
1301692 | 2 a | 236.226 | 4344.51 | Ūkio-buities nuotekos - F1 81
1301783 | 2 a | 304.933 | 4408.36 | Ūkio-buities nuotekos - F1 19
1301899 | 2 a | 125.204 | 4230.3 | Ūkio-buities nuotekos - F1 19
1301939 | 2 a | 1612.15 | 4059.47 | Ūkio-buities nuotekos - F1 19
1301972 | 2 a | 3461.24 | 3986.48 | Ūkio-buities nuotekos - F1 19
1302028 | 2 a | 76.8525 | 3814.16 | Ūkio-buities nuotekos - F1 19
1302031 | 2 a | 498.715 | 3648.88 | Ūkio-buities nuotekos - F1 19
1302614 | 2 a | 386.269 | 4316.09 | Ūkio-buities nuotekos - F1 81
1302625 | 2 a | 613.598 | 4286.39 | Ūkio-buities nuotekos - F1 81
1302634 | 2 a | 107.485 | 4929.46 | Ūkio-buities nuotekos - F1 81
1302665 | 2 a | 414.181 | 4420.67 | Ūkio-buities nuotekos - F1 81
1302723 | 2 a | 468.343 | 4289.15 | Ūkio-buities nuotekos - F1 81
1302734 | 2 a | 205.451 | 4267.61 | Ūkio-buities nuotekos - F1 81
1302743 | 2 a | 889.388 | 4302.29 | Ūkio-buities nuotekos - F1 81
1302757 | 2 a | 187.501 | 4929.46 | Ūkio-buities nuotekos - F1 81
1302788 | 2 a | 417.921 | 4416.93 | Ūkio-buities nuotekos - F1 81
1302854 | 2 a | 839.081 | 4225.23 | Ūkio-buities nuotekos - F1 81
1302970 | 2 a | 6406.26 | 4342.1 | Ūkio-buities nuotekos - F1 81
1302980 | 2 a | 631.928 | 4467.36 | Ūkio-buities nuotekos - F1 81
1303027 | 2 a | 162.049 | 4929.46 | Ūkio-buities nuotekos - F1 81
1303064 | 2 a | 258.006 | 4576.84 | Ūkio-buities nuotekos - F1 81
1303104 | 2 a | 420.274 | 4344.66 | Ūkio-buities nuotekos - F1 81
1303113 | 2 a | 3360.91 | 4275.97 | Ūkio-buities nuotekos - F1 81
1303169 | 2 a | 384.939 | 4449.91 | Ūkio-buities nuotekos - F1 81
1303770 | 4 a V1 | 36.6626 | -426.422 | Ūkio-buities nuotekos - F1 2
1303802 | 4 a V1 | 170.127 | -665.508 | Ūkio-buities nuotekos - F1 2
1303814 | 4 a V1 | 36.5906 | -886.422 | Ūkio-buities nuotekos - F1 2
1303828 | 4 a V1 | 4031.53 | -4986.91 | Ūkio-buities nuotekos - F1 2
1304147 | 4 a V1 | 1286.81 | -146.339 | Ūkio-buities nuotekos - F1 2
1304158 | 4 a V1 | 3111.46 | -161.55 | Ūkio-buities nuotekos - F1 2
1304236 | 1 a +-152.84 | 2265.7 | -119.279 | Ūkio-buities nuotekos - F1 2
1304288 | 1 a +-152.84 | 364.558 | -72.4099 | Ūkio-buities nuotekos - F1 2
1304719 | 1 a +-152.84 | 187.501 | 429.455 | Ūkio-buities nuotekos - F1 2
1304736 | 1 a +-152.84 | 303.12 | 31.729 | Ūkio-buities nuotekos - F1 2
1304770 | 1 a +-152.84 | 4149.7 | -4932.7 | Ūkio-buities nuotekos - F1 2
1304838 | 1 a +-152.84 | 835.947 | -681.23 | Ūkio-buities nuotekos - F1 2
1305028 | 1 a +-152.84 | 900.855 | -566.006 | Ūkio-buities nuotekos - F1 83
1305156 | 1 a +-152.84 | 139.684 | -678.649 | Ūkio-buities nuotekos - F1 2
1305197 | 1 a +-152.84 | 235.117 | -688.397 | Ūkio-buities nuotekos - F1 2
1305204 | 1 a +-152.84 | 5032.27 | -672.081 | Ūkio-buities nuotekos - F1 2
1305218 | 1 a +-152.84 | 271.856 | -567.681 | Ūkio-buities nuotekos - F1 2
1305232 | 1 a +-152.84 | 121.453 | 429.455 | Ūkio-buities nuotekos - F1 2
1305307 | 1 a +-152.84 | 800.245 | -465.396 | Ūkio-buities nuotekos - F1 2
1305341 | 1 a +-152.84 | 6213.04 | -5195.53 | Ūkio-buities nuotekos - F1 2
1305534 | 0 a | 673.935 | -5212.78 | Ūkio-buities nuotekos - F1 2
1305554 | 0 a | 273.278 | -5204.06 | Ūkio-buities nuotekos - F1 2
1305597 | 4 a V1 | 827.675 | -5223.64 | Ūkio-buities nuotekos - F1 2
1305754 | 2 a | 391.478 | -683.393 | Ūkio-buities nuotekos - F1 71
1305763 | 2 a | 5207.33 | -6178.92 | Ūkio-buities nuotekos - F1 71
1305819 | 2 a | 498.703 | -538.045 | Ūkio-buities nuotekos - F1 71
1306426 | 1 a +-152.84 | 609.026 | -665.084 | Ūkio-buities nuotekos - F1 71
1306443 | 2 a | 29.677 | -691.766 | Ūkio-buities nuotekos - F1 71
1306476 | 1 a +-152.84 | 167.853 | -649.131 | Ūkio-buities nuotekos - F1 71
1306490 | 1 a +-152.84 | 87.5848 | 429.455 | Ūkio-buities nuotekos - F1 71
1306565 | 1 a +-152.84 | 883.775 | -548.926 | Ūkio-buities nuotekos - F1 71
1306596 | 1 a +-152.84 | 178.86 | -664.284 | Ūkio-buities nuotekos - F1 71
1306605 | 1 a +-152.84 | 15.9458 | -667.868 | Ūkio-buities nuotekos - F1 71
1306612 | 1 a +-152.84 | 87.4809 | 429.455 | Ūkio-buities nuotekos - F1 71
1306715 | 1 a +-152.84 | 898.707 | -563.858 | Ūkio-buities nuotekos - F1 71
1306843 | 1 a +-152.84 | 2897.34 | -687.91 | Ūkio-buities nuotekos - F1 71
1306890 | 2 a | 731 | -738.664 | Ūkio-buities nuotekos - F1 71
1307003 | 1 a +-152.84 | 524.152 | -508.375 | Ūkio-buities nuotekos - F1 71
1307259 | 1 a +-152.84 | 2897.34 | -734.808 | Ūkio-buities nuotekos - F1 71
1307272 | 2 a | 743.401 | -786.211 | Ūkio-buities nuotekos - F1 71
1307316 | 1 a +-152.84 | 571.05 | -555.273 | Ūkio-buities nuotekos - F1 71
1307358 | 1 a +-152.84 | 2897.11 | -782.356 | Ūkio-buities nuotekos - F1 71
1307367 | 2 a | 289.695 | -810.013 | Ūkio-buities nuotekos - F1 71
1307495 | 1 a +-152.84 | 619.656 | -603.879 | Ūkio-buities nuotekos - F1 71
1307683 | 1 a +-152.84 | 3592.16 | -4483.66 | Ūkio-buities nuotekos - F1 84
1307808 | 1 a +-152.84 | 379.383 | -683.279 | Ūkio-buities nuotekos - F1 84
1307817 | 1 a +-152.84 | 3537.46 | -669.307 | Ūkio-buities nuotekos - F1 84
1307849 | 1 a +-152.84 | 2729.82 | -673.332 | Ūkio-buities nuotekos - F1 84
1307867 | 1 a +-152.84 | 692.833 | -576.252 | Ūkio-buities nuotekos - F1 84
1307942 | 1 a +-152.84 | 164.946 | 252.615 | Ūkio-buities nuotekos - F1 84
1307953 | 1 a +-152.84 | 525.872 | -394.058 | Ūkio-buities nuotekos - F1 84
1307982 | 1 a +-152.84 | 164.946 | 252.615 | Ūkio-buities nuotekos - F1 84
1307995 | 1 a +-152.84 | 467.342 | -335.529 | Ūkio-buities nuotekos - F1 84
1307998 | 1 a +-152.84 | 656.867 | -593.83 | Ūkio-buities nuotekos - F1 84
1308049 | 1 a +-152.84 | 164.769 | 252.615 | Ūkio-buities nuotekos - F1 84
1308060 | 1 a +-152.84 | 482.85 | -351.038 | Ūkio-buities nuotekos - F1 84
1308063 | 1 a +-152.84 | 905.766 | -616.385 | Ūkio-buities nuotekos - F1 84
1308155 | 1 a +-152.84 | 412.635 | -657.091 | Ūkio-buities nuotekos - F1 84
1308166 | 1 a +-152.84 | 221.697 | -698.967 | Ūkio-buities nuotekos - F1 84
1308179 | 1 a +-152.84 | 363.342 | -645.339 | Ūkio-buities nuotekos - F1 84
1308201 | 1 a +-152.84 | 181.844 | 252.615 | Ūkio-buities nuotekos - F1 84
1308233 | 1 a +-152.84 | 601.547 | -469.735 | Ūkio-buities nuotekos - F1 84
1308429 | 1 a +-152.84 | 341.709 | -660.356 | Ūkio-buities nuotekos - F1 84
1308438 | 1 a +-152.84 | 633.557 | -676.03 | Ūkio-buities nuotekos - F1 84
1308447 | 1 a +-152.84 | 181.844 | 252.615 | Ūkio-buities nuotekos - F1 84
1308476 | 1 a +-152.84 | 616.996 | -485.183 | Ūkio-buities nuotekos - F1 84
1308506 | 1 a +-152.84 | 341.533 | -669.508 | Ūkio-buities nuotekos - F1 84
1308517 | 1 a +-152.84 | 262.333 | -683.7 | Ūkio-buities nuotekos - F1 84
1308524 | 1 a +-152.84 | 138.329 | 258.557 | Ūkio-buities nuotekos - F1 84
1308584 | 1 a +-152.84 | 632.094 | -494.34 | Ūkio-buities nuotekos - F1 84
1308930 | 1 a +-152.84 | 776.682 | -642.59 | Ūkio-buities nuotekos - F1 84
1308943 | 1 a +-152.84 | 166.52 | -690.09 | Ūkio-buities nuotekos - F1 84
1308952 | 1 a +-152.84 | 213.97 | -619.321 | Ūkio-buities nuotekos - F1 84
1309013 | 1 a +-152.84 | 509.219 | -493.446 | Ūkio-buities nuotekos - F1 84
1309055 | 1 a +-152.84 | 327.814 | -638.592 | Ūkio-buities nuotekos - F1 84
1309066 | 1 a +-152.84 | 725.028 | -660.389 | Ūkio-buities nuotekos - F1 84
1309187 | 1 a +-152.84 | 526.214 | -510.439 | Ūkio-buities nuotekos - F1 84
1309229 | 1 a +-152.84 | 337.769 | -655.991 | Ūkio-buities nuotekos - F1 84
1309242 | 1 a +-152.84 | 18.2458 | -664.056 | Ūkio-buities nuotekos - F1 84
1309319 | 1 a +-152.84 | 543.415 | -527.642 | Ūkio-buities nuotekos - F1 84
1309475 | 1 a +-152.84 | 200.025 | -662.484 | Ūkio-buities nuotekos - F1 84
1309498 | 1 a +-152.84 | 852.445 | -534.917 | Ūkio-buities nuotekos - F1 84
1309570 | 1 a +-152.84 | 789.158 | -514.097 | Ūkio-buities nuotekos - F1 84
1309584 | 1 a +-152.84 | 207.505 | 429.455 | Ūkio-buities nuotekos - F1 84
1309655 | 1 a +-152.84 | 736.316 | -401.468 | Ūkio-buities nuotekos - F1 84
1309687 | 1 a +-152.84 | 583.672 | -607.413 | Ūkio-buities nuotekos - F1 84
1309697 | 1 a +-152.84 | 58.8664 | -532.336 | Ūkio-buities nuotekos - F1 84
1309698 | 1 a +-152.84 | 32.9675 | -559.204 | Ūkio-buities nuotekos - F1 84
1309702 | 1 a +-152.84 | 769.811 | -552.775 | Ūkio-buities nuotekos - F1 84
1309721 | 1 a +-152.84 | 207.505 | 429.455 | Ūkio-buities nuotekos - F1 84
1309821 | 1 a +-152.84 | 833.741 | -498.892 | Ūkio-buities nuotekos - F1 84
1309890 | 1 a +-152.84 | 820.116 | -552.189 | Ūkio-buities nuotekos - F1 84
1309899 | 1 a +-152.84 | 358.978 | -562.419 | Ūkio-buities nuotekos - F1 84
1309906 | 1 a +-152.84 | 105.888 | 429.455 | Ūkio-buities nuotekos - F1 84
1309941 | 1 a +-152.84 | 773.789 | -438.94 | Ūkio-buities nuotekos - F1 84
1309994 | 1 a +-152.84 | 17.8315 | -578.484 | Ūkio-buities nuotekos - F1 84
1310003 | 1 a +-152.84 | 1835.73 | -618.643 | Ūkio-buities nuotekos - F1 84
1310010 | 1 a +-152.84 | 349.031 | -574.353 | Ūkio-buities nuotekos - F1 84
1310024 | 1 a +-152.84 | 87.4809 | 429.455 | Ūkio-buities nuotekos - F1 84
1310085 | 1 a +-152.84 | 805.373 | -470.524 | Ūkio-buities nuotekos - F1 84
1310138 | 1 a +-152.84 | 361.867 | -564.857 | Ūkio-buities nuotekos - F1 84
1310147 | 1 a +-152.84 | 729.432 | -579.47 | Ūkio-buities nuotekos - F1 84
1310207 | 1 a +-152.84 | 39.2834 | -563.554 | Ūkio-buities nuotekos - F1 84
1310312 | 1 a +-152.84 | 147.493 | 429.455 | Ūkio-buities nuotekos - F1 84
1310358 | 1 a +-152.84 | 800.768 | -465.92 | Ūkio-buities nuotekos - F1 84
1310493 | 1 a +-152.84 | 442.336 | -614.266 | Ūkio-buities nuotekos - F1 84
1310502 | 1 a +-152.84 | 249.468 | -626.097 | Ūkio-buities nuotekos - F1 84
1310509 | 1 a +-152.84 | 809.347 | -543.664 | Ūkio-buities nuotekos - F1 84
1310556 | 1 a +-152.84 | 211.844 | -523.707 | Ūkio-buities nuotekos - F1 84
1310570 | 1 a +-152.84 | 91.4466 | 429.455 | Ūkio-buities nuotekos - F1 84
1310652 | 1 a +-152.84 | 757.471 | -422.622 | Ūkio-buities nuotekos - F1 84
1310684 | 1 a +-152.84 | 180.226 | -541.083 | Ūkio-buities nuotekos - F1 84
1310693 | 1 a +-152.84 | 783.922 | -561.802 | Ūkio-buities nuotekos - F1 84
1310724 | 1 a +-152.84 | 75.6372 | 429.455 | Ūkio-buities nuotekos - F1 84
1310800 | 1 a +-152.84 | 775.479 | -440.63 | Ūkio-buities nuotekos - F1 84
1310832 | 1 a +-152.84 | 180.226 | -559.221 | Ūkio-buities nuotekos - F1 84
1310841 | 1 a +-152.84 | 1869.55 | -601.647 | Ūkio-buities nuotekos - F1 84
1310848 | 1 a +-152.84 | 74.6372 | 429.455 | Ūkio-buities nuotekos - F1 84
1310930 | 1 a +-152.84 | 793.617 | -458.768 | Ūkio-buities nuotekos - F1 84
1310961 | 1 a +-152.84 | 300.664 | -604.792 | Ūkio-buities nuotekos - F1 84
1310974 | 1 a +-152.84 | 36.3464 | -622.653 | Ūkio-buities nuotekos - F1 84
1310983 | 1 a +-152.84 | 271.856 | -595.005 | Ūkio-buities nuotekos - F1 84
1310997 | 1 a +-152.84 | 12.5199 | 429.455 | Ūkio-buities nuotekos - F1 84
1311057 | 1 a +-152.84 | 827.569 | -492.72 | Ūkio-buities nuotekos - F1 84
1311307 | 4 a V1 | 56.4568 | 2741.1 | Ūkio-buities nuotekos - F1 1
1311343 | 4 a V1 | 3803.86 | -4623.19 | Ūkio-buities nuotekos - F1 1
1311430 | 4 a V1 | 3350.76 | -678.627 | Ūkio-buities nuotekos - F1 1
1311642 | 1 a +-152.84 | 749.077 | -636.968 | Ūkio-buities nuotekos - F1 1
1311680 | 1 a +-152.84 | 251.214 | 429.439 | Ūkio-buities nuotekos - F1 1
1311755 | 1 a +-152.84 | 864.702 | -529.853 | Ūkio-buities nuotekos - F1 1
1312049 | 1 a +-152.84 | 785.051 | -655.132 | Ūkio-buities nuotekos - F1 1
1312056 | 1 a +-152.84 | 237.475 | 429.455 | Ūkio-buities nuotekos - F1 1
1312134 | 1 a +-152.84 | 880.219 | -545.37 | Ūkio-buities nuotekos - F1 1
1312414 | 1 a +-152.84 | 290.969 | -663.415 | Ūkio-buities nuotekos - F1 1
1312456 | 1 a +-152.84 | 891.147 | -556.298 | Ūkio-buities nuotekos - F1 1
1312694 | 4 a V1 | 1762.91 | -753.264 | Ūkio-buities nuotekos - F1 1
1312703 | 4 a V1 | 8923.12 | -771.05 | Ūkio-buities nuotekos - F1 1
1312994 | 1 a +-152.84 | 715.043 | -689.953 | Ūkio-buities nuotekos - F1 1
1313010 | 1 a +-152.84 | 207.505 | 429.455 | Ūkio-buities nuotekos - F1 1
1313046 | 1 a +-152.84 | 913.655 | -578.806 | Ūkio-buities nuotekos - F1 1
1313141 | 1 a +-152.84 | 227.509 | 429.455 | Ūkio-buities nuotekos - F1 1
1313150 | 1 a +-152.84 | 897.65 | -562.801 | Ūkio-buities nuotekos - F1 1
1313153 | 1 a +-152.84 | 1091.22 | -714.238 | Ūkio-buities nuotekos - F1 1
1313184 | 1 a +-152.84 | 8101.81 | -750.683 | Ūkio-buities nuotekos - F1 1
1313201 | 4 a V1 | 5.39538 | -755.839 | Ūkio-buities nuotekos - F1 1
1313268 | 1 a +-152.84 | 826.679 | -491.83 | Ūkio-buities nuotekos - F1 1
1313366 | 2 a | 3474.25 | -797.49 | Ūkio-buities nuotekos - F1 87
1313368 | 2 a | 391.478 | -683.393 | Ūkio-buities nuotekos - F1 87
1313371 | 2 a | 4027.95 | -4999.54 | Ūkio-buities nuotekos - F1 87
1313376 | 2 a | 498.703 | -538.045 | Ūkio-buities nuotekos - F1 87
1313386 | 1 a +-152.84 | 609.026 | -665.084 | Ūkio-buities nuotekos - F1 87
1313389 | 2 a | 29.677 | -691.766 | Ūkio-buities nuotekos - F1 87
1313394 | 1 a +-152.84 | 167.853 | -649.131 | Ūkio-buities nuotekos - F1 87
1313402 | 1 a +-152.84 | 87.5848 | 429.455 | Ūkio-buities nuotekos - F1 87
1313404 | 1 a +-152.84 | 883.775 | -548.926 | Ūkio-buities nuotekos - F1 87
1313418 | 1 a +-152.84 | 178.86 | -664.284 | Ūkio-buities nuotekos - F1 87
1313421 | 1 a +-152.84 | 15.9458 | -667.868 | Ūkio-buities nuotekos - F1 87
1313426 | 1 a +-152.84 | 87.4809 | 429.455 | Ūkio-buities nuotekos - F1 87
1313428 | 1 a +-152.84 | 898.707 | -563.858 | Ūkio-buities nuotekos - F1 87
1313442 | 1 a +-152.84 | 2897.34 | -687.91 | Ūkio-buities nuotekos - F1 87
1313445 | 2 a | 731 | -738.664 | Ūkio-buities nuotekos - F1 87
1313450 | 1 a +-152.84 | 524.152 | -508.375 | Ūkio-buities nuotekos - F1 87
1313458 | 1 a +-152.84 | 2897.34 | -734.808 | Ūkio-buities nuotekos - F1 87
1313461 | 2 a | 743.401 | -786.211 | Ūkio-buities nuotekos - F1 87
1313466 | 1 a +-152.84 | 571.05 | -555.273 | Ūkio-buities nuotekos - F1 87
1313474 | 1 a +-152.84 | 2897.11 | -782.356 | Ūkio-buities nuotekos - F1 87
1313477 | 2 a | 289.695 | -810.013 | Ūkio-buities nuotekos - F1 87
1313488 | 1 a +-152.84 | 619.656 | -603.879 | Ūkio-buities nuotekos - F1 87
1313505 | 1 a +-152.84 | 3856.42 | -4739.14 | Ūkio-buities nuotekos - F1 84
1313507 | 1 a +-152.84 | 379.383 | -674.497 | Ūkio-buities nuotekos - F1 84
1313510 | 1 a +-152.84 | 4331.22 | -660.523 | Ūkio-buities nuotekos - F1 84
1313515 | 1 a +-152.84 | 2729.82 | -664.549 | Ūkio-buities nuotekos - F1 84
1313521 | 1 a +-152.84 | 692.833 | -567.477 | Ūkio-buities nuotekos - F1 84
1313527 | 1 a +-152.84 | 164.946 | 252.615 | Ūkio-buities nuotekos - F1 84
1313529 | 1 a +-152.84 | 517.096 | -385.286 | Ūkio-buities nuotekos - F1 84
1313543 | 1 a +-152.84 | 164.946 | 252.615 | Ūkio-buities nuotekos - F1 84
1313545 | 1 a +-152.84 | 458.566 | -326.756 | Ūkio-buities nuotekos - F1 84
1313548 | 1 a +-152.84 | 656.867 | -585.054 | Ūkio-buities nuotekos - F1 84
1313559 | 1 a +-152.84 | 164.769 | 252.615 | Ūkio-buities nuotekos - F1 84
1313561 | 1 a +-152.84 | 478.461 | -346.649 | Ūkio-buities nuotekos - F1 84
1313564 | 1 a +-152.84 | 905.417 | -607.602 | Ūkio-buities nuotekos - F1 84
1313575 | 1 a +-152.84 | 412.655 | -650.503 | Ūkio-buities nuotekos - F1 84
1313578 | 1 a +-152.84 | 221.609 | -690.182 | Ūkio-buities nuotekos - F1 84
1313589 | 1 a +-152.84 | 363.123 | -638.751 | Ūkio-buities nuotekos - F1 84
1313597 | 1 a +-152.84 | 181.844 | 252.615 | Ūkio-buities nuotekos - F1 84
1313599 | 1 a +-152.84 | 594.963 | -463.152 | Ūkio-buities nuotekos - F1 84
1313613 | 1 a +-152.84 | 341.506 | -654.167 | Ūkio-buities nuotekos - F1 84
1313616 | 1 a +-152.84 | 633.557 | -669.442 | Ūkio-buities nuotekos - F1 84
1313621 | 1 a +-152.84 | 181.844 | 252.615 | Ūkio-buities nuotekos - F1 84
1313623 | 1 a +-152.84 | 610.811 | -479 | Ūkio-buities nuotekos - F1 84
1313637 | 1 a +-152.84 | 341.314 | -662.92 | Ūkio-buities nuotekos - F1 84
1313640 | 1 a +-152.84 | 262.333 | -677.111 | Ūkio-buities nuotekos - F1 84
1313645 | 1 a +-152.84 | 138.329 | 258.557 | Ūkio-buities nuotekos - F1 84
1313647 | 1 a +-152.84 | 625.51 | -487.757 | Ūkio-buities nuotekos - F1 84
1313661 | 1 a +-152.84 | 776.682 | -636.209 | Ūkio-buities nuotekos - F1 84
1313664 | 1 a +-152.84 | 166.52 | -681.308 | Ūkio-buities nuotekos - F1 84
1313669 | 1 a +-152.84 | 213.97 | -612.945 | Ūkio-buities nuotekos - F1 84
1313677 | 1 a +-152.84 | 502.843 | -487.066 | Ūkio-buities nuotekos - F1 84
1313685 | 1 a +-152.84 | 327.647 | -632.211 | Ūkio-buities nuotekos - F1 84
1313688 | 1 a +-152.84 | 725.028 | -654.008 | Ūkio-buities nuotekos - F1 84
1313693 | 1 a +-152.84 | 519.836 | -504.061 | Ūkio-buities nuotekos - F1 84
1313701 | 1 a +-152.84 | 337.681 | -651.606 | Ūkio-buities nuotekos - F1 84
1313704 | 1 a +-152.84 | 17.9812 | -657.669 | Ūkio-buities nuotekos - F1 84
1313709 | 1 a +-152.84 | 539.03 | -523.258 | Ūkio-buities nuotekos - F1 84
1313727 | 1 a +-152.84 | 200.005 | -655.896 | Ūkio-buities nuotekos - F1 84
1313732 | 1 a +-152.84 | 852.445 | -528.329 | Ūkio-buities nuotekos - F1 84
1313734 | 1 a +-152.84 | 789.195 | -507.509 | Ūkio-buities nuotekos - F1 84
1313742 | 1 a +-152.84 | 207.505 | 429.455 | Ūkio-buities nuotekos - F1 84
1313744 | 1 a +-152.84 | 729.728 | -394.88 | Ūkio-buities nuotekos - F1 84
1313758 | 1 a +-152.84 | 583.672 | -607.413 | Ūkio-buities nuotekos - F1 84
1313760 | 1 a +-152.84 | 52.4004 | -525.748 | Ūkio-buities nuotekos - F1 84
1313761 | 1 a +-152.84 | 42.1941 | -559.204 | Ūkio-buities nuotekos - F1 84
1313765 | 1 a +-152.84 | 769.811 | -546.188 | Ūkio-buities nuotekos - F1 84
1313778 | 1 a +-152.84 | 207.505 | 429.455 | Ūkio-buities nuotekos - F1 84
1313780 | 1 a +-152.84 | 833.741 | -498.892 | Ūkio-buities nuotekos - F1 84
1313794 | 1 a +-152.84 | 820.152 | -545.601 | Ūkio-buities nuotekos - F1 84
1313797 | 1 a +-152.84 | 358.978 | -555.831 | Ūkio-buities nuotekos - F1 84
1313802 | 1 a +-152.84 | 105.888 | 429.455 | Ūkio-buities nuotekos - F1 84
1313804 | 1 a +-152.84 | 767.201 | -432.353 | Ūkio-buities nuotekos - F1 84
1313818 | 1 a +-152.84 | 17.6074 | -572.695 | Ūkio-buities nuotekos - F1 84
1313821 | 1 a +-152.84 | 1835.54 | -612.051 | Ūkio-buities nuotekos - F1 84
1313826 | 1 a +-152.84 | 349.075 | -568.568 | Ūkio-buities nuotekos - F1 84
1313834 | 1 a +-152.84 | 87.4809 | 429.455 | Ūkio-buities nuotekos - F1 84
1313836 | 1 a +-152.84 | 799.588 | -464.739 | Ūkio-buities nuotekos - F1 84
1313850 | 1 a +-152.84 | 362.083 | -558.272 | Ūkio-buities nuotekos - F1 84
1313853 | 1 a +-152.84 | 729.432 | -572.882 | Ūkio-buities nuotekos - F1 84
1313870 | 1 a +-152.84 | 39.0638 | -556.969 | Ūkio-buities nuotekos - F1 84
1313872 | 1 a +-152.84 | 147.493 | 429.455 | Ūkio-buities nuotekos - F1 84
1313874 | 1 a +-152.84 | 794.188 | -459.34 | Ūkio-buities nuotekos - F1 84
1313888 | 1 a +-152.84 | 442.432 | -609.47 | Ūkio-buities nuotekos - F1 84
1313891 | 1 a +-152.84 | 249.66 | -619.509 | Ūkio-buities nuotekos - F1 84
1313896 | 1 a +-152.84 | 569.395 | -538.866 | Ūkio-buities nuotekos - F1 84
1313904 | 1 a +-152.84 | 211.844 | -523.707 | Ūkio-buities nuotekos - F1 84
1313912 | 1 a +-152.84 | 91.4466 | 429.455 | Ūkio-buities nuotekos - F1 84
1313914 | 1 a +-152.84 | 757.471 | -422.622 | Ūkio-buities nuotekos - F1 84
1313928 | 1 a +-152.84 | 180.13 | -536.285 | Ūkio-buities nuotekos - F1 84
1313931 | 1 a +-152.84 | 783.922 | -557.005 | Ūkio-buities nuotekos - F1 84
1313936 | 1 a +-152.84 | 75.6372 | 429.455 | Ūkio-buities nuotekos - F1 84
1313938 | 1 a +-152.84 | 770.683 | -435.834 | Ūkio-buities nuotekos - F1 84
1313952 | 1 a +-152.84 | 180.178 | -556.823 | Ūkio-buities nuotekos - F1 84
1313955 | 1 a +-152.84 | 1869.55 | -596.849 | Ūkio-buities nuotekos - F1 84
1313960 | 1 a +-152.84 | 74.6372 | 429.455 | Ūkio-buities nuotekos - F1 84
1313962 | 1 a +-152.84 | 791.22 | -456.371 | Ūkio-buities nuotekos - F1 84
1313976 | 1 a +-152.84 | 300.664 | -600.11 | Ūkio-buities nuotekos - F1 84
1313979 | 1 a +-152.84 | 36.0911 | -616.272 | Ūkio-buities nuotekos - F1 84
1313984 | 1 a +-152.84 | 271.944 | -590.323 | Ūkio-buities nuotekos - F1 84
1313992 | 1 a +-152.84 | 12.5199 | 429.455 | Ūkio-buities nuotekos - F1 84
1313994 | 1 a +-152.84 | 822.885 | -488.036 | Ūkio-buities nuotekos - F1 84
1314993 | 4 a V1 | 3300 | -302.903 | K1 2
1315109 | 4 a V1 | 374.344 | -791.776 | K1 2
1315118 | 4 a V1 | 462.397 | -759.082 | K1 2
1316235 | 1 a +-152.84 | 167.5 | -707.224 | K1 2
1316311 | 1 a +-152.84 | 491.749 | -535.235 | K1 2
1316517 | 1 a +-152.84 | 321.089 | -756.107 | K1 2
1316526 | 1 a +-152.84 | 263.997 | -770.029 | K1 2
1316533 | 1 a +-152.84 | 130.527 | 252.615 | K1 2
1316586 | 1 a +-152.84 | 713.16 | -581.347 | K1 2
1316617 | 1 a +-152.84 | 281.081 | -739.037 | K1 2
1316630 | 1 a +-152.84 | 351.464 | -754.708 | K1 2
1316637 | 1 a +-152.84 | 108.323 | 252.615 | K1 2
1316705 | 1 a +-152.84 | 696.89 | -565.077 | K1 2
1316737 | 1 a +-152.84 | 321.041 | -719.132 | K1 2
1316750 | 1 a +-152.84 | 372.376 | -735.221 | K1 2
1316757 | 1 a +-152.84 | 128.327 | 252.615 | K1 2
1316786 | 1 a +-152.84 | 676.185 | -544.372 | K1 2
1316817 | 1 a +-152.84 | 369.069 | -676.08 | K1 2
1316830 | 1 a +-152.84 | 284.614 | -715.729 | K1 2
1316839 | 1 a +-152.84 | 131.054 | 429.455 | K1 2
1316887 | 1 a +-152.84 | 906.7 | -571.851 | K1 2
1317002 | 1 a +-152.84 | 314.286 | -675.33 | K1 2
1317011 | 1 a +-152.84 | 260.199 | -743.237 | K1 2
1317020 | 1 a +-152.84 | 109.317 | -665.271 | K1 2
1317034 | 1 a +-152.84 | 87.4809 | 429.455 | K1 2
1317074 | 1 a +-152.84 | 901.084 | -566.235 | K1 2
1317103 | 1 a +-152.84 | 282.304 | -674.547 | K1 2
1317116 | 1 a +-152.84 | 1314.36 | -704.077 | K1 2
1317123 | 1 a +-152.84 | 169.087 | -665.128 | K1 2
1317137 | 1 a +-152.84 | 124.559 | 429.455 | K1 2
1317167 | 1 a +-152.84 | 899.746 | -564.897 | K1 2
1317199 | 1 a +-152.84 | 1049.59 | -738.886 | K1 2
1317208 | 1 a +-152.84 | 287.405 | -778.59 | K1 2
1317278 | 1 a +-152.84 | 167.497 | 429.455 | K1 2
1317287 | 1 a +-152.84 | 955.898 | -621.049 | K1 2
1317317 | 1 a +-152.84 | 261.385 | -787.575 | K1 2
1317337 | 1 a +-152.84 | 294.759 | 252.615 | K1 2
1317376 | 1 a +-152.84 | 745.822 | -614.009 | K1 2
1317447 | 1 a +-152.84 | 593.73 | -723.564 | K1 2
1317458 | 1 a +-152.84 | 139.309 | -760.307 | K1 2
1317467 | 1 a +-152.84 | 89.0714 | -707.833 | K1 2
1317514 | 1 a +-152.84 | 267.517 | 429.455 | K1 2
1317560 | 1 a +-152.84 | 944.052 | -609.203 | K1 2
1317590 | 1 a +-152.84 | 973.861 | -696.505 | K1 2
1317603 | 1 a +-152.84 | 206.124 | -723.332 | K1 2
1317618 | 1 a +-152.84 | 906.265 | -675.994 | K1 2
1317663 | 1 a +-152.84 | 469.895 | -656.047 | K1 2
1317781 | 1 a +-152.84 | 540.828 | -525.051 | K1 2
1317906 | 4 a V1 | 1524.33 | -721.088 | Ūkio-buities nuotekos - F1 5
1317915 | 4 a V1 | 4456.5 | -761.656 | Ūkio-buities nuotekos - F1 5
1317981 | 1 a +-152.84 | 1540.7 | -686.201 | Ūkio-buities nuotekos - F1 5
1318088 | 1 a +-152.84 | 549.57 | -533.803 | Ūkio-buities nuotekos - F1 5
1318181 | 1 a +-152.84 | 208.411 | -730.617 | Ūkio-buities nuotekos - F1 5
1318196 | 4 a V1 | 1334.69 | -774.739 | Ūkio-buities nuotekos - F1 5
1318205 | 1 a +-152.84 | 742.967 | -694.547 | Ūkio-buities nuotekos - F1 5
1318219 | 1 a +-152.84 | 130.658 | 429.455 | Ūkio-buities nuotekos - F1 5
1318305 | 1 a +-152.84 | 917.69 | -582.842 | Ūkio-buities nuotekos - F1 5
1318367 | 1 a +-152.84 | 88.8852 | 429.455 | Ūkio-buities nuotekos - F1 5
1318380 | 1 a +-152.84 | 902.244 | -567.396 | Ūkio-buities nuotekos - F1 5
1318383 | 1 a +-152.84 | 298.53 | -702.982 | Ūkio-buities nuotekos - F1 5
1318412 | 1 a +-152.84 | 100.21 | -699.202 | Ūkio-buities nuotekos - F1 5
1318425 | 1 a +-152.84 | 861.543 | -722.675 | Ūkio-buities nuotekos - F1 5
1318432 | 1 a +-152.84 | 107.485 | 429.455 | Ūkio-buities nuotekos - F1 5
1318469 | 1 a +-152.84 | 935.198 | -600.349 | Ūkio-buities nuotekos - F1 5
1318547 | 2 a | 790.828 | 3016.66 | Ūkio-buities nuotekos - F1 69
1318556 | 2 a | 11.8898 | 3240.72 | Ūkio-buities nuotekos - F1 69
1318763 | 2 a | 2.89667 | 3010.9 | Ūkio-buities nuotekos - F1 69
1318828 | 2 a | 3527.73 | -585.789 | Ūkio-buities nuotekos - F1 69
1318881 | 2 a | 55.6832 | -807.084 | Ūkio-buities nuotekos - F1 69
1318898 | 2 a | 404.66 | -810.474 | Ūkio-buities nuotekos - F1 69
1319034 | 2 a | 15.6259 | -780.287 | Ūkio-buities nuotekos - F1 69
1319061 | 2 a | 741.972 | -608.687 | Ūkio-buities nuotekos - F1 69
1319246 | 1 a +-152.84 | 155.633 | -588.15 | Ūkio-buities nuotekos - F1 69
1319262 | 1 a +-152.84 | 424.821 | 252.615 | Ūkio-buities nuotekos - F1 69
1319317 | 1 a +-152.84 | 548.511 | -416.701 | Ūkio-buities nuotekos - F1 69
1319386 | 2 a | 447.886 | -622.086 | Ūkio-buities nuotekos - F1 69
