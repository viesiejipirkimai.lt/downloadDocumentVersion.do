Properties of the parts of a building model (IFC2X3), part 19 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1373156_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373180_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373229_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373229_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373229_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373645_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373234_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373248_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373285_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373246_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373246_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373248_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373252_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373289_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373252_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373283_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373285_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373283_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373289_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373304_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373375_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373304_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373388_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373317_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373375_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373375_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373376_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373376_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373449_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373380_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373388_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373380_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373419_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373390_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373423_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373390_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373417_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373419_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373423_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373439_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373449_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373439_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373449_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373450_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373450_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373453_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373537_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373453_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373531_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373533_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373555_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373565_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373555_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373577_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373565_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373566_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373566_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373569_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373577_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373569_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373579_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373617_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373579_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373611_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373613_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373611_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373644_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373656_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373645_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373648_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373656_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373689_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373658_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373693_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373658_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373687_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373689_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373693_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373723_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373723_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373724_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373723_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373807_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373856_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373815_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373860_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373815_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373854_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373856_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373854_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373860_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373876_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373935_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373948_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373891_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424918_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373935_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373940_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373948_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373940_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373983_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373975_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373983_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373975_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1373991_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374805_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374016_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376391_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374016_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375283_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374032_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374032_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374629_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374048_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374631_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374598_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374600_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375312_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374601_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383504_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374629_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380625_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374631_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374796_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374931_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374796_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375283_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374805_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374931_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375335_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375857_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375432_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375388_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376240_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375388_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375389_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375388_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375916_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375389_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375392_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375527_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375392_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375444_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375432_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375528_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375436_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375436_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375446_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375493_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375446_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375487_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375489_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375487_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375493_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375517_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375527_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375517_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375578_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375527_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375528_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375531_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375582_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375576_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375578_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375576_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375582_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375597_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375722_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375597_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375605_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375788_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375605_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375605_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375723_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375606_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375915_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375609_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375615_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375609_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375663_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375617_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375667_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375661_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375663_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375667_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375710_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375722_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375710_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375759_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375722_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375723_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375726_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375763_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375726_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375757_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375759_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375757_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375779_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375787_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375779_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375858_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375787_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375791_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375834_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375791_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375828_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375830_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375834_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375849_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375857_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375849_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375888_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375857_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375892_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375886_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375888_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375886_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375892_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375907_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376074_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375925_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375915_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375916_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375915_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376134_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375919_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375925_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375919_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375935_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375927_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375927_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375937_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375999_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375993_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375995_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375993_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1375999_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376066_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376074_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376066_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376103_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376074_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376075_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376075_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376133_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376078_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376107_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376078_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376101_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376103_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376101_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376107_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376125_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376133_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376125_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376133_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376134_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376137_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376171_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376137_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376167_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376171_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376219_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376329_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376254_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376239_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376392_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376239_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376240_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376239_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376330_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376243_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376256_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376262_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376256_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376297_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376264_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376301_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376295_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376297_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376295_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376321_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376329_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376321_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376329_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376330_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376333_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376364_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376358_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376360_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376358_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376364_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376379_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376391_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376379_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376391_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376392_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376395_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376428_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376395_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376422_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376424_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376444_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376454_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376494_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376454_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376839_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376458_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376498_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376458_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376492_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376494_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376492_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376498_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376515_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376625_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376541_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376529_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376772_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376529_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376530_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376529_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376698_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376530_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376533_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376543_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376549_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376551_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376600_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376594_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376596_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376617_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376625_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376625_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376626_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376626_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376697_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376629_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376665_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376629_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376659_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376661_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376659_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376687_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376697_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376743_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376697_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376698_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376701_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376747_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376701_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376741_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376743_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376741_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376747_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376763_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376771_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376811_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376771_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376771_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376775_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376815_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376775_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376809_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376811_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376809_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376815_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376831_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376839_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376831_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376839_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376843_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376883_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376843_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376877_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376877_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1376883_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377076_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377090_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377076_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377119_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377090_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377247_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377090_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377091_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377153_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377094_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377123_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377094_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377117_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377119_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377117_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377139_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377153_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377139_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377197_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377153_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377154_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377154_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378880_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377157_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377201_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377157_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377195_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377197_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377195_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377201_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377222_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377258_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377246_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377655_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377246_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377246_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377544_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377250_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377464_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377250_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377268_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377258_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377465_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377260_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377378_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377260_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377300_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377270_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377270_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377379_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377292_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377300_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377302_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377335_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377329_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377331_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377329_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377370_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377378_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377370_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377378_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377379_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377382_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377439_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377433_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377435_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377433_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377439_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377454_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377464_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377464_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377468_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377517_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377468_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377509_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377511_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377517_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377513_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377535_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377543_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377543_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377544_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377547_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377598_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377547_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377592_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377594_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377613_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377654_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377664_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377654_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377658_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377664_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377658_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377684_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377666_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377684_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377666_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377719_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377709_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377709_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377745_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377721_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377747_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377721_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377759_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377745_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377747_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377751_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377759_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377761_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377797_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377761_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377791_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377793_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377791_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377797_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377850_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377860_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377903_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377860_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377933_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377860_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377864_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377907_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377864_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377901_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377903_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377924_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377932_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377932_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378008_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377932_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377973_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377967_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377969_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377997_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1377997_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378019_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378007_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378406_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378007_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378008_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378007_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378199_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378011_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378019_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378011_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378063_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378021_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378067_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378061_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378063_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378061_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378067_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378190_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378198_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378190_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378198_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378199_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378202_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378238_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378232_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378234_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378232_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378254_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378264_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378297_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378332_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378264_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378265_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378265_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378405_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378301_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378295_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378297_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378295_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378319_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378331_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378319_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378331_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378332_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378335_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378367_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378361_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378363_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378385_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378385_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378446_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378405_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378406_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378405_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378537_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378409_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378446_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378409_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378504_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378448_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378508_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378448_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378502_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378504_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378502_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378508_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378528_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378536_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378528_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378536_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378540_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378569_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378540_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378563_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378565_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378563_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378569_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378584_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378584_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378606_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378739_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378594_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378595_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378594_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378673_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378595_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379891_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378598_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378614_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378608_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378614_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378608_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378643_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378616_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378647_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378616_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378641_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378643_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378647_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378664_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378672_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378664_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378708_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378672_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378673_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378676_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378712_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378706_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378708_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378706_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378712_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378728_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378738_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378728_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378773_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378804_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378738_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378739_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378742_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378777_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378742_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378771_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378773_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378771_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378777_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378793_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378803_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378844_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378803_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378803_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378804_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378807_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378848_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378842_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378844_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378842_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378848_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378868_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378892_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378880_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378880_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379817_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378884_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379209_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378884_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378940_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378892_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379749_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378894_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378944_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378894_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378938_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378944_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378938_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1378940_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379199_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379209_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379199_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379209_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379210_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379210_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379298_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379213_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379242_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379213_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379236_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379238_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379236_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379242_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379290_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379298_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379290_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379298_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379299_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379299_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379302_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379337_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379331_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379333_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379337_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379355_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379517_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379367_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379367_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379518_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379368_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379584_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379371_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379382_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379430_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379384_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379434_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379384_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379428_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379430_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379509_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379517_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379552_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379517_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379521_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379556_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379521_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379550_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379552_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379550_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379556_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379572_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379670_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379572_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379596_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379584_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379584_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379671_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379585_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379748_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379588_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379598_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379588_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379602_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379645_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379602_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379639_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379641_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379639_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379645_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379660_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379670_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379660_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379716_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379670_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379671_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379674_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379720_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379674_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379714_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379716_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379714_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379720_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379736_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379748_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379736_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379748_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379752_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379790_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379752_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379784_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379786_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379784_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379790_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379808_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379816_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379808_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379826_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379816_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379820_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379826_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379820_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379860_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379828_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379864_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379858_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379860_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379864_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379891_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379926_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379891_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379892_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379892_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379895_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379930_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379895_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379924_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379926_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379930_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379946_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379956_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379946_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379956_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380021_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379956_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380248_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379960_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379991_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379960_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379985_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379987_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379985_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1379991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380012_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380012_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380032_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380020_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380020_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380124_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380024_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455523_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380072_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380032_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455524_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380034_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380076_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380070_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380072_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380070_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380076_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380115_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380123_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380169_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380123_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380127_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380173_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380127_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380167_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380169_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380248_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380449_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380248_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380249_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380249_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380252_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380392_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380252_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380286_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380262_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380288_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380300_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380286_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380288_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380292_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380300_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380308_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380302_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380308_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380348_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380310_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380352_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380310_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380346_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380348_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380346_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380382_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380392_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380392_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380393_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380393_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380449_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380396_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380432_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380396_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380426_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380428_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380426_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380432_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380449_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380552_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380460_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380460_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380484_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380484_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380523_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380486_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380527_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380521_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380523_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380521_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380527_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380543_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380551_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380551_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380552_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380555_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380589_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380555_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380583_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380585_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380583_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380610_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382864_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380642_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380624_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380625_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380624_3 | SOURCEANDSINK | vanduo šaltas - V1 2
