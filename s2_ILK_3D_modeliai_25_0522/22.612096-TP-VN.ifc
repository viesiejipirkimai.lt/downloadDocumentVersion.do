Properties of the parts of a building model (IFC2X3), part 9 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1254450_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254442_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254504_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254451_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254450_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1506603_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254458_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254512_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254502_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254504_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254512_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254690_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254700_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254690_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254700_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254701_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254701_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254954_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254708_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254803_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254708_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254748_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254750_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254803_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254818_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254826_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254818_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254826_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254826_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255371_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254834_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254883_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254834_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254873_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254875_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254873_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254946_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255073_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254946_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255033_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254954_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254955_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254954_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255074_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254955_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1506602_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254964_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255039_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254964_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255031_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255033_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255060_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255081_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255071_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255073_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255071_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255081_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255073_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255074_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255192_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255206_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255192_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255216_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255267_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255216_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255259_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255261_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255267_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255360_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255370_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255360_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255386_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255380_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255386_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255380_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255441_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255439_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255441_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255447_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255733_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255741_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255815_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255741_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255741_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255907_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255813_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255815_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255813_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255896_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255906_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255896_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255989_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255907_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255906_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256098_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255987_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255989_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255987_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256026_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256085_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256097_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256097_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256098_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256097_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256232_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256107_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256113_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256107_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256121_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256202_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256121_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256194_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256196_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256202_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256223_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256231_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256223_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256338_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256231_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256336_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256338_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256377_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256571_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256579_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256571_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256621_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256580_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258412_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256668_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258497_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256668_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256768_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256760_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256768_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256760_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256785_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256794_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256804_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256864_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256805_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256804_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258015_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256805_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257194_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256856_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256864_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256856_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256870_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258731_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256870_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256876_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258732_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257140_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257148_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257148_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257194_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257242_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257195_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257195_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258202_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257234_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257242_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257234_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257248_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258845_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257254_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258846_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257966_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257985_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257977_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257979_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257977_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1257985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258006_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258022_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258006_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258092_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258014_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258015_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258014_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258498_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258014_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258028_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258108_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258028_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258090_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258092_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258108_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258190_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258202_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258202_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258203_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258203_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258210_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258256_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258210_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258246_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258248_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258246_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258256_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258397_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258411_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258397_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258412_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258421_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258466_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258421_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258456_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258458_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258456_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258466_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258487_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258620_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258498_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258497_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258507_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258561_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258507_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258551_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258553_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258551_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258612_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258620_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258612_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258634_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258628_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258688_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258642_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258696_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258642_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258688_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258696_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258717_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258731_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258717_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258747_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258731_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258741_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259191_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258741_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258798_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258747_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259192_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258753_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258804_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258753_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258796_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258798_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258825_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258845_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258861_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258846_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258855_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258861_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258855_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258925_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258867_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258931_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258923_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258925_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258923_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1258931_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259181_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259191_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259192_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259199_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259238_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259250_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259244_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259250_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259302_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259258_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259379_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259258_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259300_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259302_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1259770_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260093_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259770_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259815_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259787_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261110_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259787_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259879_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259871_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261111_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259871_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261070_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259879_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259880_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259880_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260080_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260103_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260080_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260091_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260093_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260103_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260093_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260094_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260094_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260536_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260528_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260536_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260683_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260536_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260537_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260882_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260669_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260683_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260669_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260770_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260768_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260770_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260768_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260807_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
OutPort_1260852_1 | SOURCE
Port_1260874_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260882_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260874_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260883_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261069_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260906_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260987_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260979_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260981_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1260987_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261038_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 68
Port_1261038_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 68
Port_1261058_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261077_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261058_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261067_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261069_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261067_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261077_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261069_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261070_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261098_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261110_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261098_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261110_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261111_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261140_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261148_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261294_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261148_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261168_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261162_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261168_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261234_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261176_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261242_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261176_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261232_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261234_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261242_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261294_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261307_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261307_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261426_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261317_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261426_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261482_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261490_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261496_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261583_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261573_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261575_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261573_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261583_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1261725_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261725_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1419476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261862_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318556_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261862_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261863_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261862_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261863_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261916_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261925_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262009_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261925_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261963_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261949_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261963_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261949_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261980_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261995_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263054_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1261995_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262043_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262005_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262009_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262017_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262006_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262017_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262006_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262009_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262010_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262010_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263368_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262031_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263055_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262037_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262540_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262043_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262826_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262051_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262096_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262051_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262088_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262090_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262088_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262096_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262532_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262540_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262540_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262541_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262541_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262825_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
OutPort_1262763_1 | SOURCE
Port_1262781_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262825_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262781_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262947_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262826_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262835_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262955_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262945_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262947_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262945_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1262955_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263036_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263253_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263070_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263055_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263054_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263254_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263064_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263070_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263064_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263129_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263078_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263135_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263127_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263129_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263135_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263253_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263267_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263261_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263267_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263275_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263321_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263313_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263315_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263313_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263321_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263360_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263368_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263360_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263368_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263425_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263439_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263425_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263451_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1263451_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264048_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264151_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264149_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264151_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264157_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1264185_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 70
Port_1264185_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 70
Port_1264237_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264303_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264237_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264283_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264295_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279657_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264295_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264303_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264303_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264647_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264304_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266925_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264311_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264317_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264311_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264415_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265302_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264415_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264646_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264435_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264638_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264435_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264479_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264487_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264479_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264499_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264493_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264499_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264493_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264638_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265883_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264646_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264647_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264646_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279658_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264672_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264684_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264712_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265336_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264684_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264685_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265047_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264704_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264712_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264704_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264724_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264718_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264724_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1264718_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265021_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265047_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265021_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265116_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265047_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265048_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265074_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265116_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265074_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
OutPort_1265242_1 | SOURCE
Port_1265280_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265302_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265280_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265302_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265303_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265303_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265325_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265335_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265325_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265351_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265335_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265351_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265607_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265709_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265715_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265707_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265709_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265707_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265874_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266261_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265874_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265898_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265882_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265882_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266579_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265892_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266022_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265898_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266023_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265906_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265985_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265977_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265979_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265977_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1265985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266012_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266030_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266012_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266159_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266023_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266022_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266036_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266200_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266157_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266159_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266200_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266251_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266261_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266275_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266262_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266578_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266269_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266269_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266283_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266289_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266283_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266297_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266375_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266297_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266367_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266369_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266367_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266375_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
OutPort_1266406_1 | SOURCE
Port_1266556_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266578_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266556_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266578_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266659_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266678_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266659_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266670_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266672_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266670_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266917_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267016_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266917_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267223_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266925_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266925_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267017_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1266926_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267269_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267000_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267016_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267000_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267017_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267024_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267030_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267024_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267084_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267076_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267084_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267076_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267096_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267090_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267096_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267154_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267173_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267165_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267167_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267165_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267173_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267223_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267269_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267269_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268132_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267270_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305762_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267436_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268268_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267436_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267450_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267444_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267887_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267444_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267503_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267562_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267501_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267503_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267553_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267561_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267640_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267562_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267561_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267833_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267648_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267638_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267640_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267638_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267648_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267708_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267822_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267824_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267832_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267822_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267824_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267832_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267833_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267832_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267888_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267879_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267887_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267879_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267998_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267887_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267888_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267992_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267998_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1267992_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268084_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268039_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268090_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268082_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268084_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268082_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268113_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268131_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268184_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268132_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268131_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268269_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268190_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268184_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268254_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268372_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268269_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268268_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268373_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268278_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268332_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268324_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268326_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268364_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268372_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268364_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268453_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268372_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268373_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268380_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268461_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268380_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268451_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268453_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268451_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1268497_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269117_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268592_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268600_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268592_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268600_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269118_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268676_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270238_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268931_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271166_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268931_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268945_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268939_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274342_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268939_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269008_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1268945_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274343_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269000_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269008_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269000_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269109_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269262_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269109_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269117_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269118_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269117_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269608_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269159_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269167_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269159_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269184_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269197_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269222_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269212_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269214_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269212_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269222_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269215_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269214_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269263_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269215_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269607_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
