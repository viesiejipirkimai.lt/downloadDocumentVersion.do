Properties of the parts of a building model (IFC2X3), part 42 of 57

# IfcFlowFitting: PIF_Tigris_Elbow_M-K_Wavin:Standard (3281)
Name (PIF_Tigris_Elbow_M-K_Wavin:Standard:...) | In | Group
1406105 | 1 a +-152.84 | vanduo šaltas - V1 2
1406139 | 1 a +-152.84 | vanduo šaltas - V1 2
1406143 | 1 a +-152.84 | vanduo šaltas - V1 2
1406212 | 1 a +-152.84 | vanduo šaltas - V1 2
1406220 | 1 a +-152.84 | vanduo šaltas - V1 2
1406266 | 1 a +-152.84 | vanduo šaltas - V1 2
1406270 | 1 a +-152.84 | vanduo šaltas - V1 2
1406316 | 1 a +-152.84 | vanduo šaltas - V1 2
1406324 | 1 a +-152.84 | vanduo šaltas - V1 2
1406380 | 1 a +-152.84 | vanduo šaltas - V1 2
1406424 | 1 a +-152.84 | vanduo šaltas - V1 2
1406428 | 1 a +-152.84 | vanduo šaltas - V1 2
1406509 | 1 a +-152.84 | vanduo šaltas - V1 2
1406513 | 1 a +-152.84 | vanduo šaltas - V1 2
1406589 | 1 a +-152.84 | vanduo šaltas - V1 2
1406593 | 1 a +-152.84 | vanduo šaltas - V1 2
1406633 | 1 a +-152.84 | vanduo šaltas - V1 2
1406680 | 1 a +-152.84 | vanduo šaltas - V1 2
1406684 | 1 a +-152.84 | vanduo šaltas - V1 2
1406751 | 1 a +-152.84 | vanduo šaltas - V1 2
1406755 | 1 a +-152.84 | vanduo šaltas - V1 2
1406827 | 1 a +-152.84 | vanduo šaltas - V1 2
1406897 | 1 a +-152.84 | vanduo šaltas - V1 2
1406932 | 1 a +-152.84 | vanduo šaltas - V1 2
1406936 | 1 a +-152.84 | vanduo šaltas - V1 2
1407007 | 1 a +-152.84 | vanduo šaltas - V1 2
1407011 | 1 a +-152.84 | vanduo šaltas - V1 2
1407087 | 1 a +-152.84 | vanduo šaltas - V1 2
1407091 | 1 a +-152.84 | vanduo šaltas - V1 2
1407163 | 1 a +-152.84 | vanduo šaltas - V1 2
1407217 | 1 a +-152.84 | vanduo šaltas - V1 2
1407221 | 1 a +-152.84 | vanduo šaltas - V1 2
1407257 | 1 a +-152.84 | vanduo šaltas - V1 2
1407288 | 1 a +-152.84 | vanduo šaltas - V1 2
1407292 | 1 a +-152.84 | vanduo šaltas - V1 2
1407346 | 1 a +-152.84 | vanduo šaltas - V1 2
1407358 | 1 a +-152.84 | vanduo šaltas - V1 2
1407366 | 1 a +-152.84 | vanduo šaltas - V1 2
1407410 | 1 a +-152.84 | vanduo šaltas - V1 2
1407414 | 1 a +-152.84 | vanduo šaltas - V1 2
1407452 | 1 a +-152.84 | vanduo šaltas - V1 2
1407512 | 1 a +-152.84 | vanduo šaltas - V1 2
1407516 | 1 a +-152.84 | vanduo šaltas - V1 2
1407592 | 1 a +-152.84 | vanduo šaltas - V1 2
1407604 | 1 a +-152.84 | vanduo šaltas - V1 2
1407640 | 1 a +-152.84 | vanduo šaltas - V1 2
1407644 | 1 a +-152.84 | vanduo šaltas - V1 2
1407733 | 1 a +-152.84 | vanduo šaltas - V1 2
1407737 | 1 a +-152.84 | vanduo šaltas - V1 2
1407796 | 1 a +-152.84 | vanduo šaltas - V1 2
1407800 | 1 a +-152.84 | vanduo šaltas - V1 2
1408104 | 1 a +-152.84 | vanduo šaltas - V1 2
1408108 | 1 a +-152.84 | vanduo šaltas - V1 2
1408170 | 1 a +-152.84 | vanduo šaltas - V1 2
1408174 | 1 a +-152.84 | vanduo šaltas - V1 2
1408262 | 1 a +-152.84 | vanduo šaltas - V1 2
1408274 | 1 a +-152.84 | vanduo šaltas - V1 2
1408316 | 1 a +-152.84 | vanduo šaltas - V1 2
1408320 | 1 a +-152.84 | vanduo šaltas - V1 2
1408380 | 1 a +-152.84 | vanduo šaltas - V1 2
1408400 | 1 a +-152.84 | vanduo šaltas - V1 2
1408435 | 1 a +-152.84 | vanduo šaltas - V1 2
1408439 | 1 a +-152.84 | vanduo šaltas - V1 2
1408498 | 1 a +-152.84 | vanduo šaltas - V1 2
1408502 | 1 a +-152.84 | vanduo šaltas - V1 2
1408561 | 1 a +-152.84 | vanduo šaltas - V1 2
1408565 | 1 a +-152.84 | vanduo šaltas - V1 2
1408599 | 1 a +-152.84 | vanduo šaltas - V1 2
1408644 | 1 a +-152.84 | vanduo šaltas - V1 2
1408648 | 1 a +-152.84 | vanduo šaltas - V1 2
1409181 | 1 a +-152.84 | vanduo šaltas - V1 2
1409185 | 1 a +-152.84 | vanduo šaltas - V1 2
1409197 | 1 a +-152.84 | vanduo šaltas - V1 2
1409229 | 1 a +-152.84 | vanduo šaltas - V1 2
1409233 | 1 a +-152.84 | vanduo šaltas - V1 2
1409308 | 1 a +-152.84 | vanduo šaltas - V1 2
1409312 | 1 a +-152.84 | vanduo šaltas - V1 2
1419947 | 0 a | vanduo šaltas - V1 6
1420210 | 0 a | vanduo šaltas - V1 6
1420349 | 0 a | vanduo šaltas - V1 6
1420485 | 0 a | vanduo šaltas - V1 2
1420496 | 0 a | vanduo šaltas - V1 2
1420561 | 0 a | vanduo šaltas - V1 2
1420565 | 0 a | vanduo šaltas - V1 2
1420661 | 0 a | vanduo šaltas - V1 2
1420671 | 0 a | vanduo šaltas - V1 2
1420745 | 0 a | vanduo šaltas - V1 2
1420750 | 0 a | vanduo šaltas - V1 2
1420900 | 0 a | vanduo šaltas - V1 2
1420902 | 0 a | vanduo šaltas - V1 2
1421021 | 0 a | vanduo šaltas - V1 2
1421023 | 0 a | vanduo šaltas - V1 2
1421115 | 0 a | vanduo šaltas - V1 2
1421117 | 0 a | vanduo šaltas - V1 2
1421160 | 0 a | vanduo šaltas - V1 2
1421222 | 0 a | vanduo šaltas - V1 2
1421226 | 0 a | vanduo šaltas - V1 2
1421333 | 0 a | vanduo šaltas - V1 2
1421335 | 0 a | vanduo šaltas - V1 2
1421374 | 0 a | vanduo šaltas - V1 2
1421462 | 0 a | vanduo šaltas - V1 2
1421466 | 0 a | vanduo šaltas - V1 2
1421509 | 0 a | vanduo šaltas - V1 2
1421601 | 0 a | vanduo šaltas - V1 2
1421603 | 0 a | vanduo šaltas - V1 2
1421795 | 0 a | vanduo šaltas - V1 2
1421799 | 0 a | vanduo šaltas - V1 2
1421904 | 0 a | vanduo šaltas - V1 2
1421908 | 0 a | vanduo šaltas - V1 2
1422013 | 0 a | vanduo šaltas - V1 2
1422017 | 0 a | vanduo šaltas - V1 2
1422135 | 0 a | vanduo šaltas - V1 2
1422139 | 0 a | vanduo šaltas - V1 2
1422187 | 0 a | vanduo šaltas - V1 2
1422243 | 0 a | vanduo šaltas - V1 2
1422247 | 0 a | vanduo šaltas - V1 2
1422351 | 0 a | vanduo šaltas - V1 2
1422355 | 0 a | vanduo šaltas - V1 2
1422409 | 0 a | vanduo šaltas - V1 2
1422467 | 0 a | vanduo šaltas - V1 2
1422469 | 0 a | vanduo šaltas - V1 2
1422621 | 0 a | vanduo šaltas - V1 2
1422699 | 0 a | vanduo šaltas - V1 2
1422703 | 0 a | vanduo šaltas - V1 2
1422751 | 0 a | vanduo šaltas - V1 2
1422809 | 0 a | vanduo šaltas - V1 2
1422811 | 0 a | vanduo šaltas - V1 2
1422867 | 0 a | vanduo šaltas - V1 2
1422947 | 0 a | vanduo šaltas - V1 2
1422951 | 0 a | vanduo šaltas - V1 2
1423021 | 0 a | vanduo šaltas - V1 2
1423071 | 0 a | vanduo šaltas - V1 2
1423075 | 0 a | vanduo šaltas - V1 2
1423222 | 0 a | vanduo šaltas - V1 2
1423232 | 0 a | vanduo šaltas - V1 2
1423305 | 0 a | vanduo šaltas - V1 2
1423307 | 0 a | vanduo šaltas - V1 2
1423406 | 0 a | vanduo šaltas - V1 2
1423469 | 0 a | vanduo šaltas - V1 2
1423473 | 0 a | vanduo šaltas - V1 2
1423549 | 0 a | vanduo šaltas - V1 2
1423612 | 0 a | vanduo šaltas - V1 2
1423614 | 0 a | vanduo šaltas - V1 2
1423695 | 0 a | vanduo šaltas - V1 2
1423838 | 0 a | vanduo šaltas - V1 2
1423846 | 0 a | vanduo šaltas - V1 2
1424243 | 0 a | vanduo šaltas - V1 2
1424251 | 0 a | vanduo šaltas - V1 2
1424261 | 0 a | vanduo šaltas - V1 2
1424315 | 0 a | vanduo šaltas - V1 2
1424323 | 0 a | vanduo šaltas - V1 2
1424369 | 0 a | vanduo šaltas - V1 2
1424379 | 0 a | vanduo šaltas - V1 2
1424387 | 0 a | vanduo šaltas - V1 2
1424423 | 0 a | vanduo šaltas - V1 2
1424518 | 0 a | vanduo šaltas - V1 2
1424562 | 0 a | vanduo šaltas - V1 2
1424601 | 0 a | vanduo šaltas - V1 2
1424694 | 0 a | vanduo šaltas - V1 2
1424735 | 0 a | vanduo šaltas - V1 2
1424769 | 1 a +-152.84 | vanduo šaltas - V1 2
1424781 | 1 a +-152.84 | vanduo šaltas - V1 2
1424789 | 1 a +-152.84 | vanduo šaltas - V1 2
1424877 | 1 a +-152.84 | vanduo šaltas - V1 2
1424931 | 1 a +-152.84 | vanduo šaltas - V1 2
1425109 | 1 a +-152.84 | vanduo šaltas - V1 2
1425323 | 1 a +-152.84 | vanduo šaltas - V1 2
1425525 | 1 a +-152.84 | vanduo šaltas - V1 2
1425569 | 1 a +-152.84 | vanduo šaltas - V1 2
1425606 | 1 a +-152.84 | vanduo šaltas - V1 2
1427031 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 2
1427039 | 0 a | vanduo karštas tiekiamasis - T3 2
1427995 | 0 a | vanduo karštas tiekiamasis - T3 3
1428034 | 0 a | vanduo karštas tiekiamasis - T3 3
1428038 | 0 a | vanduo karštas tiekiamasis - T3 3
1428148 | 0 a | vanduo karštas tiekiamasis - T3 3
1428152 | 0 a | vanduo karštas tiekiamasis - T3 3
1428769 | 0 a | vanduo karštas tiekiamasis - T3 1
1428773 | 0 a | vanduo karštas tiekiamasis - T3 1
1428823 | 0 a | vanduo karštas tiekiamasis - T3 1
1428906 | 0 a | vanduo karštas tiekiamasis - T3 1
1428910 | 0 a | vanduo karštas tiekiamasis - T3 1
1428974 | 0 a | vanduo karštas tiekiamasis - T3 1
1429050 | 0 a | vanduo karštas tiekiamasis - T3 1
1429054 | 0 a | vanduo karštas tiekiamasis - T3 1
1429268 | 0 a | vanduo karštas tiekiamasis - T3 1
1429334 | 0 a | vanduo karštas tiekiamasis - T3 1
1429338 | 0 a | vanduo karštas tiekiamasis - T3 1
1429444 | 0 a | vanduo karštas tiekiamasis - T3 1
1429448 | 0 a | vanduo karštas tiekiamasis - T3 1
1429557 | 0 a | vanduo karštas tiekiamasis - T3 1
1429561 | 0 a | vanduo karštas tiekiamasis - T3 1
1429667 | 0 a | vanduo karštas tiekiamasis - T3 1
1429701 | 0 a | vanduo karštas tiekiamasis - T3 1
1429713 | 0 a | vanduo karštas tiekiamasis - T3 1
1429811 | 0 a | vanduo karštas tiekiamasis - T3 1
1429815 | 0 a | vanduo karštas tiekiamasis - T3 1
1429865 | 0 a | vanduo karštas tiekiamasis - T3 1
1429942 | 0 a | vanduo karštas tiekiamasis - T3 1
1429946 | 0 a | vanduo karštas tiekiamasis - T3 1
1430071 | 0 a | vanduo karštas tiekiamasis - T3 1
1430075 | 0 a | vanduo karštas tiekiamasis - T3 1
1430129 | 0 a | vanduo karštas tiekiamasis - T3 1
1430137 | 0 a | vanduo karštas tiekiamasis - T3 1
1430236 | 0 a | vanduo karštas tiekiamasis - T3 1
1430240 | 0 a | vanduo karštas tiekiamasis - T3 1
1430592 | 0 a | vanduo karštas tiekiamasis - T3 1
1430644 | 0 a | vanduo karštas tiekiamasis - T3 1
1430648 | 0 a | vanduo karštas tiekiamasis - T3 1
1430706 | 0 a | vanduo karštas tiekiamasis - T3 1
1430717 | 0 a | vanduo karštas tiekiamasis - T3 1
1430770 | 0 a | vanduo karštas tiekiamasis - T3 1
1430774 | 0 a | vanduo karštas tiekiamasis - T3 1
1431087 | 0 a | vanduo karštas tiekiamasis - T3 1
1431091 | 0 a | vanduo karštas tiekiamasis - T3 1
1431243 | 0 a | vanduo karštas tiekiamasis - T3 1
1431354 | 0 a | vanduo karštas tiekiamasis - T3 1
1431358 | 0 a | vanduo karštas tiekiamasis - T3 1
1431396 | 0 a | vanduo karštas tiekiamasis - T3 1
1431467 | 0 a | vanduo karštas tiekiamasis - T3 1
1431469 | 0 a | vanduo karštas tiekiamasis - T3 1
1431676 | 0 a | vanduo karštas tiekiamasis - T3 4
1431731 | 0 a | vanduo karštas tiekiamasis - T3 4
1431735 | 0 a | vanduo karštas tiekiamasis - T3 4
1433004 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433192 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433342 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433579 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433626 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433634 | 0 a | vanduo karštas apytakinis - T4 1
1434237 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434312 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434316 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434391 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434395 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434438 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434448 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434491 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434495 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434579 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434583 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434669 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434673 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434734 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434795 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434799 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434904 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434908 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434956 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434964 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434977 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435019 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435023 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435103 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435107 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435165 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435262 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435266 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435530 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435534 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435655 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435659 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435724 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435772 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435833 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435837 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435918 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435922 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435992 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435996 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436099 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436103 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436361 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1436616 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436624 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436676 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436680 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436747 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436751 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436828 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436832 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437027 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437070 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437121 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437125 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437193 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437197 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437320 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437324 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437421 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437425 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437544 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437554 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437639 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437643 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437753 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437757 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437954 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437958 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438010 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438077 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438081 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438164 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438168 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438291 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438295 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438355 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438363 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438479 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438483 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438579 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438583 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438625 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438636 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438711 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438715 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438827 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438831 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438881 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1438967 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438980 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438988 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439000 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439008 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439085 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439089 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439184 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439194 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439259 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439263 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439347 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439351 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439399 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439491 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439495 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439537 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439586 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439588 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439625 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439688 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439692 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439752 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439764 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439823 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439827 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439901 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439905 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439974 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439978 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1440049 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1440057 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1440162 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1440508 | 2 a | vanduo karštas tiekiamasis - T3 1
1440518 | 2 a | vanduo karštas tiekiamasis - T3 1
1440588 | 2 a | vanduo karštas tiekiamasis - T3 1
1440594 | 2 a | vanduo karštas tiekiamasis - T3 1
1440783 | 2 a | vanduo karštas tiekiamasis - T3 1
1440848 | 2 a | vanduo karštas tiekiamasis - T3 1
1440854 | 2 a | vanduo karštas tiekiamasis - T3 1
1440947 | 2 a | vanduo karštas tiekiamasis - T3 1
1440955 | 2 a | vanduo karštas tiekiamasis - T3 1
1440965 | 2 a | vanduo karštas tiekiamasis - T3 1
1441045 | 2 a | vanduo karštas tiekiamasis - T3 1
1441051 | 2 a | vanduo karštas tiekiamasis - T3 1
1441115 | 2 a | vanduo karštas tiekiamasis - T3 1
1441226 | 2 a | vanduo karštas tiekiamasis - T3 1
1441228 | 2 a | vanduo karštas tiekiamasis - T3 1
1441269 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1441336 | 2 a | vanduo karštas tiekiamasis - T3 1
1441348 | 2 a | vanduo karštas tiekiamasis - T3 1
1441358 | 2 a | vanduo karštas tiekiamasis - T3 1
1441452 | 2 a | vanduo karštas tiekiamasis - T3 1
1441456 | 2 a | vanduo karštas tiekiamasis - T3 1
1441538 | 2 a | vanduo karštas tiekiamasis - T3 1
1441548 | 2 a | vanduo karštas tiekiamasis - T3 1
1441558 | 2 a | vanduo karštas tiekiamasis - T3 1
1441604 | 2 a | vanduo karštas tiekiamasis - T3 1
1441608 | 2 a | vanduo karštas tiekiamasis - T3 1
1441647 | 2 a | vanduo karštas tiekiamasis - T3 1
1441686 | 2 a | vanduo karštas tiekiamasis - T3 1
1441690 | 2 a | vanduo karštas tiekiamasis - T3 1
1441763 | 2 a | vanduo karštas tiekiamasis - T3 1
1441767 | 2 a | vanduo karštas tiekiamasis - T3 1
1441855 | 2 a | vanduo karštas tiekiamasis - T3 1
1441859 | 2 a | vanduo karštas tiekiamasis - T3 1
1441936 | 2 a | vanduo karštas tiekiamasis - T3 1
1441938 | 2 a | vanduo karštas tiekiamasis - T3 1
1442112 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1442266 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1442278 | 2 a | vanduo karštas tiekiamasis - T3 1
1442290 | 2 a | vanduo karštas tiekiamasis - T3 1
1442306 | 2 a | vanduo karštas tiekiamasis - T3 1
1442314 | 2 a | vanduo karštas tiekiamasis - T3 1
1442365 | 2 a | vanduo karštas tiekiamasis - T3 1
1442369 | 2 a | vanduo karštas tiekiamasis - T3 1
1442498 | 2 a | vanduo karštas tiekiamasis - T3 1
1442504 | 2 a | vanduo karštas tiekiamasis - T3 1
1442538 | 2 a | vanduo karštas tiekiamasis - T3 1
1442550 | 2 a | vanduo karštas tiekiamasis - T3 1
1442560 | 2 a | vanduo karštas tiekiamasis - T3 1
1442587 | 2 a | vanduo karštas tiekiamasis - T3 1
1442595 | 2 a | vanduo karštas tiekiamasis - T3 1
1442627 | 2 a | vanduo karštas tiekiamasis - T3 1
1442769 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1442779 | 2 a | vanduo karštas apytakinis - T4 1
1442850 | 2 a | vanduo karštas tiekiamasis - T3 1
1442913 | 2 a | vanduo karštas tiekiamasis - T3 1
1442917 | 2 a | vanduo karštas tiekiamasis - T3 1
1442959 | 2 a | vanduo karštas tiekiamasis - T3 1
1443033 | 2 a | vanduo karštas tiekiamasis - T3 1
1443037 | 2 a | vanduo karštas tiekiamasis - T3 1
1443171 | 2 a | vanduo karštas tiekiamasis - T3 1
1443175 | 2 a | vanduo karštas tiekiamasis - T3 1
1443349 | 2 a | vanduo karštas tiekiamasis - T3 1
1443381 | 2 a | vanduo karštas tiekiamasis - T3 1
1443385 | 2 a | vanduo karštas tiekiamasis - T3 1
1443482 | 2 a | vanduo karštas tiekiamasis - T3 1
1443502 | 2 a | vanduo karštas tiekiamasis - T3 1
1443512 | 2 a | vanduo karštas tiekiamasis - T3 1
1443533 | 2 a | vanduo karštas tiekiamasis - T3 1
1443547 | 2 a | vanduo karštas tiekiamasis - T3 1
1443592 | 2 a | vanduo karštas tiekiamasis - T3 1
1443596 | 2 a | vanduo karštas tiekiamasis - T3 1
1443697 | 2 a | vanduo karštas tiekiamasis - T3 1
1443701 | 2 a | vanduo karštas tiekiamasis - T3 1
1443818 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1443911 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1443933 | 2 a | vanduo karštas tiekiamasis - T3 1
1443941 | 2 a | vanduo karštas tiekiamasis - T3 1
1443951 | 2 a | vanduo karštas tiekiamasis - T3 1
1443959 | 2 a | vanduo karštas tiekiamasis - T3 1
1443973 | 2 a | vanduo karštas tiekiamasis - T3 1
1443997 | 2 a | vanduo karštas tiekiamasis - T3 1
1444042 | 2 a | vanduo karštas tiekiamasis - T3 1
1444046 | 2 a | vanduo karštas tiekiamasis - T3 1
1444082 | 2 a | vanduo karštas tiekiamasis - T3 1
1444095 | 2 a | vanduo karštas tiekiamasis - T3 1
1444122 | 2 a | vanduo karštas tiekiamasis - T3 1
1444135 | 2 a | vanduo karštas tiekiamasis - T3 1
1444146 | 2 a | vanduo karštas tiekiamasis - T3 1
1444192 | 2 a | vanduo karštas tiekiamasis - T3 1
1444196 | 2 a | vanduo karštas tiekiamasis - T3 1
1444243 | 2 a | vanduo karštas tiekiamasis - T3 1
1444280 | 2 a | vanduo karštas tiekiamasis - T3 1
1444282 | 2 a | vanduo karštas tiekiamasis - T3 1
1444365 | 2 a | vanduo karštas tiekiamasis - T3 1
1444369 | 2 a | vanduo karštas tiekiamasis - T3 1
1444403 | 2 a | vanduo karštas tiekiamasis - T3 1
1444435 | 2 a | vanduo karštas tiekiamasis - T3 1
1444437 | 2 a | vanduo karštas tiekiamasis - T3 1
1444506 | 2 a | vanduo karštas tiekiamasis - T3 1
1444514 | 2 a | vanduo karštas tiekiamasis - T3 1
1444524 | 2 a | vanduo karštas tiekiamasis - T3 1
1444566 | 2 a | vanduo karštas tiekiamasis - T3 1
1444570 | 2 a | vanduo karštas tiekiamasis - T3 1
1444612 | 2 a | vanduo karštas tiekiamasis - T3 1
1444622 | 2 a | vanduo karštas tiekiamasis - T3 1
1444696 | 2 a | vanduo karštas tiekiamasis - T3 1
1444700 | 2 a | vanduo karštas tiekiamasis - T3 1
1444775 | 2 a | vanduo šaltas - V1 2
1444777 | 2 a | vanduo šaltas - V1 2
1444905 | 2 a | vanduo karštas tiekiamasis - T3 1
1444947 | 2 a | vanduo karštas tiekiamasis - T3 1
1444951 | 2 a | vanduo karštas tiekiamasis - T3 1
1445632 | 2 a | vanduo karštas tiekiamasis - T3 7
1445686 | 2 a | vanduo karštas tiekiamasis - T3 7
1445702 | 2 a | vanduo karštas tiekiamasis - T3 7
1445754 | 2 a | vanduo karštas tiekiamasis - T3 7
1445758 | 2 a | vanduo karštas tiekiamasis - T3 7
1445812 | 2 a | vanduo karštas tiekiamasis - T3 7
1445862 | 2 a | vanduo karštas tiekiamasis - T3 7
1445866 | 2 a | vanduo karštas tiekiamasis - T3 7
1445945 | 2 a | vanduo karštas tiekiamasis - T3 7
1445949 | 2 a | vanduo karštas tiekiamasis - T3 7
1445997 | 2 a | vanduo karštas tiekiamasis - T3 7
1446044 | 2 a | vanduo karštas tiekiamasis - T3 7
1446048 | 2 a | vanduo karštas tiekiamasis - T3 7
1446093 | 2 a | vanduo karštas tiekiamasis - T3 7
1446103 | 2 a | vanduo karštas tiekiamasis - T3 7
1446190 | 2 a | vanduo karštas tiekiamasis - T3 7
1446194 | 2 a | vanduo karštas tiekiamasis - T3 7
1446231 | 2 a | vanduo karštas tiekiamasis - T3 7
1446241 | 2 a | vanduo karštas tiekiamasis - T3 7
1446249 | 2 a | vanduo karštas tiekiamasis - T3 7
1446297 | 2 a | vanduo karštas tiekiamasis - T3 7
1446299 | 2 a | vanduo karštas tiekiamasis - T3 7
1446377 | 2 a | vanduo karštas tiekiamasis - T3 7
1446449 | 2 a | vanduo karštas tiekiamasis - T3 7
1446453 | 2 a | vanduo karštas tiekiamasis - T3 7
1446542 | 2 a | vanduo karštas tiekiamasis - T3 7
1446546 | 2 a | vanduo karštas tiekiamasis - T3 7
1446584 | 2 a | vanduo karštas tiekiamasis - T3 1
1446615 | 2 a | vanduo karštas tiekiamasis - T3 1
1446623 | 2 a | vanduo karštas tiekiamasis - T3 1
1446654 | 2 a | vanduo karštas tiekiamasis - T3 1
1446956 | 2 a | vanduo karštas tiekiamasis - T3 1
1446960 | 2 a | vanduo karštas tiekiamasis - T3 1
1447010 | 2 a | vanduo karštas tiekiamasis - T3 1
1447061 | 2 a | vanduo karštas tiekiamasis - T3 1
1447065 | 2 a | vanduo karštas tiekiamasis - T3 1
1447119 | 2 a | vanduo karštas tiekiamasis - T3 1
1447201 | 2 a | vanduo karštas tiekiamasis - T3 1
1447278 | 2 a | vanduo karštas tiekiamasis - T3 1
1447284 | 2 a | vanduo karštas tiekiamasis - T3 1
1447359 | 2 a | vanduo karštas tiekiamasis - T3 1
1447365 | 2 a | vanduo karštas tiekiamasis - T3 1
1447459 | 2 a | vanduo karštas tiekiamasis - T3 1
1447463 | 2 a | vanduo karštas tiekiamasis - T3 1
1447510 | 2 a | vanduo šaltas - V1 2
1447520 | 2 a | vanduo šaltas - V1 2
1447568 | 2 a | vanduo šaltas - V1 2
1447572 | 2 a | vanduo šaltas - V1 2
1447610 | 2 a | vanduo karštas tiekiamasis - T3 1
1447689 | 2 a | vanduo karštas tiekiamasis - T3 8
1447693 | 2 a | vanduo karštas tiekiamasis - T3 8
1447736 | 2 a | vanduo karštas tiekiamasis - T3 8
1447753 | 2 a | vanduo karštas tiekiamasis - T3 1
1447926 | 2 a | vanduo karštas tiekiamasis - T3 10
1447969 | 2 a | vanduo karštas tiekiamasis - T3 10
1447971 | 2 a | vanduo karštas tiekiamasis - T3 10
1448168 | 2 a | vanduo karštas tiekiamasis - T3 1
1448230 | 2 a | vanduo karštas tiekiamasis - T3 1
1448236 | 2 a | vanduo karštas tiekiamasis - T3 1
1448291 | 2 a | vanduo karštas apytakinis - T4 1
1448340 | 2 a | vanduo karštas apytakinis - T4 1
1448342 | 2 a | vanduo karštas apytakinis - T4 1
1448963 | 2 a | vanduo karštas tiekiamasis - T3 1
1448973 | 2 a | vanduo karštas tiekiamasis - T3 1
1448981 | 2 a | vanduo karštas tiekiamasis - T3 1
1449025 | 2 a | vanduo karštas tiekiamasis - T3 1
1449029 | 2 a | vanduo karštas tiekiamasis - T3 1
1449080 | 2 a | vanduo karštas tiekiamasis - T3 1
1449110 | 2 a | vanduo karštas tiekiamasis - T3 1
1449112 | 2 a | vanduo karštas tiekiamasis - T3 1
1449245 | 2 a | vanduo karštas tiekiamasis - T3 1
1449249 | 2 a | vanduo karštas tiekiamasis - T3 1
1449295 | 2 a | vanduo karštas tiekiamasis - T3 1
1449336 | 2 a | vanduo karštas tiekiamasis - T3 1
1449340 | 2 a | vanduo karštas tiekiamasis - T3 1
1449386 | 2 a | vanduo karštas tiekiamasis - T3 1
1449434 | 2 a | vanduo karštas tiekiamasis - T3 1
1449440 | 2 a | vanduo karštas tiekiamasis - T3 1
1449839 | 2 a | vanduo karštas apytakinis - T4 1
1449873 | 2 a | vanduo karštas apytakinis - T4 1
1449877 | 2 a | vanduo karštas apytakinis - T4 2
1450226 | 2 a | vanduo karštas tiekiamasis - T3 1
1450274 | 2 a | vanduo karštas tiekiamasis - T3 1
1450302 | 2 a | vanduo karštas tiekiamasis - T3 1
1450345 | 2 a | vanduo karštas tiekiamasis - T3 1
1450347 | 2 a | vanduo karštas tiekiamasis - T3 1
1450385 | 2 a | vanduo karštas tiekiamasis - T3 1
1450483 | 2 a | vanduo karštas tiekiamasis - T3 1
1450487 | 2 a | vanduo karštas tiekiamasis - T3 1
1450521 | 2 a | vanduo karštas tiekiamasis - T3 1
1450531 | 2 a | vanduo karštas tiekiamasis - T3 1
1450539 | 2 a | vanduo karštas tiekiamasis - T3 1
1450621 | 2 a | vanduo karštas tiekiamasis - T3 1
1450625 | 2 a | vanduo karštas tiekiamasis - T3 1
1450667 | 2 a | vanduo karštas tiekiamasis - T3 1
1450675 | 2 a | vanduo karštas tiekiamasis - T3 1
1450714 | 2 a | vanduo karštas tiekiamasis - T3 1
1450718 | 2 a | vanduo karštas tiekiamasis - T3 1
1450789 | 2 a | vanduo karštas tiekiamasis - T3 1
1450793 | 2 a | vanduo karštas tiekiamasis - T3 1
1450926 | 2 a | vanduo karštas tiekiamasis - T3 1
1450980 | 2 a | vanduo karštas tiekiamasis - T3 1
1450984 | 2 a | vanduo karštas tiekiamasis - T3 1
1451046 | 2 a | vanduo karštas tiekiamasis - T3 1
1451050 | 2 a | vanduo karštas tiekiamasis - T3 1
1451086 | 2 a | vanduo karštas tiekiamasis - T3 1
1451096 | 2 a | vanduo karštas tiekiamasis - T3 1
1451129 | 2 a | vanduo karštas tiekiamasis - T3 1
1451133 | 2 a | vanduo karštas tiekiamasis - T3 1
1451383 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1451423 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1451431 | 2 a | vanduo karštas tiekiamasis - T3 1
1451441 | 2 a | vanduo karštas tiekiamasis - T3 1
1451467 | 2 a | vanduo karštas tiekiamasis - T3 1
1451477 | 2 a | vanduo karštas tiekiamasis - T3 1
1451485 | 2 a | vanduo karštas tiekiamasis - T3 1
1451499 | 2 a | vanduo karštas tiekiamasis - T3 1
1451624 | 2 a | vanduo karštas tiekiamasis - T3 1
1451761 | 2 a | vanduo karštas tiekiamasis - T3 1
1451955 | 2 a | vanduo karštas tiekiamasis - T3 1
1452147 | 2 a | vanduo karštas tiekiamasis - T3 1
1452157 | 2 a | vanduo karštas tiekiamasis - T3 1
1452182 | 2 a | vanduo karštas tiekiamasis - T3 1
1452245 | 2 a | vanduo karštas tiekiamasis - T3 1
1452279 | 2 a | vanduo karštas tiekiamasis - T3 1
1452358 | 2 a | vanduo karštas tiekiamasis - T3 1
1452368 | 2 a | vanduo karštas tiekiamasis - T3 1
1452406 | 2 a | vanduo karštas tiekiamasis - T3 1
1452410 | 2 a | vanduo karštas tiekiamasis - T3 1
1452508 | 2 a | vanduo karštas tiekiamasis - T3 1
1452512 | 2 a | vanduo karštas tiekiamasis - T3 1
1452576 | 2 a | vanduo karštas tiekiamasis - T3 1
1452580 | 2 a | vanduo karštas tiekiamasis - T3 1
1452659 | 2 a | vanduo karštas tiekiamasis - T3 1
1452661 | 2 a | vanduo karštas tiekiamasis - T3 1
1452721 | 2 a | vanduo karštas tiekiamasis - T3 1
1452723 | 2 a | vanduo karštas tiekiamasis - T3 1
1452769 | 2 a | vanduo karštas tiekiamasis - T3 1
1452815 | 2 a | vanduo karštas tiekiamasis - T3 1
1452819 | 2 a | vanduo karštas tiekiamasis - T3 1
1452974 | 2 a | vanduo karštas apytakinis - T4 1
1453158 | 2 a | vanduo karštas apytakinis - T4 1
1453176 | 2 a | vanduo karštas apytakinis - T4 1
1453184 | 2 a | vanduo karštas apytakinis - T4 1
1453194 | 2 a | vanduo karštas apytakinis - T4 1
1453202 | 2 a | vanduo karštas apytakinis - T4 1
1453220 | 2 a | vanduo karštas apytakinis - T4 1
1453228 | 2 a | vanduo karštas apytakinis - T4 1
1453305 | 2 a | vanduo karštas apytakinis - T4 1
1453348 | 2 a | vanduo karštas apytakinis - T4 1
1453371 | 2 a | vanduo karštas apytakinis - T4 1
1453375 | 2 a | vanduo karštas apytakinis - T4 1
1453470 | 2 a | vanduo karštas tiekiamasis - T3 1
1453474 | 2 a | vanduo karštas tiekiamasis - T3 1
1453618 | 2 a | vanduo karštas tiekiamasis - T3 1
1453622 | 2 a | vanduo karštas tiekiamasis - T3 1
1453719 | 2 a | vanduo karštas tiekiamasis - T3 1
1453765 | 2 a | vanduo karštas tiekiamasis - T3 1
1453769 | 2 a | vanduo karštas tiekiamasis - T3 1
1453859 | 2 a | vanduo karštas tiekiamasis - T3 1
1453863 | 2 a | vanduo karštas tiekiamasis - T3 1
1453937 | 2 a | vanduo karštas tiekiamasis - T3 1
1453941 | 2 a | vanduo karštas tiekiamasis - T3 1
1454024 | 2 a | vanduo karštas tiekiamasis - T3 1
1454028 | 2 a | vanduo karštas tiekiamasis - T3 1
1454103 | 2 a | vanduo karštas tiekiamasis - T3 1
1454107 | 2 a | vanduo karštas tiekiamasis - T3 1
1454156 | 2 a | vanduo karštas tiekiamasis - T3 1
1454164 | 2 a | vanduo karštas tiekiamasis - T3 1
1454208 | 2 a | vanduo karštas tiekiamasis - T3 1
1454212 | 2 a | vanduo karštas tiekiamasis - T3 1
1454280 | 2 a | vanduo karštas tiekiamasis - T3 1
1454284 | 2 a | vanduo karštas tiekiamasis - T3 1
1454356 | 2 a | vanduo karštas tiekiamasis - T3 1
1454360 | 2 a | vanduo karštas tiekiamasis - T3 1
1454430 | 2 a | vanduo karštas tiekiamasis - T3 1
1454434 | 2 a | vanduo karštas tiekiamasis - T3 1
1454529 | 2 a | vanduo karštas tiekiamasis - T3 1
1454580 | 2 a | vanduo karštas tiekiamasis - T3 1
1454582 | 2 a | vanduo karštas tiekiamasis - T3 1
1454664 | 2 a | vanduo karštas tiekiamasis - T3 1
1454668 | 2 a | vanduo karštas tiekiamasis - T3 1
1454705 | 2 a | vanduo karštas tiekiamasis - T3 1
1454715 | 2 a | vanduo karštas tiekiamasis - T3 1
1454760 | 2 a | vanduo karštas tiekiamasis - T3 1
1454764 | 2 a | vanduo karštas tiekiamasis - T3 1
1454867 | 2 a | vanduo karštas tiekiamasis - T3 1
1454881 | 2 a | vanduo karštas tiekiamasis - T3 1
1454898 | 2 a | vanduo karštas tiekiamasis - T3 1
1454966 | 2 a | vanduo karštas tiekiamasis - T3 1
1454970 | 2 a | vanduo karštas tiekiamasis - T3 1
1455037 | 2 a | vanduo karštas tiekiamasis - T3 1
1455041 | 2 a | vanduo karštas tiekiamasis - T3 1
1455098 | 2 a | vanduo karštas tiekiamasis - T3 1
1455100 | 2 a | vanduo karštas tiekiamasis - T3 1
1455136 | 2 a | vanduo karštas tiekiamasis - T3 1
1455193 | 2 a | vanduo karštas tiekiamasis - T3 1
1455197 | 2 a | vanduo karštas tiekiamasis - T3 1
1455257 | 2 a | vanduo karštas tiekiamasis - T3 1
1455261 | 2 a | vanduo karštas tiekiamasis - T3 1
1455324 | 2 a | vanduo karštas tiekiamasis - T3 1
1455328 | 2 a | vanduo karštas tiekiamasis - T3 1
1455374 | 2 a | vanduo karštas tiekiamasis - T3 1
1455382 | 2 a | vanduo karštas tiekiamasis - T3 1
1455427 | 2 a | vanduo karštas tiekiamasis - T3 1
1455431 | 2 a | vanduo karštas tiekiamasis - T3 1
1455495 | 2 a | vanduo karštas tiekiamasis - T3 1
1455499 | 2 a | vanduo karštas tiekiamasis - T3 1
1455564 | 2 a | vanduo šaltas - V1 2
1455568 | 2 a | vanduo šaltas - V1 2
1455614 | 2 a | vanduo karštas tiekiamasis - T3 1
1455660 | 2 a | vanduo karštas tiekiamasis - T3 1
1455664 | 2 a | vanduo karštas tiekiamasis - T3 1
1455703 | 2 a | vanduo karštas tiekiamasis - T3 1
1455736 | 2 a | vanduo karštas tiekiamasis - T3 1
1455738 | 2 a | vanduo karštas tiekiamasis - T3 1
1455804 | 2 a | vanduo karštas tiekiamasis - T3 1
1455808 | 2 a | vanduo karštas tiekiamasis - T3 1
1455884 | 2 a | vanduo karštas tiekiamasis - T3 1
1455888 | 2 a | vanduo karštas tiekiamasis - T3 1
1455937 | 2 a | vanduo karštas tiekiamasis - T3 1
1455948 | 2 a | vanduo karštas tiekiamasis - T3 1
1456004 | 2 a | vanduo karštas tiekiamasis - T3 1
1456008 | 2 a | vanduo karštas tiekiamasis - T3 1
1456079 | 2 a | vanduo karštas tiekiamasis - T3 1
1456083 | 2 a | vanduo karštas tiekiamasis - T3 1
1456161 | 2 a | vanduo karštas tiekiamasis - T3 1
1456165 | 2 a | vanduo karštas tiekiamasis - T3 1
1456205 | 2 a | vanduo karštas tiekiamasis - T3 1
1456245 | 2 a | vanduo karštas tiekiamasis - T3 1
1456249 | 2 a | vanduo karštas tiekiamasis - T3 1
1456283 | 2 a | vanduo karštas tiekiamasis - T3 1
1456323 | 2 a | vanduo karštas tiekiamasis - T3 1
1456327 | 2 a | vanduo karštas tiekiamasis - T3 1
1456402 | 2 a | vanduo karštas tiekiamasis - T3 1
1456406 | 2 a | vanduo karštas tiekiamasis - T3 1
1456493 | 2 a | vanduo karštas tiekiamasis - T3 1
1456495 | 2 a | vanduo karštas tiekiamasis - T3 1
1456537 | 2 a | vanduo karštas tiekiamasis - T3 1
1456572 | 2 a | vanduo karštas tiekiamasis - T3 1
1456576 | 2 a | vanduo karštas tiekiamasis - T3 1
1456640 | 2 a | vanduo karštas tiekiamasis - T3 1
1456644 | 2 a | vanduo karštas tiekiamasis - T3 1
1456680 | 2 a | vanduo karštas tiekiamasis - T3 1
1456699 | 2 a | vanduo karštas tiekiamasis - T3 1
1456707 | 2 a | vanduo karštas tiekiamasis - T3 1
1456741 | 2 a | vanduo karštas tiekiamasis - T3 1
1456745 | 2 a | vanduo karštas tiekiamasis - T3 1
1456820 | 2 a | vanduo karštas tiekiamasis - T3 1
1456824 | 2 a | vanduo karštas tiekiamasis - T3 1
1456887 | 2 a | vanduo karštas tiekiamasis - T3 1
1456891 | 2 a | vanduo karštas tiekiamasis - T3 1
1456929 | 2 a | vanduo karštas tiekiamasis - T3 1
1456972 | 2 a | vanduo karštas tiekiamasis - T3 1
1456976 | 2 a | vanduo karštas tiekiamasis - T3 1
1457048 | 2 a | vanduo karštas tiekiamasis - T3 1
1457118 | 2 a | vanduo karštas tiekiamasis - T3 1
1457128 | 2 a | vanduo karštas tiekiamasis - T3 1
1457164 | 2 a | vanduo karštas apytakinis - T4 1
1457174 | 2 a | vanduo karštas apytakinis - T4 1
1457213 | 2 a | vanduo karštas tiekiamasis - T3 1
1457279 | 2 a | vanduo karštas tiekiamasis - T3 1
1457283 | 2 a | vanduo karštas tiekiamasis - T3 1
1457321 | 2 a | vanduo karštas tiekiamasis - T3 1
1457372 | 2 a | vanduo karštas tiekiamasis - T3 1
1457376 | 2 a | vanduo karštas tiekiamasis - T3 1
1457414 | 2 a | vanduo karštas tiekiamasis - T3 1
1457422 | 2 a | vanduo karštas tiekiamasis - T3 1
1457435 | 2 a | vanduo karštas tiekiamasis - T3 1
1457443 | 2 a | vanduo karštas tiekiamasis - T3 1
1457483 | 2 a | vanduo karštas tiekiamasis - T3 1
1457487 | 2 a | vanduo karštas tiekiamasis - T3 1
1457523 | 2 a | vanduo karštas tiekiamasis - T3 1
1457564 | 2 a | vanduo karštas tiekiamasis - T3 1
1457568 | 2 a | vanduo karštas tiekiamasis - T3 1
1457642 | 2 a | vanduo karštas tiekiamasis - T3 1
1457646 | 2 a | vanduo karštas tiekiamasis - T3 1
1457706 | 2 a | vanduo šaltas - V1 2
1457712 | 2 a | vanduo šaltas - V1 2
1457763 | 2 a | vanduo karštas tiekiamasis - T3 1
1457813 | 2 a | vanduo karštas tiekiamasis - T3 1
1457817 | 2 a | vanduo karštas tiekiamasis - T3 1
1457898 | 2 a | vanduo karštas tiekiamasis - T3 1
1457902 | 2 a | vanduo karštas tiekiamasis - T3 1
1457977 | 2 a | vanduo karštas tiekiamasis - T3 1
1457981 | 2 a | vanduo karštas tiekiamasis - T3 1
1458035 | 2 a | vanduo karštas tiekiamasis - T3 1
1458039 | 2 a | vanduo karštas tiekiamasis - T3 1
1458115 | 2 a | vanduo šaltas - V1 2
1458125 | 2 a | vanduo šaltas - V1 2
1458188 | 2 a | vanduo šaltas - V1 2
1458192 | 2 a | vanduo šaltas - V1 2
1458258 | 2 a | vanduo karštas tiekiamasis - T3 1
1458272 | 2 a | vanduo karštas tiekiamasis - T3 1
1458282 | 2 a | vanduo karštas tiekiamasis - T3 1
1458346 | 2 a | vanduo karštas tiekiamasis - T3 1
1458350 | 2 a | vanduo karštas tiekiamasis - T3 1
1458396 | 2 a | vanduo karštas tiekiamasis - T3 1
1458435 | 2 a | vanduo karštas tiekiamasis - T3 1
1458437 | 2 a | vanduo karštas tiekiamasis - T3 1
1458511 | 2 a | vanduo karštas tiekiamasis - T3 1
1458515 | 2 a | vanduo karštas tiekiamasis - T3 1
1458585 | 2 a | vanduo karštas tiekiamasis - T3 1
1458587 | 2 a | vanduo karštas tiekiamasis - T3 1
1458664 | 2 a | vanduo karštas tiekiamasis - T3 1
1458668 | 2 a | vanduo karštas tiekiamasis - T3 1
1458784 | 2 a | vanduo karštas tiekiamasis - T3 1
1458788 | 2 a | vanduo karštas tiekiamasis - T3 1
1458850 | 2 a | vanduo karštas tiekiamasis - T3 1
1458864 | 2 a | vanduo karštas tiekiamasis - T3 1
1458874 | 2 a | vanduo karštas tiekiamasis - T3 1
1458894 | 2 a | vanduo karštas tiekiamasis - T3 1
1458910 | 2 a | vanduo karštas tiekiamasis - T3 1
1458955 | 2 a | vanduo karštas tiekiamasis - T3 1
1458959 | 2 a | vanduo karštas tiekiamasis - T3 1
1459023 | 2 a | vanduo karštas tiekiamasis - T3 1
1459025 | 2 a | vanduo karštas tiekiamasis - T3 1
1459092 | 2 a | vanduo karštas tiekiamasis - T3 1
1459125 | 2 a | vanduo karštas tiekiamasis - T3 1
1459127 | 2 a | vanduo karštas tiekiamasis - T3 1
1459221 | 2 a | vanduo karštas tiekiamasis - T3 1
1459270 | 2 a | vanduo karštas tiekiamasis - T3 1
1459274 | 2 a | vanduo karštas tiekiamasis - T3 1
1459318 | 2 a | vanduo šaltas - V1 2
1459359 | 2 a | vanduo šaltas - V1 2
1459361 | 2 a | vanduo šaltas - V1 2
1459415 | 2 a | vanduo karštas tiekiamasis - T3 1
1459453 | 2 a | vanduo karštas tiekiamasis - T3 1
1459455 | 2 a | vanduo karštas tiekiamasis - T3 1
1459501 | 2 a | vanduo karštas tiekiamasis - T3 1
1459559 | 2 a | vanduo karštas tiekiamasis - T3 1
1459563 | 2 a | vanduo karštas tiekiamasis - T3 1
1459621 | 2 a | vanduo karštas tiekiamasis - T3 1
1459625 | 2 a | vanduo karštas tiekiamasis - T3 1
1459673 | 2 a | vanduo karštas tiekiamasis - T3 1
1459729 | 2 a | vanduo karštas tiekiamasis - T3 1
1459731 | 2 a | vanduo karštas tiekiamasis - T3 1
1459773 | 2 a | vanduo karštas tiekiamasis - T3 1
1459808 | 2 a | vanduo karštas tiekiamasis - T3 1
1459844 | 2 a | vanduo karštas tiekiamasis - T3 1
1459846 | 2 a | vanduo karštas tiekiamasis - T3 1
1459881 | 2 a | vanduo karštas tiekiamasis - T3 1
1459933 | 2 a | vanduo karštas tiekiamasis - T3 1
1459997 | 2 a | vanduo karštas tiekiamasis - T3 1
1460001 | 2 a | vanduo karštas tiekiamasis - T3 1
1460059 | 2 a | vanduo karštas tiekiamasis - T3 1
1460118 | 2 a | vanduo karštas tiekiamasis - T3 1
1460122 | 2 a | vanduo karštas tiekiamasis - T3 1
1460178 | 2 a | vanduo karštas tiekiamasis - T3 1
1460182 | 2 a | vanduo karštas tiekiamasis - T3 1
1460250 | 2 a | vanduo karštas tiekiamasis - T3 1
1460252 | 2 a | vanduo karštas tiekiamasis - T3 1
1460294 | 2 a | vanduo karštas tiekiamasis - T3 1
1460316 | 2 a | vanduo karštas tiekiamasis - T3 1
1460338 | 2 a | vanduo karštas tiekiamasis - T3 1
1460356 | 2 a | vanduo karštas tiekiamasis - T3 1
1460370 | 2 a | vanduo karštas tiekiamasis - T3 1
1460410 | 2 a | vanduo karštas tiekiamasis - T3 1
1460414 | 2 a | vanduo karštas tiekiamasis - T3 1
1460494 | 2 a | vanduo karštas tiekiamasis - T3 1
1460498 | 2 a | vanduo karštas tiekiamasis - T3 1
1460545 | 2 a | vanduo karštas tiekiamasis - T3 1
1460585 | 2 a | vanduo karštas tiekiamasis - T3 1
1460589 | 2 a | vanduo karštas tiekiamasis - T3 1
1460666 | 2 a | vanduo karštas tiekiamasis - T3 1
1460670 | 2 a | vanduo karštas tiekiamasis - T3 1
1460735 | 2 a | vanduo karštas tiekiamasis - T3 1
1460741 | 2 a | vanduo karštas tiekiamasis - T3 1
1460811 | 2 a | vanduo karštas tiekiamasis - T3 1
1460817 | 2 a | vanduo karštas tiekiamasis - T3 1
1460924 | 2 a | vanduo karštas tiekiamasis - T3 1
1460930 | 2 a | vanduo karštas tiekiamasis - T3 1
1461062 | 2 a | vanduo karštas tiekiamasis - T3 1
1461100 | 2 a | vanduo karštas tiekiamasis - T3 1
1461158 | 2 a | vanduo karštas tiekiamasis - T3 1
1461164 | 2 a | vanduo karštas tiekiamasis - T3 1
1461220 | 2 a | vanduo karštas tiekiamasis - T3 1
1461234 | 2 a | vanduo karštas tiekiamasis - T3 1
1461272 | 2 a | vanduo karštas tiekiamasis - T3 1
1461276 | 2 a | vanduo karštas tiekiamasis - T3 1
1461319 | 2 a | vanduo karštas tiekiamasis - T3 1
1461334 | 2 a | vanduo karštas tiekiamasis - T3 1
1461382 | 2 a | vanduo karštas tiekiamasis - T3 1
1461386 | 2 a | vanduo karštas tiekiamasis - T3 1
1461426 | 2 a | vanduo karštas tiekiamasis - T3 1
1461453 | 2 a | vanduo karštas tiekiamasis - T3 1
1461457 | 2 a | vanduo karštas tiekiamasis - T3 1
1461495 | 2 a | vanduo karštas tiekiamasis - T3 1
1461536 | 2 a | vanduo karštas tiekiamasis - T3 1
1461540 | 2 a | vanduo karštas tiekiamasis - T3 1
1461582 | 2 a | vanduo karštas tiekiamasis - T3 1
1461612 | 2 a | vanduo karštas tiekiamasis - T3 1
1461643 | 2 a | vanduo karštas tiekiamasis - T3 1
1461649 | 2 a | vanduo karštas tiekiamasis - T3 1
1461712 | 2 a | vanduo karštas tiekiamasis - T3 1
1461716 | 2 a | vanduo karštas tiekiamasis - T3 1
1461849 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1461857 | 2 a | vanduo karštas tiekiamasis - T3 1
1461869 | 2 a | vanduo karštas tiekiamasis - T3 1
1461879 | 2 a | vanduo karštas tiekiamasis - T3 1
1461896 | 2 a | vanduo karštas tiekiamasis - T3 1
1461908 | 2 a | vanduo karštas tiekiamasis - T3 1
1461942 | 2 a | vanduo karštas tiekiamasis - T3 1
1461944 | 2 a | vanduo karštas tiekiamasis - T3 1
1462027 | 2 a | vanduo karštas tiekiamasis - T3 1
1462031 | 2 a | vanduo karštas tiekiamasis - T3 1
1462091 | 2 a | vanduo karštas tiekiamasis - T3 1
1462095 | 2 a | vanduo karštas tiekiamasis - T3 1
1462211 | 2 a | vanduo karštas tiekiamasis - T3 1
1462240 | 2 a | vanduo karštas tiekiamasis - T3 1
1462305 | 2 a | vanduo karštas tiekiamasis - T3 1
1462311 | 2 a | vanduo karštas tiekiamasis - T3 1
1462357 | 2 a | vanduo karštas tiekiamasis - T3 1
1462369 | 2 a | vanduo karštas tiekiamasis - T3 1
1462395 | 2 a | vanduo karštas tiekiamasis - T3 1
1462408 | 2 a | vanduo karštas tiekiamasis - T3 1
1462418 | 2 a | vanduo karštas tiekiamasis - T3 1
1462462 | 2 a | vanduo karštas tiekiamasis - T3 1
1462466 | 2 a | vanduo karštas tiekiamasis - T3 1
1462534 | 2 a | vanduo karštas tiekiamasis - T3 1
1462538 | 2 a | vanduo karštas tiekiamasis - T3 1
1462604 | 2 a | vanduo karštas tiekiamasis - T3 1
1462608 | 2 a | vanduo karštas tiekiamasis - T3 1
1462687 | 2 a | vanduo karštas tiekiamasis - T3 1
1462691 | 2 a | vanduo karštas tiekiamasis - T3 1
1462751 | 2 a | vanduo karštas tiekiamasis - T3 1
1462770 | 2 a | vanduo karštas tiekiamasis - T3 1
1462821 | 2 a | vanduo karštas tiekiamasis - T3 1
1462825 | 2 a | vanduo karštas tiekiamasis - T3 1
1462888 | 2 a | vanduo karštas tiekiamasis - T3 1
1462892 | 2 a | vanduo karštas tiekiamasis - T3 1
1463091 | 2 a | vanduo karštas tiekiamasis - T3 1
1463128 | 2 a | vanduo karštas tiekiamasis - T3 1
1463161 | 2 a | vanduo karštas tiekiamasis - T3 1
1463187 | 2 a | vanduo karštas tiekiamasis - T3 1
1463262 | 2 a | vanduo karštas tiekiamasis - T3 1
1463266 | 2 a | vanduo karštas tiekiamasis - T3 1
1463306 | 2 a | vanduo karštas tiekiamasis - T3 1
1463335 | 2 a | vanduo karštas tiekiamasis - T3 1
1463339 | 2 a | vanduo karštas tiekiamasis - T3 1
1463443 | 2 a | vanduo karštas tiekiamasis - T3 1
1463445 | 2 a | vanduo karštas tiekiamasis - T3 1
1463609 | 2 a | vanduo karštas tiekiamasis - T3 1
1463642 | 2 a | vanduo karštas tiekiamasis - T3 1
1463646 | 2 a | vanduo karštas tiekiamasis - T3 1
1463862 | 3 a | vanduo karštas tiekiamasis - T3 1
1463874 | 3 a | vanduo karštas tiekiamasis - T3 1
1463898 | 3 a | vanduo karštas tiekiamasis - T3 1
1463939 | 3 a | vanduo karštas tiekiamasis - T3 1
1463956 | 3 a | vanduo karštas tiekiamasis - T3 1
1463967 | 3 a | vanduo karštas tiekiamasis - T3 1
1464031 | 3 a | vanduo karštas tiekiamasis - T3 1
1464035 | 3 a | vanduo karštas tiekiamasis - T3 1
1464077 | 3 a | vanduo karštas tiekiamasis - T3 1
1464085 | 3 a | vanduo karštas tiekiamasis - T3 1
1464147 | 3 a | vanduo karštas tiekiamasis - T3 1
1464151 | 3 a | vanduo karštas tiekiamasis - T3 1
1464211 | 3 a | vanduo karštas tiekiamasis - T3 1
1464219 | 3 a | vanduo karštas tiekiamasis - T3 1
1464279 | 3 a | vanduo karštas tiekiamasis - T3 1
1464283 | 3 a | vanduo karštas tiekiamasis - T3 1
1464360 | 3 a | vanduo karštas tiekiamasis - T3 1
1464362 | 3 a | vanduo karštas tiekiamasis - T3 1
1464445 | 3 a | vanduo karštas tiekiamasis - T3 1
1464447 | 3 a | vanduo karštas tiekiamasis - T3 1
1464480 | 3 a | vanduo karštas tiekiamasis - T3 1
1464627 | 3 a | vanduo karštas tiekiamasis - T3 1
1464757 | 3 a | vanduo karštas apytakinis - T4 1
1464771 | 3 a | vanduo karštas apytakinis - T4 1
1464783 | 3 a | vanduo karštas apytakinis - T4 1
1464815 | 3 a | vanduo karštas apytakinis - T4 1
1464844 | 3 a | vanduo karštas apytakinis - T4 1
1464900 | 3 a | vanduo karštas tiekiamasis - T3 1
1464980 | 3 a | vanduo karštas tiekiamasis - T3 1
1464984 | 3 a | vanduo karštas tiekiamasis - T3 1
1465108 | 3 a | vanduo karštas tiekiamasis - T3 1
1465112 | 3 a | vanduo karštas tiekiamasis - T3 1
1465185 | 3 a | vanduo karštas tiekiamasis - T3 1
1465191 | 3 a | vanduo karštas tiekiamasis - T3 1
1465258 | 3 a | vanduo karštas apytakinis - T4 1
1465300 | 3 a | vanduo karštas tiekiamasis - T3 1
1465311 | 3 a | vanduo karštas tiekiamasis - T3 1
1465321 | 3 a | vanduo karštas tiekiamasis - T3 1
1465369 | 3 a | vanduo karštas tiekiamasis - T3 1
1465371 | 3 a | vanduo karštas tiekiamasis - T3 1
1465427 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1465529 | 2 a | vanduo karštas apytakinis - T4 1
1465608 | 2 a | vanduo karštas apytakinis - T4 1
1465647 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1465655 | 3 a | vanduo karštas tiekiamasis - T3 1
1465665 | 3 a | vanduo karštas tiekiamasis - T3 1
1465677 | 3 a | vanduo karštas tiekiamasis - T3 1
1465731 | 3 a | vanduo karštas tiekiamasis - T3 1
1465822 | 3 a | vanduo karštas tiekiamasis - T3 1
1465826 | 3 a | vanduo karštas tiekiamasis - T3 1
1465891 | 3 a | vanduo karštas tiekiamasis - T3 1
1465933 | 3 a | vanduo karštas tiekiamasis - T3 1
1465937 | 3 a | vanduo karštas tiekiamasis - T3 1
1466023 | 3 a | vanduo karštas tiekiamasis - T3 1
1466027 | 3 a | vanduo karštas tiekiamasis - T3 1
1466111 | 3 a | vanduo karštas tiekiamasis - T3 1
1466113 | 3 a | vanduo karštas tiekiamasis - T3 1
1466196 | 3 a | vanduo karštas tiekiamasis - T3 1
1466200 | 3 a | vanduo karštas tiekiamasis - T3 1
1466263 | 3 a | vanduo karštas tiekiamasis - T3 1
1466303 | 3 a | vanduo karštas tiekiamasis - T3 1
1466358 | 3 a | vanduo karštas tiekiamasis - T3 1
1466395 | 3 a | vanduo karštas tiekiamasis - T3 1
1466462 | 3 a | vanduo karštas tiekiamasis - T3 1
1466464 | 3 a | vanduo karštas tiekiamasis - T3 1
1466508 | 3 a | vanduo karštas tiekiamasis - T3 1
1466561 | 3 a | vanduo karštas tiekiamasis - T3 1
1466563 | 3 a | vanduo karštas tiekiamasis - T3 1
1466589 | 2 a | vanduo karštas apytakinis - T4 1
1466597 | 3 a | vanduo karštas apytakinis - T4 1
1466609 | 3 a | vanduo karštas apytakinis - T4 1
1466699 | 3 a | vanduo karštas apytakinis - T4 1
1466748 | 3 a | vanduo karštas tiekiamasis - T3 1
1466756 | 3 a | vanduo karštas tiekiamasis - T3 1
1466766 | 3 a | vanduo karštas tiekiamasis - T3 1
1466784 | 3 a | vanduo karštas tiekiamasis - T3 1
1466829 | 3 a | vanduo karštas tiekiamasis - T3 1
1466831 | 3 a | vanduo karštas tiekiamasis - T3 1
1466883 | 3 a | vanduo karštas tiekiamasis - T3 1
1466927 | 3 a | vanduo karštas tiekiamasis - T3 1
1466929 | 3 a | vanduo karštas tiekiamasis - T3 1
1467015 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1467085 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1467238 | 3 a | vanduo karštas tiekiamasis - T3 1
1467258 | 3 a | vanduo karštas tiekiamasis - T3 1
1467268 | 3 a | vanduo karštas tiekiamasis - T3 1
1467348 | 3 a | vanduo karštas tiekiamasis - T3 1
1467356 | 3 a | vanduo karštas tiekiamasis - T3 1
1467405 | 3 a | vanduo karštas tiekiamasis - T3 1
1467411 | 3 a | vanduo karštas tiekiamasis - T3 1
1467537 | 3 a | vanduo karštas tiekiamasis - T3 1
1467575 | 3 a | vanduo karštas tiekiamasis - T3 1
1467589 | 3 a | vanduo karštas tiekiamasis - T3 1
1467659 | 3 a | vanduo karštas tiekiamasis - T3 1
1467663 | 3 a | vanduo karštas tiekiamasis - T3 1
1467697 | 3 a | vanduo karštas tiekiamasis - T3 1
1467745 | 3 a | vanduo karštas tiekiamasis - T3 1
1467749 | 3 a | vanduo karštas tiekiamasis - T3 1
1467784 | 3 a | vanduo karštas tiekiamasis - T3 1
1467948 | 3 a | vanduo karštas tiekiamasis - T3 1
1467950 | 3 a | vanduo karštas tiekiamasis - T3 1
1468049 | 3 a | vanduo karštas apytakinis - T4 1
1468075 | 3 a | vanduo karštas apytakinis - T4 1
1468085 | 3 a | vanduo karštas apytakinis - T4 1
1468353 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1468361 | 3 a | vanduo karštas tiekiamasis - T3 1
1468732 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1468740 | 3 a | vanduo karštas apytakinis - T4 1
1468804 | 3 a | vanduo karštas tiekiamasis - T3 1
1468854 | 3 a | vanduo karštas tiekiamasis - T3 1
1468858 | 3 a | vanduo karštas tiekiamasis - T3 1
1468927 | 3 a | vanduo karštas tiekiamasis - T3 1
1468931 | 3 a | vanduo karštas tiekiamasis - T3 1
1469003 | 3 a | vanduo karštas tiekiamasis - T3 1
1469063 | 3 a | vanduo karštas tiekiamasis - T3 1
1469067 | 3 a | vanduo karštas tiekiamasis - T3 1
1469186 | 3 a | vanduo karštas tiekiamasis - T3 11
1469200 | 3 a | vanduo karštas tiekiamasis - T3 11
1469208 | 3 a | vanduo karštas tiekiamasis - T3 11
1469236 | 3 a | vanduo karštas tiekiamasis - T3 11
1469284 | 3 a | vanduo karštas tiekiamasis - T3 11
1469288 | 3 a | vanduo karštas tiekiamasis - T3 11
1469375 | 3 a | vanduo karštas tiekiamasis - T3 11
1469379 | 3 a | vanduo karštas tiekiamasis - T3 11
1469419 | 3 a | vanduo karštas tiekiamasis - T3 11
1469429 | 3 a | vanduo karštas tiekiamasis - T3 11
1469488 | 3 a | vanduo karštas tiekiamasis - T3 11
1469492 | 3 a | vanduo karštas tiekiamasis - T3 11
1469573 | 3 a | vanduo karštas tiekiamasis - T3 11
1469577 | 3 a | vanduo karštas tiekiamasis - T3 11
1469611 | 3 a | vanduo karštas apytakinis - T4 1
1469619 | 3 a | vanduo karštas apytakinis - T4 1
1469631 | 3 a | vanduo karštas apytakinis - T4 1
1469672 | 3 a | vanduo karštas tiekiamasis - T3 11
1469683 | 3 a | vanduo karštas tiekiamasis - T3 11
1469723 | 3 a | vanduo karštas tiekiamasis - T3 11
1469725 | 3 a | vanduo karštas tiekiamasis - T3 11
1469806 | 3 a | vanduo karštas tiekiamasis - T3 11
1469808 | 3 a | vanduo karštas tiekiamasis - T3 11
1469869 | 3 a | vanduo karštas tiekiamasis - T3 11
1469993 | 3 a | vanduo karštas tiekiamasis - T3 1
1470021 | 3 a | vanduo karštas tiekiamasis - T3 1
1470035 | 3 a | vanduo karštas tiekiamasis - T3 1
1470085 | 3 a | vanduo karštas tiekiamasis - T3 1
1470089 | 3 a | vanduo karštas tiekiamasis - T3 1
1470137 | 3 a | vanduo karštas tiekiamasis - T3 1
1470183 | 3 a | vanduo karštas tiekiamasis - T3 1
1470187 | 3 a | vanduo karštas tiekiamasis - T3 1
1470225 | 3 a | vanduo karštas tiekiamasis - T3 1
1470265 | 3 a | vanduo karštas tiekiamasis - T3 1
1470269 | 3 a | vanduo karštas tiekiamasis - T3 1
1470315 | 3 a | vanduo karštas tiekiamasis - T3 1
1470323 | 3 a | vanduo karštas tiekiamasis - T3 1
1470333 | 3 a | vanduo karštas tiekiamasis - T3 1
1470384 | 3 a | vanduo karštas tiekiamasis - T3 1
1470388 | 3 a | vanduo karštas tiekiamasis - T3 1
1470475 | 3 a | vanduo šaltas - V1 2
1470479 | 3 a | vanduo šaltas - V1 2
1470561 | 3 a | vanduo šaltas - V1 2
1470565 | 3 a | vanduo šaltas - V1 2
1470643 | 3 a | vanduo karštas tiekiamasis - T3 1
1470647 | 3 a | vanduo karštas tiekiamasis - T3 1
1470773 | 3 a | vanduo karštas tiekiamasis - T3 1
1470777 | 3 a | vanduo karštas tiekiamasis - T3 1
1471074 | 3 a | vanduo karštas apytakinis - T4 1
1471088 | 3 a | vanduo karštas apytakinis - T4 1
1471170 | 3 a | vanduo karštas apytakinis - T4 1
1471198 | 3 a | vanduo karštas apytakinis - T4 1
1471322 | 3 a | vanduo karštas tiekiamasis - T3 1
1471332 | 3 a | vanduo karštas tiekiamasis - T3 1
1471340 | 3 a | vanduo karštas tiekiamasis - T3 1
1471360 | 3 a | vanduo karštas tiekiamasis - T3 1
1471404 | 3 a | vanduo karštas tiekiamasis - T3 1
1471426 | 3 a | vanduo karštas tiekiamasis - T3 1
1471434 | 3 a | vanduo karštas tiekiamasis - T3 1
1471496 | 3 a | vanduo karštas tiekiamasis - T3 1
1471498 | 3 a | vanduo karštas tiekiamasis - T3 1
1471547 | 3 a | vanduo karštas tiekiamasis - T3 1
1471585 | 3 a | vanduo karštas tiekiamasis - T3 1
1471657 | 3 a | vanduo karštas tiekiamasis - T3 1
1471663 | 3 a | vanduo karštas tiekiamasis - T3 1
1471818 | 3 a | vanduo karštas tiekiamasis - T3 1
1471828 | 3 a | vanduo karštas tiekiamasis - T3 1
1471881 | 3 a | vanduo karštas tiekiamasis - T3 1
1471885 | 3 a | vanduo karštas tiekiamasis - T3 1
1472019 | 3 a | vanduo šaltas - V1 8
1472114 | 3 a | vanduo karštas tiekiamasis - T3 1
1472116 | 3 a | vanduo karštas tiekiamasis - T3 1
1472151 | 3 a | vanduo karštas tiekiamasis - T3 1
1472199 | 3 a | vanduo šaltas - V1 2
1472207 | 3 a | vanduo šaltas - V1 2
1472250 | 3 a | vanduo šaltas - V1 2
1472254 | 3 a | vanduo šaltas - V1 2
1472290 | 3 a | vanduo karštas tiekiamasis - T3 1
1472361 | 3 a | vanduo karštas tiekiamasis - T3 1
1472365 | 3 a | vanduo karštas tiekiamasis - T3 1
1472456 | 3 a | vanduo karštas apytakinis - T4 1
1472468 | 3 a | vanduo karštas apytakinis - T4 1
1472479 | 3 a | vanduo karštas apytakinis - T4 1
1472499 | 3 a | vanduo karštas apytakinis - T4 1
1472507 | 3 a | vanduo karštas apytakinis - T4 1
1472519 | 3 a | vanduo karštas apytakinis - T4 1
1472872 | 2 a | vanduo karštas tiekiamasis - T3 1
1473207 | 3 a | vanduo karštas tiekiamasis - T3 1
1473242 | 3 a | vanduo karštas tiekiamasis - T3 1
1473259 | 3 a | vanduo karštas tiekiamasis - T3 1
1473269 | 3 a | vanduo karštas tiekiamasis - T3 1
1473326 | 3 a | vanduo karštas tiekiamasis - T3 1
1473330 | 3 a | vanduo karštas tiekiamasis - T3 1
1473428 | 3 a | vanduo karštas tiekiamasis - T3 1
1473432 | 3 a | vanduo karštas tiekiamasis - T3 1
1473466 | 3 a | vanduo karštas tiekiamasis - T3 1
1473501 | 3 a | vanduo karštas tiekiamasis - T3 1
1473505 | 3 a | vanduo karštas tiekiamasis - T3 1
1473573 | 3 a | vanduo karštas tiekiamasis - T3 1
1473577 | 3 a | vanduo karštas tiekiamasis - T3 1
1473613 | 3 a | vanduo karštas tiekiamasis - T3 1
1473621 | 3 a | vanduo karštas tiekiamasis - T3 1
1473674 | 3 a | vanduo karštas tiekiamasis - T3 1
1473678 | 3 a | vanduo karštas tiekiamasis - T3 1
1473752 | 3 a | vanduo karštas tiekiamasis - T3 1
1473756 | 3 a | vanduo karštas tiekiamasis - T3 1
1473794 | 3 a | vanduo karštas tiekiamasis - T3 1
1473804 | 3 a | vanduo karštas tiekiamasis - T3 1
1473812 | 3 a | vanduo karštas tiekiamasis - T3 1
1473865 | 3 a | vanduo karštas tiekiamasis - T3 1
1473869 | 3 a | vanduo karštas tiekiamasis - T3 1
1473905 | 3 a | vanduo karštas tiekiamasis - T3 1
1473970 | 3 a | vanduo karštas tiekiamasis - T3 1
1473974 | 3 a | vanduo karštas tiekiamasis - T3 1
1474017 | 3 a | vanduo karštas tiekiamasis - T3 1
1474063 | 3 a | vanduo karštas tiekiamasis - T3 1
1474065 | 3 a | vanduo karštas tiekiamasis - T3 1
1474111 | 3 a | vanduo karštas tiekiamasis - T3 1
1474165 | 3 a | vanduo karštas tiekiamasis - T3 1
1474167 | 3 a | vanduo karštas tiekiamasis - T3 1
1474304 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1474764 | 3 a | vanduo karštas tiekiamasis - T3 1
1474796 | 3 a | vanduo karštas tiekiamasis - T3 1
1474852 | 3 a | vanduo karštas tiekiamasis - T3 1
1474856 | 3 a | vanduo karštas tiekiamasis - T3 1
1474906 | 3 a | vanduo karštas tiekiamasis - T3 1
1474940 | 3 a | vanduo karštas tiekiamasis - T3 1
1474944 | 3 a | vanduo karštas tiekiamasis - T3 1
1475033 | 3 a | vanduo karštas tiekiamasis - T3 1
1475037 | 3 a | vanduo karštas tiekiamasis - T3 1
1475073 | 3 a | vanduo karštas tiekiamasis - T3 1
1475083 | 3 a | vanduo karštas tiekiamasis - T3 1
1475120 | 3 a | vanduo karštas tiekiamasis - T3 1
1475124 | 3 a | vanduo karštas tiekiamasis - T3 1
1475169 | 3 a | vanduo karštas tiekiamasis - T3 1
1475179 | 3 a | vanduo karštas tiekiamasis - T3 1
1475216 | 3 a | vanduo karštas tiekiamasis - T3 1
1475218 | 3 a | vanduo karštas tiekiamasis - T3 1
1475258 | 3 a | vanduo karštas tiekiamasis - T3 1
1475336 | 3 a | vanduo karštas tiekiamasis - T3 1
1475360 | 3 a | vanduo karštas tiekiamasis - T3 1
1475376 | 3 a | vanduo karštas tiekiamasis - T3 1
1475399 | 3 a | vanduo karštas tiekiamasis - T3 1
1475410 | 3 a | vanduo karštas tiekiamasis - T3 1
1475461 | 3 a | vanduo karštas tiekiamasis - T3 1
1475465 | 3 a | vanduo karštas tiekiamasis - T3 1
1475532 | 3 a | vanduo karštas tiekiamasis - T3 1
1475542 | 3 a | vanduo karštas tiekiamasis - T3 1
1475590 | 3 a | vanduo karštas tiekiamasis - T3 1
1475594 | 3 a | vanduo karštas tiekiamasis - T3 1
1475715 | 3 a | vanduo karštas tiekiamasis - T3 1
1475717 | 3 a | vanduo karštas tiekiamasis - T3 1
1475774 | 3 a | vanduo karštas tiekiamasis - T3 1
1475782 | 3 a | vanduo karštas tiekiamasis - T3 1
1475792 | 3 a | vanduo karštas tiekiamasis - T3 1
1475847 | 3 a | vanduo karštas tiekiamasis - T3 1
1475849 | 3 a | vanduo karštas tiekiamasis - T3 1
1475884 | 3 a | vanduo karštas tiekiamasis - T3 1
1475918 | 3 a | vanduo karštas apytakinis - T4 1
1475978 | 3 a | vanduo karštas apytakinis - T4 1
1475995 | 3 a | vanduo karštas apytakinis - T4 1
1476033 | 3 a | vanduo karštas apytakinis - T4 1
1476047 | 3 a | vanduo karštas apytakinis - T4 1
1476055 | 3 a | vanduo karštas apytakinis - T4 1
1476101 | 3 a | vanduo karštas apytakinis - T4 1
1476109 | 3 a | vanduo karštas apytakinis - T4 1
1476279 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1476878 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1477021 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477045 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477053 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477067 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477126 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477130 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477170 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477240 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477244 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477335 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477400 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477404 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477472 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
