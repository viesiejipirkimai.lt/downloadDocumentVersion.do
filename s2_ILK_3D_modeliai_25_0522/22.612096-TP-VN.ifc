Properties of the parts of a building model (IFC2X3), part 43 of 57

# IfcFlowFitting: PIF_Tigris_Elbow_M-K_Wavin:Standard (3281)
Name (PIF_Tigris_Elbow_M-K_Wavin:Standard:...) | In | Group
1477474 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477512 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477574 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477578 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477624 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477673 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477687 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477695 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477758 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477762 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477827 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477831 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477918 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477920 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477990 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477998 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478014 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478022 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478102 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478106 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478183 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478189 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478229 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478286 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478290 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478401 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478403 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478442 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478454 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478467 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478477 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478518 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478522 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478563 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478571 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478627 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478659 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478689 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478699 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478707 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478767 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478771 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478815 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478823 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478856 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478860 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478907 | 4 a V1 | vanduo karštas apytakinis - T4 1
1478920 | 4 a V1 | vanduo karštas apytakinis - T4 1
1478930 | 4 a V1 | vanduo karštas apytakinis - T4 1
1478944 | 4 a V1 | vanduo karštas apytakinis - T4 1
1478954 | 4 a V1 | vanduo karštas apytakinis - T4 1
1478986 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479031 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479041 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479088 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479096 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479143 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479177 | 2 a | vanduo karštas apytakinis - T4 1
1479226 | 2 a | vanduo karštas tiekiamasis - T3 1
1479320 | 2 a | vanduo karštas tiekiamasis - T3 1
1479503 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479513 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479538 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479572 | 2 a | vanduo karštas apytakinis - T4 1
1479585 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479593 | 4 a V1 | vanduo karštas apytakinis - T4 1
1479623 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479635 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479657 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479719 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479723 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479833 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479838 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479911 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479915 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479977 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479979 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480021 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480065 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480069 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480115 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480125 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480142 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480203 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480207 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480286 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480290 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480324 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480368 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480372 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480408 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480442 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480444 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480485 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480496 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480506 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480547 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480549 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480643 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480647 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480703 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480713 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480774 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480778 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480818 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480862 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480864 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480904 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480948 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480950 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481002 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481010 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481040 | 3 a | vanduo karštas apytakinis - T4 1
1481104 | 3 a | vanduo karštas apytakinis - T4 1
1481114 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481122 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481204 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481245 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481287 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481295 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481312 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481341 | 4 a V1 | vanduo karštas apytakinis - T4 1
1481369 | 3 a | vanduo karštas tiekiamasis - T3 1
1481398 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481406 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481426 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481436 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481531 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481535 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481622 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481626 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481818 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481822 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481909 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481913 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481951 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481959 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482008 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482012 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482087 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482091 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482152 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482224 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482228 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482312 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482318 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482371 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482411 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482445 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482455 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482502 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482506 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482582 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482586 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482648 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482658 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482704 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482708 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482808 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482812 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482856 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482937 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482941 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483025 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483029 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483113 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483117 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483169 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483198 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483265 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483267 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483339 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483341 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483467 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1483481 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483489 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483506 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483552 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483554 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483669 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483673 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483743 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483747 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483818 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483824 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483894 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483898 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483934 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483944 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483995 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483997 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484030 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484065 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484161 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484211 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484215 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484303 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484307 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484374 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484378 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484452 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484456 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484506 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484522 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484569 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484573 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484701 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484705 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484774 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484778 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484849 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484851 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484887 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484935 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484937 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485047 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485051 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485111 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485113 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485143 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1485153 | 4 a V1 | vanduo karštas apytakinis - T4 1
1485391 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1485409 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485433 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485445 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485468 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485482 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485533 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485537 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485573 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485610 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485648 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485716 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485720 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485801 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485805 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485845 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485902 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485904 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485981 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485985 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486051 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486057 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486122 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486165 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486167 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486200 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486234 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486244 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486295 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486299 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486332 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486368 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486412 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486414 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486513 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486517 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486595 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486597 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486633 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486709 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486713 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486743 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1486765 | 4 a V1 | vanduo karštas apytakinis - T4 1
1486777 | 4 a V1 | vanduo karštas apytakinis - T4 1
1486796 | 4 a V1 | vanduo karštas apytakinis - T4 1
1486968 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1486976 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487019 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487027 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487114 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487118 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487265 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487269 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487303 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487317 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487363 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487365 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487438 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487442 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487508 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487512 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487658 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487662 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487696 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487706 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487714 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487808 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487814 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487885 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487889 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487974 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487980 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488025 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488091 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488093 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488126 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488198 | 4 a V1 | vanduo šaltas - V1 2
1488200 | 4 a V1 | vanduo šaltas - V1 2
1488273 | 4 a V1 | vanduo šaltas - V1 2
1488275 | 4 a V1 | vanduo šaltas - V1 2
1488355 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488357 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488444 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488446 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1488581 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1488597 | 4 a V1 | vanduo karštas apytakinis - T4 1
1488607 | 4 a V1 | vanduo karštas apytakinis - T4 1
1488654 | 4 a V1 | vanduo karštas apytakinis - T4 1
1488664 | 4 a V1 | vanduo karštas apytakinis - T4 1
1488779 | 3 a | vanduo karštas tiekiamasis - T3 1
1488804 | 3 a | vanduo karštas apytakinis - T4 1
1488812 | 3 a | vanduo karštas apytakinis - T4 1
1488836 | 3 a | vanduo karštas tiekiamasis - T3 1
1489208 | 3 a | vanduo karštas tiekiamasis - T3 1
1489220 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489234 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489242 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489262 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489277 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489317 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489319 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489404 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489408 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489483 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489487 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489567 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489571 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489641 | 4 a V1 | vanduo šaltas - V1 2
1489645 | 4 a V1 | vanduo šaltas - V1 2
1489682 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489720 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489722 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489800 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489804 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489872 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489876 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489954 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489958 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1490049 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1490053 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1490093 | 3 a | vanduo karštas apytakinis - T4 1
1490119 | 4 a V1 | vanduo karštas apytakinis - T4 1
1490129 | 4 a V1 | vanduo karštas apytakinis - T4 1
1490139 | 4 a V1 | vanduo karštas apytakinis - T4 1
1490149 | 4 a V1 | vanduo karštas apytakinis - T4 1
1490181 | 4 a V1 | vanduo šaltas - V1 2
1490236 | 4 a V1 | vanduo šaltas - V1 2
1490238 | 4 a V1 | vanduo šaltas - V1 2
1490316 | 3 a | vanduo karštas tiekiamasis - T3 14
1490511 | 3 a | vanduo karštas tiekiamasis - T3 14
1490523 | 3 a | vanduo karštas tiekiamasis - T3 14
1490621 | 2 a | vanduo karštas apytakinis - T4 1
1490631 | 2 a | vanduo karštas apytakinis - T4 1
1490643 | 2 a | vanduo karštas apytakinis - T4 1
1490654 | 2 a | vanduo karštas apytakinis - T4 1
1490707 | 2 a | vanduo karštas apytakinis - T4 1
1490781 | 3 a | vanduo karštas tiekiamasis - T3 13
1490800 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1490812 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1490858 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1490860 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1490954 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1490958 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491029 | 4 a V1 | vanduo šaltas - V1 2
1491033 | 4 a V1 | vanduo šaltas - V1 2
1491060 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491062 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491107 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491111 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491147 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491194 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491196 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491265 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491269 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491357 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491361 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491430 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491432 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491473 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491511 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491513 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491549 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491600 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491617 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491621 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491677 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491681 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491715 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491744 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491786 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491856 | 3 a | vanduo karštas tiekiamasis - T3 1
1491912 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492100 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1492252 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492292 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492296 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492332 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492396 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492400 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492436 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492477 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492481 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492539 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492627 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492631 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492697 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492703 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492753 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492763 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492835 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492839 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492911 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492917 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492955 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492965 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493010 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493014 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493089 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493101 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493111 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493151 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493153 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493215 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493219 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493333 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493337 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493427 | 4 a V1 | vanduo karštas apytakinis - T4 1
1493493 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1493511 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493529 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493580 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493584 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493695 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493697 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493739 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493801 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493805 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493851 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493865 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493910 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493914 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493985 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1493989 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494111 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494115 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494153 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494235 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494239 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494288 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1494304 | 5 a V1 | vanduo karštas apytakinis - T4 1
1494370 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1494451 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1494469 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494481 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494505 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494515 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494529 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494554 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494606 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494610 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494730 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494732 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494775 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1494787 | 5 a V1 | vanduo karštas apytakinis - T4 1
1494797 | 5 a V1 | vanduo karštas apytakinis - T4 1
1494805 | 5 a V1 | vanduo karštas apytakinis - T4 1
1494815 | 5 a V1 | vanduo karštas apytakinis - T4 1
1494853 | 5 a V1 | vanduo karštas apytakinis - T4 1
1853395 | 2 a | vanduo karštas tiekiamasis - T3 1

# IfcFlowFitting: PIF_Tigris_End_Cap_M-K_Wavin:Diameter 16-25, PIF_Tigris_End_Cap_M-K_Wavin:Diameter 16-25:1341763
In: 2 a
Type - Description: End Cap; PredefinedType: USERDEFINED; Material: Steel WVN-T, PPSU-K5, Blue, RAL5100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat); Group: vanduo šaltas - V1 2
Pset_DistributionFlowElementCommon - Reference: Diameter 16-25; sets with these values: 2

# IfcFlowFitting: PIF_Tigris_MultiReducer_Wavin:Standard Multireducer (260)
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard Multireducer; sets with these values: 2
Name (PIF_Tigris_MultiReducer_Wavin:Standard Multireducer:...) | In | Group
1330606 | 3 a | vanduo šaltas - V1 2
1331558 | 4 a V1 | vanduo šaltas - V1 2
1333410 | 2 a | vanduo šaltas - V1 2
1333701 | 4 a V1 | vanduo šaltas - V1 2
1334058 | 2 a | vanduo šaltas - V1 2
1334122 | 4 a V1 | vanduo šaltas - V1 2
1336233 | 2 a | vanduo šaltas - V1 2
1336384 | 2 a | vanduo šaltas - V1 2
1336552 | 4 a V1 | vanduo šaltas - V1 2
1337425 | 4 a V1 | vanduo šaltas - V1 2
1337659 | 4 a V1 | vanduo šaltas - V1 2
1339075 | 5 a V1 | vanduo šaltas - V1 2
1339204 | 5 a V1 | vanduo šaltas - V1 2
1339335 | 5 a V1 | vanduo šaltas - V1 2
1339681 | 2 a | vanduo šaltas - V1 2
1339828 | 2 a | vanduo šaltas - V1 2
1340541 | 4 a V1 | vanduo šaltas - V1 2
1341060 | 4 a V1 | vanduo šaltas - V1 2
1343030 | 4 a V1 | vanduo šaltas - V1 2
1343315 | 4 a V1 | vanduo šaltas - V1 2
1344100 | 2 a | vanduo šaltas - V1 2
1344223 | 2 a | vanduo šaltas - V1 2
1344597 | 5 a V1 | vanduo šaltas - V1 2
1345862 | 4 a V1 | vanduo šaltas - V1 2
1346136 | 4 a V1 | vanduo šaltas - V1 2
1346679 | 4 a V1 | vanduo šaltas - V1 2
1347054 | 4 a V1 | vanduo šaltas - V1 2
1347514 | 4 a V1 | vanduo šaltas - V1 2
1349422 | 4 a V1 | vanduo šaltas - V1 2
1349558 | 4 a V1 | vanduo šaltas - V1 2
1349670 | 4 a V1 | vanduo šaltas - V1 2
1350587 | 4 a V1 | vanduo šaltas - V1 2
1351114 | 4 a V1 | vanduo šaltas - V1 2
1351664 | 4 a V1 | vanduo šaltas - V1 2
1351683 | 4 a V1 | vanduo šaltas - V1 2
1351833 | 4 a V1 | vanduo šaltas - V1 2
1352538 | 2 a | vanduo šaltas - V1 2
1352689 | 4 a V1 | vanduo šaltas - V1 2
1353817 | 4 a V1 | vanduo šaltas - V1 2
1354768 | 1 a +-152.84 | vanduo šaltas - V1 2
1354834 | 1 a +-152.84 | vanduo šaltas - V1 2
1354879 | 4 a V1 | vanduo šaltas - V1 2
1354998 | 4 a V1 | vanduo šaltas - V1 2
1356374 | 4 a V1 | vanduo šaltas - V1 2
1356689 | 4 a V1 | vanduo šaltas - V1 2
1356790 | 4 a V1 | vanduo šaltas - V1 2
1357462 | 3 a | vanduo šaltas - V1 2
1357570 | 3 a | vanduo šaltas - V1 2
1357865 | 3 a | vanduo šaltas - V1 2
1358867 | 3 a | vanduo šaltas - V1 2
1359355 | 3 a | vanduo šaltas - V1 2
1360336 | 2 a | vanduo šaltas - V1 2
1361566 | 2 a | vanduo šaltas - V1 2
1361626 | 3 a | vanduo šaltas - V1 2
1361975 | 3 a | vanduo šaltas - V1 2
1362126 | 3 a | vanduo šaltas - V1 2
1362233 | 3 a | vanduo šaltas - V1 2
1362553 | 3 a | vanduo šaltas - V1 2
1362772 | 3 a | vanduo šaltas - V1 2
1363075 | 3 a | vanduo šaltas - V1 2
1363604 | 3 a | vanduo šaltas - V1 2
1363648 | 3 a | vanduo šaltas - V1 2
1364196 | 3 a | vanduo šaltas - V1 2
1364515 | 3 a | vanduo šaltas - V1 2
1364900 | 3 a | vanduo šaltas - V1 2
1365684 | 3 a | vanduo šaltas - V1 2
1366350 | 2 a | vanduo šaltas - V1 2
1366443 | 3 a | vanduo šaltas - V1 2
1367300 | 3 a | vanduo šaltas - V1 2
1367555 | 3 a | vanduo šaltas - V1 2
1368031 | 2 a | vanduo šaltas - V1 2
1368393 | 3 a | vanduo šaltas - V1 2
1369153 | 2 a | vanduo šaltas - V1 2
1369256 | 2 a | vanduo šaltas - V1 2
1369827 | 2 a | vanduo šaltas - V1 2
1370838 | 2 a | vanduo šaltas - V1 2
1372545 | 2 a | vanduo šaltas - V1 2
1372598 | 2 a | vanduo šaltas - V1 2
1372879 | 2 a | vanduo šaltas - V1 2
1373248 | 2 a | vanduo šaltas - V1 2
1375312 | 2 a | vanduo šaltas - V1 2
1375432 | 2 a | vanduo šaltas - V1 2
1377270 | 2 a | vanduo šaltas - V1 2
1377513 | 2 a | vanduo šaltas - V1 2
1377747 | 2 a | vanduo šaltas - V1 2
1378940 | 2 a | vanduo šaltas - V1 2
1379598 | 2 a | vanduo šaltas - V1 2
1380288 | 2 a | vanduo šaltas - V1 2
1380644 | 2 a | vanduo šaltas - V1 2
1381087 | 2 a | vanduo šaltas - V1 2
1382014 | 2 a | vanduo šaltas - V1 2
1382364 | 2 a | vanduo šaltas - V1 2
1383368 | 1 a +-152.84 | vanduo šaltas - V1 2
1383657 | 2 a | vanduo šaltas - V1 2
1383945 | 2 a | vanduo šaltas - V1 2
1385273 | 2 a | vanduo šaltas - V1 2
1385610 | 2 a | vanduo šaltas - V1 2
1386482 | 2 a | vanduo šaltas - V1 2
1387037 | 2 a | vanduo šaltas - V1 2
1387311 | 2 a | vanduo šaltas - V1 2
1387961 | 2 a | vanduo šaltas - V1 2
1388016 | 2 a | vanduo šaltas - V1 2
1388850 | 2 a | vanduo šaltas - V1 2
1389459 | 2 a | vanduo šaltas - V1 2
1390262 | 2 a | vanduo šaltas - V1 2
1391003 | 2 a | vanduo šaltas - V1 2
1391093 | 2 a | vanduo šaltas - V1 2
1392656 | 2 a | vanduo šaltas - V1 2
1392761 | 2 a | vanduo šaltas - V1 2
1392845 | 2 a | vanduo šaltas - V1 2
1394052 | 2 a | vanduo šaltas - V1 2
1394106 | 2 a | vanduo šaltas - V1 2
1395083 | 2 a | vanduo šaltas - V1 2
1395105 | 2 a | vanduo šaltas - V1 2
1395772 | 2 a | vanduo šaltas - V1 2
1396776 | 2 a | vanduo šaltas - V1 2
1397437 | 2 a | vanduo šaltas - V1 2
1397457 | 2 a | vanduo šaltas - V1 2
1398311 | 2 a | vanduo šaltas - V1 2
1398659 | 1 a +-152.84 | vanduo šaltas - V1 2
1399232 | 1 a +-152.84 | vanduo šaltas - V1 2
1400492 | 1 a +-152.84 | vanduo šaltas - V1 2
1400948 | 1 a +-152.84 | vanduo šaltas - V1 2
1402057 | 1 a +-152.84 | vanduo šaltas - V1 2
1402634 | 1 a +-152.84 | vanduo šaltas - V1 2
1402912 | 1 a +-152.84 | vanduo šaltas - V1 2
1403217 | 1 a +-152.84 | vanduo šaltas - V1 2
1403652 | 1 a +-152.84 | vanduo šaltas - V1 2
1404194 | 1 a +-152.84 | vanduo šaltas - V1 2
1404770 | 1 a +-152.84 | vanduo šaltas - V1 2
1404782 | 1 a +-152.84 | vanduo šaltas - V1 2
1405897 | 1 a +-152.84 | vanduo šaltas - V1 2
1406382 | 1 a +-152.84 | vanduo šaltas - V1 2
1407594 | 1 a +-152.84 | vanduo šaltas - V1 2
1408264 | 1 a +-152.84 | vanduo šaltas - V1 2
1408382 | 1 a +-152.84 | vanduo šaltas - V1 2
1432925 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1433006 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433675 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1435774 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436626 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437072 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438012 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1440590 | 2 a | vanduo karštas tiekiamasis - T3 1
1440699 | 2 a | vanduo karštas tiekiamasis - T3 1
1440850 | 2 a | vanduo karštas tiekiamasis - T3 1
1441047 | 2 a | vanduo karštas tiekiamasis - T3 1
1441338 | 2 a | vanduo karštas tiekiamasis - T3 1
1441473 | 2 a | vanduo karštas tiekiamasis - T3 1
1441788 | 2 a | vanduo karštas tiekiamasis - T3 1
1442280 | 2 a | vanduo karštas tiekiamasis - T3 1
1442500 | 2 a | vanduo karštas tiekiamasis - T3 1
1443535 | 2 a | vanduo karštas tiekiamasis - T3 1
1443913 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1443999 | 2 a | vanduo karštas tiekiamasis - T3 1
1444097 | 2 a | vanduo karštas tiekiamasis - T3 1
1444798 | 2 a | vanduo šaltas - V1 2
1445634 | 2 a | vanduo karštas tiekiamasis - T3 7
1445674 | 2 a | vanduo karštas tiekiamasis - T3 7
1446060 | 2 a | vanduo karštas tiekiamasis - T3 7
1446365 | 2 a | vanduo karštas tiekiamasis - T3 7
1446625 | 2 a | vanduo karštas tiekiamasis - T3 1
1447121 | 2 a | vanduo karštas tiekiamasis - T3 1
1447280 | 2 a | vanduo karštas tiekiamasis - T3 1
1447361 | 2 a | vanduo karštas tiekiamasis - T3 1
1447612 | 2 a | vanduo karštas tiekiamasis - T3 1
1448232 | 2 a | vanduo karštas tiekiamasis - T3 1
1448953 | 2 a | vanduo karštas tiekiamasis - T3 1
1449436 | 2 a | vanduo karštas tiekiamasis - T3 1
1450228 | 2 a | vanduo karštas tiekiamasis - T3 1
1450304 | 2 a | vanduo karštas tiekiamasis - T3 1
1452159 | 2 a | vanduo karštas tiekiamasis - T3 1
1452184 | 2 a | vanduo karštas tiekiamasis - T3 1
1452771 | 2 a | vanduo karštas tiekiamasis - T3 1
1454869 | 2 a | vanduo karštas tiekiamasis - T3 1
1454883 | 2 a | vanduo karštas tiekiamasis - T3 1
1457130 | 2 a | vanduo karštas tiekiamasis - T3 1
1457215 | 2 a | vanduo karštas tiekiamasis - T3 1
1457708 | 2 a | vanduo šaltas - V1 2
1459675 | 2 a | vanduo karštas tiekiamasis - T3 1
1459810 | 2 a | vanduo karštas tiekiamasis - T3 1
1460061 | 2 a | vanduo karštas tiekiamasis - T3 1
1460358 | 2 a | vanduo karštas tiekiamasis - T3 1
1460547 | 2 a | vanduo karštas tiekiamasis - T3 1
1460737 | 2 a | vanduo karštas tiekiamasis - T3 1
1460813 | 2 a | vanduo karštas tiekiamasis - T3 1
1460926 | 2 a | vanduo karštas tiekiamasis - T3 1
1461160 | 2 a | vanduo karštas tiekiamasis - T3 1
1461222 | 2 a | vanduo karštas tiekiamasis - T3 1
1461336 | 2 a | vanduo karštas tiekiamasis - T3 1
1461645 | 2 a | vanduo karštas tiekiamasis - T3 1
1461898 | 2 a | vanduo karštas tiekiamasis - T3 1
1462307 | 2 a | vanduo karštas tiekiamasis - T3 1
1462359 | 2 a | vanduo karštas tiekiamasis - T3 1
1462708 | 2 a | vanduo karštas tiekiamasis - T3 1
1463130 | 2 a | vanduo karštas tiekiamasis - T3 1
1463941 | 3 a | vanduo karštas tiekiamasis - T3 1
1465187 | 3 a | vanduo karštas tiekiamasis - T3 1
1465429 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1465610 | 2 a | vanduo karštas apytakinis - T4 1
1465667 | 3 a | vanduo karštas tiekiamasis - T3 1
1467407 | 3 a | vanduo karštas tiekiamasis - T3 1
1467577 | 3 a | vanduo karštas tiekiamasis - T3 1
1468806 | 3 a | vanduo karštas tiekiamasis - T3 1
1469238 | 3 a | vanduo karštas tiekiamasis - T3 11
1469995 | 3 a | vanduo karštas tiekiamasis - T3 1
1470023 | 3 a | vanduo karštas tiekiamasis - T3 1
1471362 | 3 a | vanduo karštas tiekiamasis - T3 1
1471406 | 3 a | vanduo karštas tiekiamasis - T3 1
1471659 | 3 a | vanduo karštas tiekiamasis - T3 1
1473193 | 3 a | vanduo karštas tiekiamasis - T3 1
1473244 | 3 a | vanduo karštas tiekiamasis - T3 1
1473623 | 3 a | vanduo karštas tiekiamasis - T3 1
1474766 | 3 a | vanduo karštas tiekiamasis - T3 1
1474798 | 3 a | vanduo karštas tiekiamasis - T3 1
1475378 | 3 a | vanduo karštas tiekiamasis - T3 1
1475935 | 3 a | vanduo karštas apytakinis - T4 1
1476252 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1477023 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477069 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1477675 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478024 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478185 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1478326 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479228 | 2 a | vanduo karštas tiekiamasis - T3 1
1479625 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1479659 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1480144 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1481438 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482154 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1482314 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483469 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1483491 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1483820 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484163 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1484524 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1485393 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1485470 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1486053 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487007 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487305 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487810 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1487976 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1489210 | 3 a | vanduo karštas tiekiamasis - T3 1
1489264 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1490589 | 2 a | vanduo karštas apytakinis - T4 1
1490802 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491475 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1491602 | 4 a V1 | vanduo karštas tiekiamasis - T3 13
1492254 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492541 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492699 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492765 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1492913 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493091 | 4 a V1 | vanduo karštas tiekiamasis - T3 1
1493531 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494155 | 5 a V1 | vanduo karštas tiekiamasis - T3 1
1494372 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1494453 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1494517 | 5 a V1 | vanduo karštas tiekiamasis - T3 1

# IfcFlowFitting: PIF_Tigris_MultiReducer_Wavin:Standard Multireducer (14)
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: PE-X, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat); Material: PE-X, White, RAL 9100, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Standard Multireducer; sets with these values: 2
Name (PIF_Tigris_MultiReducer_Wavin:Standard Multireducer:...) | In | Group
1330786 | 3 a | vanduo šaltas - V1 2
1339683 | 5 a V1 | vanduo šaltas - V1 2
1341744 | 2 a | vanduo šaltas - V1 2
1426790 | 0 a | vanduo šaltas - V1 2
1427077 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 2
1433194 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433677 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1476564 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1479179 | 2 a | vanduo karštas apytakinis - T4 1
1481183 | 3 a | vanduo karštas apytakinis - T4 1
1481371 | 3 a | vanduo karštas tiekiamasis - T3 1
1492238 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1493495 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1494290 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1

# IfcFlowFitting: PIF_Tigris_Super_Tee_Wavin:Standard SuperTee (1063)
Type - Description: Branch; PredefinedType: JUNCTION; Material: Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard SuperTee; sets with these values: 2
Name (PIF_Tigris_Super_Tee_Wavin:Standard SuperTee:...) | In | Material | Group
1118340 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1328767 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1328941 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1330228 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331204 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331323 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331499 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331625 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331672 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331729 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331802 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1331961 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332091 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332158 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332278 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332345 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332389 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332486 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332551 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332653 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1332789 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1333665 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1333754 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1333848 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1334218 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1334556 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1334631 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1334734 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1334817 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1334893 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335189 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335264 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335344 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335425 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335496 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335571 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335654 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335748 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335867 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1335942 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336030 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336089 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336459 | 4 a V1 | <Unnamed>, PE-X, White, RAL 9100, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336623 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336713 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336788 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1336893 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337180 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337269 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337394 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337495 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337572 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337764 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337872 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1337959 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1338048 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1338123 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1338229 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1338704 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339044 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339163 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339299 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339461 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339576 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339608 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1339904 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340291 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340371 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340440 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340509 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340730 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340801 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340880 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1340954 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341020 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341187 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341258 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341333 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341454 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341540 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341666 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1341977 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342287 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342368 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342465 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342536 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342618 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342680 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo šaltas - V1 2
1342879 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1342955 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343151 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343207 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343286 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343488 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343581 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343709 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343777 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343839 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1343902 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1344083 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1344737 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1344821 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1344921 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1344969 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1345064 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1345300 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1345839 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1345987 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346116 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346369 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346431 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346548 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346611 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346750 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346852 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346914 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1346987 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347129 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347204 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347281 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347416 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347484 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347615 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347699 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347762 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347836 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347907 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1347989 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1348064 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1348141 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1348240 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1348311 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1348384 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1348677 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1349254 | 4 a V1 | <Unnamed>, PE-X, White, RAL 9100, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1349507 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1349654 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1349750 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1349917 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350002 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350067 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350222 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350419 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350497 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350641 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350758 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1350932 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351005 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351088 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351191 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351265 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351447 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351537 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351617 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351726 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1351901 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1352184 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1352391 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1352624 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo šaltas - V1 2
1352995 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353092 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353330 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353431 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353644 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353734 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353909 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353935 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1353967 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354000 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354117 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354140 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354262 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354325 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354382 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354485 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354549 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1354951 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo šaltas - V1 2
1355067 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355216 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355307 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355425 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355508 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355588 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355849 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1355957 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356109 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356177 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356243 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356332 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356487 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356553 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356655 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356765 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356846 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356914 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1356998 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1357069 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1357373 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1357553 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1357649 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1357715 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
