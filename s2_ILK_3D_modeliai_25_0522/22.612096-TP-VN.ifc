Properties of the parts of a building model (IFC2X3), part 2 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1158940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130700_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158270_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130761_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130771_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130828_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130771_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130772_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130771_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159218_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130772_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158696_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130814_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130828_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130814_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130840_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130840_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130900_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131060_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131235_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157224_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131235_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131265_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131259_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186883_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131265_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131313_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131304_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131320_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131376_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131312_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131313_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131312_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157004_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131312_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131320_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131354_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131376_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131354_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1243029_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1131501_0 | SOURCEANDSINK | K1 2
Port_1131580_3 | SOURCEANDSINK | K1 2
Port_1131501_1 | SOURCEANDSINK | K1 2
Port_1131631_1 | SOURCEANDSINK | K1 2
Port_1131580_1 | SOURCEANDSINK | K1 2
Port_1131581_1 | SOURCEANDSINK | K1 2
Port_1131588_0 | SOURCEANDSINK | K1 2
Port_1131645_2 | SOURCEANDSINK | K1 2
Port_1131588_1 | SOURCEANDSINK | K1 2
Port_1131631_2 | SOURCEANDSINK | K1 2
Port_1131639_0 | SOURCEANDSINK | K1 2
Port_1131645_1 | SOURCEANDSINK | K1 2
Port_1131639_1 | SOURCEANDSINK | K1 2
Port_1131659_1 | SOURCEANDSINK | K1 2
Port_1131653_0 | SOURCEANDSINK | K1 2
Port_1131659_2 | SOURCEANDSINK | K1 2
Port_1131653_1 | SOURCEANDSINK | K1 2
Port_1131673_2 | SOURCEANDSINK | K1 2
Port_1131673_1 | SOURCEANDSINK | K1 2
Port_1131841_0 | SOURCEANDSINK | K1 2
Port_1131966_2 | SOURCEANDSINK | K1 2
Port_1131841_1 | SOURCEANDSINK | K1 2
Port_1131923_0 | SOURCEANDSINK | K1 2
Port_1131925_2 | SOURCEANDSINK | K1 2
Port_1131923_1 | SOURCEANDSINK | K1 2
Port_1131966_1 | SOURCEANDSINK | K1 2
Port_1131925_1 | SOURCEANDSINK | K1 2
Port_1132281_0 | SOURCEANDSINK | K1 2
Port_1196285_2 | SOURCEANDSINK | K1 2
Port_1132281_1 | SOURCEANDSINK | K1 2
Port_1132344_1 | SOURCEANDSINK | K1 2
Port_1132338_0 | SOURCEANDSINK | K1 2
Port_1132344_2 | SOURCEANDSINK | K1 2
Port_1132338_1 | SOURCEANDSINK | K1 2
Port_1132475_1 | SOURCEANDSINK | K1 2
Port_1132473_0 | SOURCEANDSINK | K1 2
Port_1132475_2 | SOURCEANDSINK | K1 2
Port_1132473_1 | SOURCEANDSINK | K1 2
OutPort_1132644_1 | SOURCE
Port_1139352_0 | SOURCEANDSINK | K1 2
Port_1139426_2 | SOURCEANDSINK | K1 2
Port_1139352_1 | SOURCEANDSINK | K1 2
Port_1139521_1 | SOURCEANDSINK | K1 2
Port_1139416_1 | SOURCEANDSINK | K1 2
Port_1139417_1 | SOURCEANDSINK | K1 2
Port_1139416_2 | SOURCEANDSINK | K1 2
Port_1196286_0 | SOURCEANDSINK | K1 2
Port_1139416_3 | SOURCEANDSINK | K1 2
Port_1139426_1 | SOURCEANDSINK | K1 2
Port_1139432_0 | SOURCEANDSINK | K1 2
Port_1139562_2 | SOURCEANDSINK | K1 2
Port_1139432_1 | SOURCEANDSINK | K1 2
Port_1139519_0 | SOURCEANDSINK | K1 2
Port_1139521_2 | SOURCEANDSINK | K1 2
Port_1139519_1 | SOURCEANDSINK | K1 2
Port_1139562_1 | SOURCEANDSINK | K1 2
Port_1139644_0 | SOURCEANDSINK | K1 2
Port_1139658_2 | SOURCEANDSINK | K1 2
Port_1139644_1 | SOURCEANDSINK | K1 2
Port_1139670_1 | SOURCEANDSINK | K1 2
Port_1139650_1 | SOURCEANDSINK | K1 2
Port_1139651_1 | SOURCEANDSINK | K1 2
Port_1139650_3 | SOURCEANDSINK | K1 2
Port_1139658_1 | SOURCEANDSINK | K1 2
Port_1139664_0 | SOURCEANDSINK | K1 2
Port_1139670_2 | SOURCEANDSINK | K1 2
Port_1139664_1 | SOURCEANDSINK | K1 2
Port_1139794_1 | SOURCEANDSINK | K1 2
Port_1139711_0 | SOURCEANDSINK | K1 2
Port_1139802_2 | SOURCEANDSINK | K1 2
Port_1139711_1 | SOURCEANDSINK | K1 2
Port_1139792_0 | SOURCEANDSINK | K1 2
Port_1139794_2 | SOURCEANDSINK | K1 2
Port_1139792_1 | SOURCEANDSINK | K1 2
Port_1139802_1 | SOURCEANDSINK | K1 2
Port_1140002_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140044_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140060_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140045_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140044_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140671_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140054_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140074_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140068_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140074_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140068_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140088_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140082_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140088_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140082_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140171_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140096_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140179_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140096_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140169_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140171_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140169_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140179_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140662_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140670_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140662_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140670_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140671_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141262_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141362_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141370_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141362_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141370_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1856850_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141405_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141432_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141405_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141422_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141424_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141432_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141637_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141856_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141854_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141856_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141854_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
OutPort_1142121_1 | SOURCE
Port_1142807_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142815_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142807_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142815_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143117_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143125_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143117_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143161_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143147_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143161_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143147_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143209_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143167_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143205_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143167_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143209_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143187_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143191_3 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143187_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143199_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143188_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143199_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143188_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143205_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143191_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143192_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143191_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143237_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143429_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143496_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143429_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143496_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143902_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143759_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143761_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143759_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
OutPort_1143851_1 | SOURCE
Port_1143891_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143911_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143891_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143901_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143911_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143917_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143995_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143917_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143979_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143981_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143995_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144028_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144030_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144028_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144104_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144117_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144137_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144117_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144128_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144127_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144137_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144143_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144149_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144190_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144238_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144230_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144232_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144230_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144300_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144391_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144399_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144391_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144452_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144399_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144399_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144533_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144460_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144450_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144452_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144518_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144532_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144518_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144571_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144533_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144532_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144652_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144542_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144542_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144571_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144652_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144651_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145032_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145036_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145167_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145175_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145181_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145232_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145238_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145297_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145399_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145297_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145369_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145397_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145399_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145397_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145399_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145400_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145446_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145407_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145446_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145821_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145470_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145820_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145739_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145608_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145614_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145608_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145704_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145644_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145712_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145702_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145704_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145702_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145712_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145820_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145820_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145852_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145942_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145940_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145942_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
OutPort_1146003_1 | SOURCE
Port_1146344_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1150799_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
OutPort_1150923_1 | SOURCE
OutPort_1150936_1 | SOURCE
OutPort_1150948_1 | SOURCE
OutPort_1150958_1 | SOURCE
OutPort_1150970_1 | SOURCE
OutPort_1150980_1 | SOURCE
OutPort_1150992_1 | SOURCE
OutPort_1151002_1 | SOURCE
OutPort_1151054_1 | SOURCE
OutPort_1151136_1 | SOURCE
OutPort_1151165_1 | SOURCE
OutPort_1151180_1 | SOURCE
OutPort_1151194_1 | SOURCE
OutPort_1151237_1 | SOURCE
OutPort_1151251_1 | SOURCE
OutPort_1151269_1 | SOURCE
OutPort_1151279_1 | SOURCE
OutPort_1151299_1 | SOURCE
OutPort_1151345_1 | SOURCE
OutPort_1151360_1 | SOURCE
OutPort_1151384_1 | SOURCE
Port_1151744_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151773_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185440_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151773_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152441_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151781_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187723_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151781_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153323_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151881_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151895_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151881_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151889_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153048_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151889_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151889_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151895_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151936_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151958_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1243023_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151994_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152002_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152080_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152002_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152003_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152003_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152072_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152080_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152265_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185439_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152265_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152371_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152423_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152432_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152464_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152432_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152691_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152817_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152440_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152441_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152440_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152464_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152691_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152808_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152824_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152816_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152817_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152816_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152824_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152830_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152960_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152942_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152942_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152960_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152944_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155365_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153039_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153047_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153077_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153047_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153532_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153047_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153071_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153201_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153071_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153091_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153077_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186409_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153085_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153105_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153099_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153105_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153099_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153165_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153113_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153171_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153163_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153165_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153163_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153171_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153193_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153201_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153193_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153202_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153202_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186408_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153209_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153209_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153292_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153294_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153323_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153718_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153331_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156122_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153331_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155105_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153521_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186561_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153521_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153547_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153531_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153531_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186562_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153541_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153541_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153555_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153612_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153555_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153604_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153606_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153604_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153612_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 21
Port_1153634_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 21
Port_1153718_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153731_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153718_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154238_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1153731_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154149_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154155_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154207_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154155_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154197_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155833_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154199_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155731_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154229_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154237_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154237_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1154237_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156338_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155035_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155037_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155105_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155113_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155211_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155209_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155211_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155209_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155288_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155365_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155518_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155401_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155409_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155401_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155498_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155490_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155498_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155526_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155504_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155518_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155504_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155526_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155731_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155825_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155833_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155847_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155841_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155847_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155841_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155853_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155867_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155875_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155940_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155948_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156058_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155949_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155948_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156123_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1155949_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156337_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156056_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156058_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156056_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156122_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156123_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156122_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156146_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156146_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156160_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156154_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156160_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156180_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156174_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156180_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156174_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156212_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156188_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156212_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156188_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156218_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156224_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156329_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156337_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156329_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156353_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156338_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156347_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186659_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156347_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186660_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156361_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156409_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156361_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156401_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156403_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156401_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 22
Port_1156430_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 22
Port_1156488_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156496_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156488_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156533_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156554_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156566_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156554_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156582_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156566_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156566_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186884_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156567_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156811_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156576_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156582_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156576_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156590_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156699_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156590_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156691_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156693_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156691_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156699_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 23
Port_1156733_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 23
Port_1156801_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156811_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156801_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156843_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156812_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157003_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156835_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156843_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156855_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156849_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156855_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156849_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156863_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156869_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156863_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156881_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156875_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156881_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156946_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157003_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1156946_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157003_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157004_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157028_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157036_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157028_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157210_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157224_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157210_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157225_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157254_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157262_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157281_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157289_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157281_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157320_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157289_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157290_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157312_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157320_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157312_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157326_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157332_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157340_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157346_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157340_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157358_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157352_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157358_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157352_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187124_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157506_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157491_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157490_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187125_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157491_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158110_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157500_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157506_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157500_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157950_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157935_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157956_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157935_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157950_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157956_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157999_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 24
Port_1157999_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 24
Port_1158102_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158110_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158102_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158126_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158110_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158111_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158120_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187256_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158188_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158126_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187257_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158194_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158186_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158188_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158186_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158222_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 25
Port_1158222_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 25
Port_1158269_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158269_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158542_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158269_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158277_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158277_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158329_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158321_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158329_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158321_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158341_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158335_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158341_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158373_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158349_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158373_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158349_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158379_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158385_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158399_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158393_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158399_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158393_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158405_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158405_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158533_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158541_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158533_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158635_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158541_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158542_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158541_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158697_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158633_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158635_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158633_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158696_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158729_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158696_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158697_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158721_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158729_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158721_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158741_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158741_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158749_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158749_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158817_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158811_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158817_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158829_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158823_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158829_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158823_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158843_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158837_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158843_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158837_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158873_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158849_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158873_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158849_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158932_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187474_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158932_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159011_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159091_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159009_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159011_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159009_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159059_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159068_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159090_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159068_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159106_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159090_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187475_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159100_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159106_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159100_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159159_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159114_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159165_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159114_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159157_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159159_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159165_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159186_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 26
Port_1159186_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 26
Port_1159209_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159217_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159209_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159217_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
OutPort_1159398_1 | SOURCE
OutPort_1159446_1 | SOURCE
OutPort_1159459_1 | SOURCE
OutPort_1159475_1 | SOURCE
OutPort_1159495_1 | SOURCE
OutPort_1159511_1 | SOURCE
OutPort_1159525_1 | SOURCE
Port_1159564_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160316_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159564_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159590_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159578_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159578_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160903_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159584_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159732_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159584_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159636_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159590_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160016_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159634_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159636_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159718_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159732_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159718_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159733_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159847_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159742_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159748_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159798_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159756_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159804_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159756_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159796_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159798_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159835_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159847_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159847_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160015_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159857_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159977_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159857_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159969_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159971_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159969_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159977_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159999_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160015_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159999_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160031_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160015_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160072_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160078_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160137_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160129_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160131_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160129_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160137_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160306_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160316_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160306_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160317_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160427_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160326_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160332_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160391_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160340_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160397_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160340_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160389_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160391_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160389_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160397_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160419_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160427_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160419_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160518_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160427_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160428_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160428_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160613_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160435_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160526_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160435_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160516_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160518_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160516_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160526_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160605_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160613_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160605_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160627_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160614_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160732_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160682_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160635_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160688_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160635_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160680_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
