Properties of the parts of a building model (IFC2X3), part 54 of 57

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1409273 | 1 a +-152.84 | 3494.41 | 3292.3 | vanduo šaltas - V1 2
1409276 | 1 a +-152.84 | 80 | 642.299 | vanduo šaltas - V1 2
1409306 | 1 a +-152.84 | 2610 | 670 | vanduo šaltas - V1 2
1410069 | 1 a +-152.84 | 121 | 3454.5 | vanduo šaltas - V1 2
1410082 | 2 a | 2952.43 | 3450 | vanduo šaltas - V1 2
1410097 | 1 a +-152.84 | 10264 | 3094.5 | vanduo šaltas - V1 2
1410317 | 1 a +-152.84 | 264 | 3168 | vanduo šaltas - V1 2
1410399 | 1 a +-152.84 | 3831.4 | -759.399 | vanduo šaltas - V1 2
1410627 | 0 a | 4464.65 | -832.9 | vanduo šaltas - V1 2
1410637 | 0 a | 292.759 | -832.9 | vanduo šaltas - V1 2
1411050 | 0 a | 84 | -832.9 | vanduo šaltas - V1 2
1411136 | 0 a | 4190.9 | -759.399 | vanduo šaltas - V1 2
1411390 | 0 a | 324 | 3454 | vanduo šaltas - V1 2
1411440 | 1 a +-152.84 | 666.429 | 3454.03 | vanduo šaltas - V1 2
1411521 | 2 a | 602.82 | 3450 | vanduo šaltas - V1 2
1411529 | 2 a | 8020.06 | 3450 | vanduo šaltas - V1 2
1419836 | 0 a | 93.3617 | -815.1 | vanduo šaltas - V1 2
1419892 | 0 a | 840.48 | -834.499 | vanduo šaltas - V1 6
1419923 | 0 a | 178.04 | -3311.66 | vanduo šaltas - V1 6
1419941 | 0 a | 2432.8 | -3280 | vanduo šaltas - V1 6
1420369 | 0 a | 1544.94 | -832.9 | vanduo šaltas - V1 2
1420429 | 0 a | 645.933 | -832.9 | vanduo šaltas - V1 2
1420455 | 0 a | 120.072 | -817.899 | vanduo šaltas - V1 2
1420464 | 0 a | 159.339 | -815.1 | vanduo šaltas - V1 2
1420479 | 0 a | 300.108 | -824.7 | vanduo šaltas - V1 2
1420490 | 0 a | 1000.29 | -845.501 | vanduo šaltas - V1 2
1420500 | 0 a | 120.028 | -3310.5 | vanduo šaltas - V1 2
1420559 | 0 a | 2421.8 | -3280 | vanduo šaltas - V1 2
1420631 | 0 a | 520.112 | -827.897 | vanduo šaltas - V1 2
1420640 | 0 a | 112.339 | -815.1 | vanduo šaltas - V1 2
1420655 | 0 a | 180.044 | -832.297 | vanduo šaltas - V1 2
1420665 | 0 a | 280.064 | -838.699 | vanduo šaltas - V1 2
1420676 | 0 a | 120.028 | -3310.5 | vanduo šaltas - V1 2
1420743 | 0 a | 2428.6 | -3280 | vanduo šaltas - V1 2
1420774 | 0 a | 380.136 | -828.298 | vanduo šaltas - V1 2
1420787 | 0 a | 1979.55 | -832.9 | vanduo šaltas - V1 2
1420830 | 0 a | 180.04 | -3311.7 | vanduo šaltas - V1 2
1420898 | 0 a | 2439 | -3280 | vanduo šaltas - V1 2
1420921 | 0 a | 800.22 | -836.698 | vanduo šaltas - V1 2
1420940 | 0 a | 428.28 | -832.9 | vanduo šaltas - V1 2
1420947 | 0 a | 200.044 | -3162.1 | vanduo šaltas - V1 2
1421019 | 0 a | 2280.6 | -3130 | vanduo šaltas - V1 2
1421038 | 0 a | 360.132 | -827.898 | vanduo šaltas - V1 2
1421051 | 0 a | 350.336 | -832.9 | vanduo šaltas - V1 2
1421058 | 0 a | 140.032 | -3310.9 | vanduo šaltas - V1 2
1421113 | 0 a | 2439.4 | -3280 | vanduo šaltas - V1 2
1421132 | 0 a | 2560.57 | -871.898 | vanduo šaltas - V1 2
1421147 | 0 a | 331.07 | -832.9 | vanduo šaltas - V1 2
1421154 | 0 a | 1100.27 | -894.699 | vanduo šaltas - V1 2
1421164 | 0 a | 135.393 | -3310.81 | vanduo šaltas - V1 2
1421220 | 0 a | 2372.6 | -3280 | vanduo šaltas - V1 2
1421253 | 0 a | 380.136 | -830.297 | vanduo šaltas - V1 2
1421268 | 0 a | 374.872 | -832.9 | vanduo šaltas - V1 2
1421275 | 0 a | 140.032 | -3310.9 | vanduo šaltas - V1 2
1421331 | 0 a | 2437 | -3280 | vanduo šaltas - V1 2
1421350 | 0 a | 1100.24 | -842.697 | vanduo šaltas - V1 2
1421361 | 0 a | 403.428 | -832.9 | vanduo šaltas - V1 2
1421368 | 0 a | 200.048 | -847.497 | vanduo šaltas - V1 2
1421378 | 0 a | 180.04 | -3311.7 | vanduo šaltas - V1 2
1421460 | 0 a | 2419.8 | -3280 | vanduo šaltas - V1 2
1421481 | 0 a | 1516.87 | -945.497 | vanduo šaltas - V1 2
1421496 | 0 a | 372 | -832.9 | vanduo šaltas - V1 2
1421503 | 0 a | 680.144 | -959.897 | vanduo šaltas - V1 2
1421513 | 0 a | 160.036 | -3311.3 | vanduo šaltas - V1 2
1421599 | 0 a | 2307.4 | -3280 | vanduo šaltas - V1 2
1421684 | 0 a | 180.044 | -918.766 | vanduo šaltas - V1 2
1421693 | 0 a | 1717.39 | -914.366 | vanduo šaltas - V1 2
1421708 | 0 a | 80.02 | -3309.7 | vanduo šaltas - V1 2
1421793 | 0 a | 2348.53 | -3280 | vanduo šaltas - V1 2
1421816 | 0 a | 180 | -879.627 | vanduo šaltas - V1 2
1421827 | 0 a | 2827.03 | -879.225 | vanduo šaltas - V1 2
1421830 | 0 a | 140 | -3607.7 | vanduo šaltas - V1 2
1421902 | 0 a | 2688.07 | -3580 | vanduo šaltas - V1 2
1421923 | 0 a | 379.96 | -815.1 | vanduo šaltas - V1 2
1421932 | 0 a | 2730.14 | -832.9 | vanduo šaltas - V1 2
1421939 | 0 a | 160 | -3307.7 | vanduo šaltas - V1 2
1422011 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1422032 | 0 a | 359.96 | -815.1 | vanduo šaltas - V1 2
1422049 | 0 a | 963.966 | -832.9 | vanduo šaltas - V1 2
1422056 | 0 a | 160 | -3307.7 | vanduo šaltas - V1 2
1422133 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1422163 | 0 a | 3580.04 | -815.1 | vanduo šaltas - V1 2
1422172 | 0 a | 3464.42 | -832.9 | vanduo šaltas - V1 2
1422179 | 0 a | 120 | -815.1 | vanduo šaltas - V1 2
1422189 | 0 a | 200 | -3307.7 | vanduo šaltas - V1 2
1422241 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1422269 | 0 a | 379.96 | -815.1 | vanduo šaltas - V1 2
1422282 | 0 a | 587.415 | -832.9 | vanduo šaltas - V1 2
1422289 | 0 a | 200 | -3307.7 | vanduo šaltas - V1 2
1422349 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1422375 | 0 a | 135.453 | -815.1 | vanduo šaltas - V1 2
1422394 | 0 a | 464.061 | -832.9 | vanduo šaltas - V1 2
1422401 | 0 a | 330 | -815.1 | vanduo šaltas - V1 2
1422411 | 0 a | 120 | -3307.7 | vanduo šaltas - V1 2
1422465 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1422603 | 0 a | 480 | -817.099 | vanduo šaltas - V1 2
1422612 | 0 a | 224.507 | -815.1 | vanduo šaltas - V1 2
1422615 | 0 a | 120 | -817.099 | vanduo šaltas - V1 2
1422623 | 0 a | 180 | -3307.7 | vanduo šaltas - V1 2
1422697 | 0 a | 2450.6 | -3280 | vanduo šaltas - V1 2
1422723 | 0 a | 180 | -815.1 | vanduo šaltas - V1 2
1422736 | 0 a | 1559.76 | -832.9 | vanduo šaltas - V1 2
1422743 | 0 a | 400 | -815.1 | vanduo šaltas - V1 2
1422753 | 0 a | 120 | -3307.7 | vanduo šaltas - V1 2
1422807 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1422849 | 0 a | 520 | -817.099 | vanduo šaltas - V1 2
1422858 | 0 a | 179.96 | -815.1 | vanduo šaltas - V1 2
1422861 | 0 a | 160 | -817.099 | vanduo šaltas - V1 2
1422869 | 0 a | 100 | -3307.7 | vanduo šaltas - V1 2
1422945 | 0 a | 2450.6 | -3280 | vanduo šaltas - V1 2
1422987 | 0 a | 3400.04 | -815.1 | vanduo šaltas - V1 2
1423006 | 0 a | 3308.48 | -832.9 | vanduo šaltas - V1 2
1423013 | 0 a | 100 | -815.1 | vanduo šaltas - V1 2
1423023 | 0 a | 220 | -3307.7 | vanduo šaltas - V1 2
1423069 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1423141 | 0 a | 180 | -815.1 | vanduo šaltas - V1 2
1423169 | 0 a | 637.593 | -832.9 | vanduo šaltas - V1 2
1423196 | 0 a | 3511.8 | -832.9 | vanduo šaltas - V1 2
1423210 | 0 a | 680 | -815.1 | vanduo šaltas - V1 2
1423224 | 0 a | 525 | -815.1 | vanduo šaltas - V1 2
1423234 | 0 a | 115 | -3307.7 | vanduo šaltas - V1 2
1423303 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1423357 | 0 a | 268.175 | -832.9 | vanduo šaltas - V1 2
1423364 | 0 a | 1440 | -815.1 | vanduo šaltas - V1 2
1423400 | 0 a | 1020 | -815.1 | vanduo šaltas - V1 2
1423408 | 0 a | 140 | -3307.7 | vanduo šaltas - V1 2
1423467 | 0 a | 2452.6 | -3280 | vanduo šaltas - V1 2
1423520 | 0 a | 2980 | -817.099 | vanduo šaltas - V1 2
1423533 | 0 a | 3511.76 | -832.9 | vanduo šaltas - V1 2
1423540 | 0 a | 1140 | -817.099 | vanduo šaltas - V1 2
1423551 | 0 a | 120 | -3307.7 | vanduo šaltas - V1 2
1423610 | 0 a | 2450.6 | -3280 | vanduo šaltas - V1 2
1423661 | 0 a | 6426.22 | -970 | vanduo šaltas - V1 2
1423676 | 0 a | 2881.23 | -970 | vanduo šaltas - V1 2
1423679 | 0 a | 16752 | -953 | vanduo šaltas - V1 2
1423687 | 0 a | 425.319 | -953 | vanduo šaltas - V1 2
1423738 | 0 a | 780 | -950 | vanduo šaltas - V1 2
1423778 | 0 a | 2628.82 | -970 | vanduo šaltas - V1 2
1423799 | 0 a | 1177 | -953 | vanduo šaltas - V1 2
1423825 | 0 a | 830.955 | -970 | vanduo šaltas - V1 2
1423828 | 0 a | 3648 | -953 | vanduo šaltas - V1 2
1423840 | 0 a | 474 | -953 | vanduo šaltas - V1 2
1424019 | 0 a | 8684 | -822.399 | vanduo šaltas - V1 2
1424034 | 0 a | 271.352 | -832.9 | vanduo šaltas - V1 2
1424076 | 0 a | 6803.96 | -820.4 | vanduo šaltas - V1 2
1424091 | 0 a | 2647.51 | -832.9 | vanduo šaltas - V1 2
1424143 | 0 a | 6823.96 | -820.4 | vanduo šaltas - V1 2
1424160 | 0 a | 312.664 | -832.9 | vanduo šaltas - V1 2
1424185 | 0 a | 3497.96 | -820.4 | vanduo šaltas - V1 2
1424202 | 0 a | 2665.21 | -832.9 | vanduo šaltas - V1 2
1424207 | 0 a | 1648 | -820.4 | vanduo šaltas - V1 2
1424245 | 0 a | 3348 | -820.4 | vanduo šaltas - V1 2
1424253 | 0 a | 390.002 | -820.4 | vanduo šaltas - V1 2
1424277 | 0 a | 5997.96 | -820.4 | vanduo šaltas - V1 2
1424302 | 0 a | 2031.88 | -832.9 | vanduo šaltas - V1 2
1424307 | 0 a | 850.061 | -820.4 | vanduo šaltas - V1 2
1424317 | 0 a | 982.478 | -820.4 | vanduo šaltas - V1 2
1424349 | 0 a | 2198 | -820.4 | vanduo šaltas - V1 2
1424358 | 0 a | 405.374 | -832.9 | vanduo šaltas - V1 2
1424363 | 0 a | 1748 | -820.4 | vanduo šaltas - V1 2
1424371 | 0 a | 1848 | -820.4 | vanduo šaltas - V1 2
1424381 | 0 a | 674 | -820.4 | vanduo šaltas - V1 2
1424401 | 0 a | 2398 | -820.4 | vanduo šaltas - V1 2
1424410 | 0 a | 1432.63 | -832.9 | vanduo šaltas - V1 2
1424415 | 0 a | 2874 | -820.4 | vanduo šaltas - V1 2
1424448 | 0 a | 6104.04 | -832.9 | vanduo šaltas - V1 2
1424455 | 0 a | 4335.08 | -832.9 | vanduo šaltas - V1 2
1424458 | 0 a | 1304 | -832.9 | vanduo šaltas - V1 2
1424468 | 0 a | 573.456 | -832.9 | vanduo šaltas - V1 2
1424488 | 0 a | 7525 | -953 | vanduo šaltas - V1 2
1424503 | 0 a | 437.686 | -970 | vanduo šaltas - V1 2
1424506 | 0 a | 598.582 | -953 | vanduo šaltas - V1 2
1424536 | 0 a | 7425 | -953 | vanduo šaltas - V1 2
1424551 | 0 a | 5327.42 | -970 | vanduo šaltas - V1 2
1424554 | 0 a | 282.146 | -953 | vanduo šaltas - V1 2
1424579 | 0 a | 7425 | -953 | vanduo šaltas - V1 2
1424588 | 0 a | 6141.96 | -970 | vanduo šaltas - V1 2
1424591 | 0 a | 374 | -953 | vanduo šaltas - V1 2
1424629 | 0 a | 6279.96 | -970 | vanduo šaltas - V1 2
1424632 | 0 a | 7440.96 | -953 | vanduo šaltas - V1 2
1424686 | 0 a | 134 | -953 | vanduo šaltas - V1 2
1424718 | 0 a | 3672.05 | -970 | vanduo šaltas - V1 2
1424721 | 0 a | 7440 | -953 | vanduo šaltas - V1 2
1424727 | 0 a | 124 | -953 | vanduo šaltas - V1 2
1424748 | 1 a +-152.84 | 3941.6 | 3947 | vanduo šaltas - V1 2
1424763 | 1 a +-152.84 | 405 | 3529 | vanduo šaltas - V1 2
1424766 | 2 a | 242.738 | 3450 | vanduo šaltas - V1 2
1424773 | 1 a +-152.84 | 1128 | 3947 | vanduo šaltas - V1 2
1424783 | 1 a +-152.84 | 234.237 | 3947 | vanduo šaltas - V1 2
1424805 | 1 a +-152.84 | 1094 | 3947 | vanduo šaltas - V1 2
1424818 | 1 a +-152.84 | 8665.74 | 3947 | vanduo šaltas - V1 2
1424833 | 1 a +-152.84 | 1094 | 3947 | vanduo šaltas - V1 2
1424842 | 1 a +-152.84 | 3779.87 | 3947 | vanduo šaltas - V1 2
1424859 | 1 a +-152.84 | 1068 | 3947 | vanduo šaltas - V1 2
1424868 | 1 a +-152.84 | 804.792 | 3947 | vanduo šaltas - V1 2
1424871 | 1 a +-152.84 | 538.717 | 3947 | vanduo šaltas - V1 2
1424891 | 1 a +-152.84 | 3973.16 | 3467 | vanduo šaltas - V1 2
1424918 | 2 a | 2706.1 | 3450 | vanduo šaltas - V1 2
1424921 | 1 a +-152.84 | 1392.74 | 3467 | vanduo šaltas - V1 2
1424949 | 1 a +-152.84 | 1335.69 | 3467 | vanduo šaltas - V1 2
1424958 | 1 a +-152.84 | 4345.7 | 3467 | vanduo šaltas - V1 2
1424979 | 1 a +-152.84 | 1382.1 | 3467 | vanduo šaltas - V1 2
1424988 | 1 a +-152.84 | 4293.04 | 3467 | vanduo šaltas - V1 2
1425029 | 1 a +-152.84 | 1367.72 | 3467 | vanduo šaltas - V1 2
1425038 | 1 a +-152.84 | 4602.13 | 3467 | vanduo šaltas - V1 2
1425091 | 1 a +-152.84 | 1341.72 | 3467 | vanduo šaltas - V1 2
1425100 | 1 a +-152.84 | 4288.48 | 3467 | vanduo šaltas - V1 2
1425103 | 1 a +-152.84 | 134 | 3467 | vanduo šaltas - V1 2
1425174 | 1 a +-152.84 | 1367.72 | 3467 | vanduo šaltas - V1 2
1425187 | 1 a +-152.84 | 3862.48 | 3467 | vanduo šaltas - V1 2
1425202 | 1 a +-152.84 | 10351 | 3947 | vanduo šaltas - V1 2
1425219 | 2 a | 10281 | 3930 | vanduo šaltas - V1 2
1425298 | 1 a +-152.84 | 4046.4 | 3947 | vanduo šaltas - V1 2
1425317 | 1 a +-152.84 | 405 | 3529 | vanduo šaltas - V1 2
1425320 | 2 a | 9.00138 | 3450 | vanduo šaltas - V1 2
1425327 | 1 a +-152.84 | 1014 | 3947 | V1 1
1425410 | 1 a +-152.84 | 1014 | 3947 | vanduo šaltas - V1 2
1425419 | 1 a +-152.84 | 3641.49 | 3947 | vanduo šaltas - V1 2
1425435 | 1 a +-152.84 | 1014 | 3947 | vanduo šaltas - V1 2
1425444 | 1 a +-152.84 | 4108.75 | 3947 | vanduo šaltas - V1 2
1425459 | 1 a +-152.84 | 1014 | 3947 | vanduo šaltas - V1 2
1425468 | 1 a +-152.84 | 169.643 | 3947 | vanduo šaltas - V1 2
1425483 | 1 a +-152.84 | 374 | 3947 | vanduo šaltas - V1 2
1425492 | 1 a +-152.84 | 3937.21 | 3947 | vanduo šaltas - V1 2
1425507 | 1 a +-152.84 | 988 | 3947 | vanduo šaltas - V1 2
1425516 | 1 a +-152.84 | 4084.51 | 3947 | vanduo šaltas - V1 2
1425519 | 1 a +-152.84 | 144.444 | 3947 | vanduo šaltas - V1 2
1425541 | 1 a +-152.84 | 9665 | 3767 | vanduo šaltas - V1 2
1425558 | 2 a | 611.366 | 3750 | vanduo šaltas - V1 2
1425561 | 1 a +-152.84 | 1334 | 3767 | vanduo šaltas - V1 2
1425584 | 1 a +-152.84 | 6825 | 3467 | vanduo šaltas - V1 2
1425597 | 0 a | 300.433 | 3450 | vanduo šaltas - V1 2
1425600 | 1 a +-152.84 | 22274 | 3467 | vanduo šaltas - V1 2
1425694 | 0 a | 6198 | -970 | vanduo šaltas - V1 2
1425709 | 0 a | 8171.26 | -970 | vanduo šaltas - V1 2
1425712 | 0 a | 429 | -970 | vanduo šaltas - V1 2
1425737 | 0 a | 5598 | -970 | vanduo šaltas - V1 2
1425746 | 0 a | 3386.82 | -970 | vanduo šaltas - V1 2
1425749 | 0 a | 2049 | -970 | vanduo šaltas - V1 2
1425775 | 0 a | 1849 | -1060 | vanduo karštas tiekiamasis - T3 1
1425784 | 0 a | 5398 | -1060 | vanduo karštas tiekiamasis - T3 1
1425866 | 0 a | 32118 | -1060 | vanduo karštas tiekiamasis - T3 1
1425874 | 0 a | 2839.36 | -1060 | vanduo karštas tiekiamasis - T3 1
1426026 | 0 a | 9749 | -1060 | vanduo karštas tiekiamasis - T3 1
1426034 | 0 a | 4488 | -979 | vanduo karštas tiekiamasis - T3 1
1426302 | 0 a | 1908.75 | 3530 | vanduo karštas tiekiamasis - T3 1
1426376 | 1 a +-152.84 | 1118 | 3530 | vanduo karštas tiekiamasis - T3 1
1426552 | 1 a +-152.84 | 3990 | 3611 | vanduo karštas tiekiamasis - T3 1
1426560 | 1 a +-152.84 | 185.499 | 7618 | vanduo karštas tiekiamasis - T3 1
1426652 | 1 a +-152.84 | 2942.19 | 3530 | vanduo karštas tiekiamasis - T3 1
1426661 | 0 a | 7796.86 | 3530 | vanduo karštas tiekiamasis - T3 1
1426704 | 1 a +-152.84 | 498.111 | 3530 | vanduo karštas tiekiamasis - T3 1
1426713 | 1 a +-152.84 | 344.596 | 3530 | vanduo karštas tiekiamasis - T3 1
1426717 | 0 a | 3646.59 | 3530 | vanduo karštas tiekiamasis - T3 1
1426723 | 1 a +-152.84 | 617.314 | 3530 | vanduo karštas tiekiamasis - T3 1
1426735 | 1 a +-152.84 | 688 | 2821 | vanduo karštas tiekiamasis - T3 1
1426745 | 1 a +-152.84 | 238 | 2740 | vanduo karštas tiekiamasis - T3 1
1426755 | 1 a +-152.84 | 3698 | -979 | vanduo karštas tiekiamasis - T3 1
1426768 | 1 a +-152.84 | 109 | -1060 | vanduo karštas tiekiamasis - T3 1
1426771 | 0 a | 3596.64 | -1060 | vanduo karštas tiekiamasis - T3 1
1426996 | 1 a +-152.84 | 185 | -878.001 | vanduo karštas tiekiamasis - T3 2
1427023 | 0 a | 128 | -878.001 | vanduo karštas tiekiamasis - T3 2
1427041 | 0 a | 8333.12 | -878.001 | vanduo karštas tiekiamasis - T3 2
1427129 | 1 a +-152.84 | 74 | -885.042 | vanduo karštas tiekiamasis - T3 1
1427136 | 1 a +-152.84 | 4323.54 | -811.541 | vanduo karštas tiekiamasis - T3 1
1427718 | 0 a | 4624 | -885.042 | vanduo karštas tiekiamasis - T3 1
1427728 | 0 a | 284 | -885.042 | vanduo karštas tiekiamasis - T3 1
1427762 | 0 a | 184 | -885.042 | vanduo karštas tiekiamasis - T3 1
1427802 | 0 a | 4574 | -811.541 | vanduo karštas tiekiamasis - T3 1
1427862 | 1 a +-152.84 | 404 | 3784.96 | vanduo karštas tiekiamasis - T3 1
1427870 | 1 a +-152.84 | 879 | 3784.96 | vanduo karštas tiekiamasis - T3 1
1427879 | 1 a +-152.84 | 151.459 | 3611 | vanduo karštas tiekiamasis - T3 1
1427882 | 1 a +-152.84 | 625.809 | 3530 | vanduo karštas tiekiamasis - T3 1
1427896 | 0 a | 480.013 | -867.242 | vanduo karštas tiekiamasis - T3 3
1427980 | 0 a | 1719.13 | -885.042 | vanduo karštas tiekiamasis - T3 1
1427987 | 0 a | 1260 | -867.242 | vanduo karštas tiekiamasis - T3 3
1427997 | 0 a | 100 | -3307.7 | vanduo karštas tiekiamasis - T3 3
1428032 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 3
1428054 | 0 a | 1240 | -867.242 | vanduo karštas tiekiamasis - T3 3
1428067 | 0 a | 170 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428070 | 0 a | 116.556 | -3307.7 | vanduo karštas tiekiamasis - T3 3
1428146 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 3
1428207 | 0 a | 4176.43 | -885.042 | vanduo karštas tiekiamasis - T3 1
1428488 | 0 a | 520 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428640 | 0 a | 1126.38 | -885.042 | vanduo karštas tiekiamasis - T3 1
1428689 | 0 a | 460 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428700 | 0 a | 835.727 | -885.042 | vanduo karštas tiekiamasis - T3 1
1428707 | 0 a | 120 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1428767 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1428791 | 0 a | 2740 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428808 | 0 a | 333.729 | -885.042 | vanduo karštas tiekiamasis - T3 1
1428815 | 0 a | 1240 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428825 | 0 a | 120 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1428904 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1428937 | 0 a | 1060 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428956 | 0 a | 879.199 | -885.042 | vanduo karštas tiekiamasis - T3 1
1428963 | 0 a | 330 | -867.242 | vanduo karštas tiekiamasis - T3 1
1428976 | 0 a | 100 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1429048 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1429236 | 0 a | 1638.21 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429253 | 0 a | 389.313 | -885.042 | vanduo karštas tiekiamasis - T3 1
1429260 | 0 a | 120 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429270 | 0 a | 80 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1429332 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1429354 | 0 a | 120 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429363 | 0 a | 2641.79 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429366 | 0 a | 80 | -3607.7 | vanduo karštas tiekiamasis - T3 1
1429442 | 0 a | 2700.46 | -3580 | vanduo karštas tiekiamasis - T3 1
1429471 | 0 a | 480 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429480 | 0 a | 3302.28 | -885.042 | vanduo karštas tiekiamasis - T3 1
1429487 | 0 a | 145.321 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1429555 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1429591 | 0 a | 3518 | -872.542 | vanduo karštas tiekiamasis - T3 1
1429654 | 0 a | 2627.73 | -885.042 | vanduo karštas tiekiamasis - T3 1
1429669 | 0 a | 1668 | -872.542 | vanduo karštas tiekiamasis - T3 1
1429679 | 0 a | 3328 | -872.542 | vanduo karštas tiekiamasis - T3 1
1429703 | 0 a | 294 | -872.542 | vanduo karštas tiekiamasis - T3 1
1429727 | 0 a | 480 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429738 | 0 a | 986.481 | -885.042 | vanduo karštas tiekiamasis - T3 1
1429745 | 0 a | 125.321 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1429809 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1429833 | 0 a | 3420 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429850 | 0 a | 3262.69 | -885.042 | vanduo karštas tiekiamasis - T3 1
1429857 | 0 a | 220 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429867 | 0 a | 80 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1429940 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1429968 | 0 a | 500 | -867.242 | vanduo karštas tiekiamasis - T3 1
1429981 | 0 a | 795.304 | -885.042 | vanduo karštas tiekiamasis - T3 1
1429988 | 0 a | 165.321 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1430069 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1430091 | 0 a | 142.827 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430114 | 0 a | 2522.7 | -885.042 | vanduo karštas tiekiamasis - T3 1
1430121 | 0 a | 37.0863 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430131 | 0 a | 50 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430223 | 0 a | 165 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1430234 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1430479 | 0 a | 10 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430492 | 0 a | 262.914 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430574 | 0 a | 290 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430583 | 0 a | 257.173 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430586 | 0 a | 120 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430594 | 0 a | 50 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1430642 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1430672 | 0 a | 180 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430691 | 0 a | 2388.46 | -885.042 | vanduo karštas tiekiamasis - T3 1
1430698 | 0 a | 57.9596 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430708 | 0 a | 220 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430719 | 0 a | 60 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1430768 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1430991 | 0 a | 275 | -867.242 | vanduo karštas tiekiamasis - T3 1
1430998 | 0 a | 317.04 | -867.242 | vanduo karštas tiekiamasis - T3 1
1431001 | 0 a | 90 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1431085 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1431115 | 0 a | 5884 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431132 | 0 a | 3556.82 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431135 | 0 a | 1104 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431145 | 0 a | 438.777 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431171 | 0 a | 3220 | -867.242 | vanduo karštas tiekiamasis - T3 1
1431192 | 0 a | 3113.63 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431235 | 0 a | 200 | -867.242 | vanduo karštas tiekiamasis - T3 1
1431245 | 0 a | 242.672 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1431352 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1431374 | 0 a | 2940 | -867.242 | vanduo karštas tiekiamasis - T3 1
1431383 | 0 a | 3489.83 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431390 | 0 a | 980 | -867.242 | vanduo karštas tiekiamasis - T3 1
1431398 | 0 a | 176.855 | -3307.7 | vanduo karštas tiekiamasis - T3 1
1431465 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 1
1431554 | 0 a | 2851.97 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431648 | 0 a | 3646.2 | -885.042 | vanduo karštas tiekiamasis - T3 1
1431668 | 0 a | 700 | -867.242 | vanduo karštas tiekiamasis - T3 4
1431678 | 0 a | 100 | -3307.7 | vanduo karštas tiekiamasis - T3 4
1431729 | 0 a | 2400.46 | -3280 | vanduo karštas tiekiamasis - T3 4
1431959 | 0 a | 1692 | -1055.5 | vanduo karštas apytakinis - T4 1
1432029 | 0 a | 5264 | -1055.5 | vanduo karštas apytakinis - T4 1
1432045 | 0 a | 31984 | -1055.5 | vanduo karštas apytakinis - T4 1
1432065 | 0 a | 2805.33 | -1055.5 | vanduo karštas apytakinis - T4 1
1432199 | 0 a | 9740 | -1055.5 | vanduo karštas apytakinis - T4 1
1432275 | 0 a | 3682.67 | -1055.5 | vanduo karštas apytakinis - T4 1
1432373 | 0 a | 3624 | -982 | vanduo karštas apytakinis - T4 1
1432381 | 0 a | 244 | 2664.5 | vanduo karštas apytakinis - T4 1
1432407 | 0 a | 714 | 2738 | vanduo karštas apytakinis - T4 1
1432510 | 1 a +-152.84 | 226.928 | 3530 | vanduo karštas tiekiamasis - T3 1
1432522 | 1 a +-152.84 | 298 | 3530 | vanduo karštas tiekiamasis - T3 1
1432532 | 1 a +-152.84 | 207 | 3530 | vanduo karštas tiekiamasis - T3 1
1432630 | 1 a +-152.84 | 2285.86 | 3474.5 | vanduo karštas apytakinis - T4 1
1432638 | 1 a +-152.84 | 324 | 3474.5 | vanduo karštas apytakinis - T4 1
1432648 | 1 a +-152.84 | 130.975 | 3474.5 | vanduo karštas apytakinis - T4 1
1432672 | 1 a +-152.84 | 34393.6 | 3474.5 | vanduo karštas apytakinis - T4 1
1432683 | 1 a +-152.84 | 5135.73 | 3474.5 | vanduo karštas apytakinis - T4 1
1432718 | 1 a +-152.84 | 3617.11 | 3474.5 | vanduo karštas apytakinis - T4 1
1432727 | 1 a +-152.84 | 12289.2 | 3474.5 | vanduo karštas apytakinis - T4 1
1432731 | 1 a +-152.84 | 11328.8 | 3474.5 | vanduo karštas apytakinis - T4 1
1432737 | 1 a +-152.84 | 13301.1 | 3474.5 | vanduo karštas apytakinis - T4 1
1432805 | 1 a +-152.84 | 8921 | 3474.5 | vanduo karštas apytakinis - T4 1
1432825 | 1 a +-152.84 | 1244 | 3474.5 | vanduo karštas apytakinis - T4 1
1432849 | 1 a +-152.84 | 10719 | 3474.5 | vanduo karštas apytakinis - T4 1
1432866 | 1 a +-152.84 | 2919.68 | 3474.5 | vanduo karštas apytakinis - T4 1
1432907 | 1 a +-152.84 | 72.9989 | 17447 | vanduo karštas tiekiamasis - T3 1
1432967 | 1 a +-152.84 | 155.795 | 17228.2 | vanduo karštas apytakinis - T4 1
1433068 | 1 a +-152.84 | 4014.4 | -562.399 | vanduo karštas apytakinis - T4 1
1433176 | 1 a +-152.84 | 43 | -774.9 | vanduo karštas apytakinis - T4 1
1433332 | 1 a +-152.84 | 116 | -892.399 | vanduo karštas apytakinis - T4 1
1433571 | 1 a +-152.84 | 36 | -924.4 | vanduo karštas apytakinis - T4 1
1433618 | 0 a | 106 | -924.4 | vanduo karštas apytakinis - T4 1
1433628 | 0 a | 8378 | -924.4 | vanduo karštas apytakinis - T4 1
1433717 | 0 a | 35.5094 | -774.9 | vanduo karštas apytakinis - T4 1
1433743 | 1 a +-152.84 | 43 | -774.9 | vanduo karštas apytakinis - T4 1
1433746 | 0 a | 232 | -774.9 | vanduo karštas apytakinis - T4 1
1433778 | 0 a | 4382 | -774.9 | vanduo karštas apytakinis - T4 1
1433792 | 0 a | 287 | -774.9 | vanduo karštas apytakinis - T4 1
1433812 | 0 a | 33242 | -774.9 | vanduo karštas apytakinis - T4 1
1433820 | 0 a | 10122 | -774.9 | vanduo karštas apytakinis - T4 1
1433828 | 0 a | 282 | -774.9 | vanduo karštas apytakinis - T4 1
1433889 | 0 a | 4176.4 | -715.399 | vanduo karštas apytakinis - T4 1
1434001 | 0 a | 1266.81 | 3479.5 | vanduo karštas apytakinis - T4 1
1434004 | 1 a +-152.84 | 1075 | 3474.5 | vanduo karštas apytakinis - T4 1
1434121 | 1 a +-152.84 | 4005 | 3548 | vanduo karštas apytakinis - T4 1
1434146 | 1 a +-152.84 | 283.809 | 7574 | vanduo karštas apytakinis - T4 1
1434189 | 1 a +-152.84 | 57.1021 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434226 | 1 a +-152.84 | 1517.89 | 3530 | vanduo karštas tiekiamasis - T3 1
1434231 | 1 a +-152.84 | 300 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434297 | 1 a +-152.84 | 100.902 | 642.299 | vanduo karštas tiekiamasis - T3 1
1434310 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434335 | 1 a +-152.84 | 245 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434344 | 1 a +-152.84 | 138.088 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434347 | 1 a +-152.84 | 60 | 642.3 | vanduo karštas tiekiamasis - T3 1
1434389 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434416 | 1 a +-152.84 | 343.845 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434427 | 1 a +-152.84 | 6971.25 | 3530 | vanduo karštas tiekiamasis - T3 1
1434432 | 1 a +-152.84 | 1420 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434440 | 1 a +-152.84 | 120 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434450 | 1 a +-152.84 | 120 | 642.3 | vanduo karštas tiekiamasis - T3 1
1434489 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434511 | 1 a +-152.84 | 1740 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434522 | 1 a +-152.84 | 673.802 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434525 | 1 a +-152.84 | 100 | 642.3 | vanduo karštas tiekiamasis - T3 1
1434577 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434601 | 1 a +-152.84 | 1798.25 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434610 | 1 a +-152.84 | 4120.63 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434613 | 1 a +-152.84 | 150 | 642.3 | vanduo karštas tiekiamasis - T3 1
1434667 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434714 | 1 a +-152.84 | 1380 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434723 | 1 a +-152.84 | 2311.29 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434726 | 1 a +-152.84 | 280 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434736 | 1 a +-152.84 | 100 | 642.3 | vanduo karštas tiekiamasis - T3 1
1434793 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434815 | 1 a +-152.84 | 2520 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434836 | 1 a +-152.84 | 290.432 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434839 | 1 a +-152.84 | 120 | 642.299 | vanduo karštas tiekiamasis - T3 1
1434902 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1434926 | 1 a +-152.84 | 5160 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434943 | 1 a +-152.84 | 3704.81 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434946 | 1 a +-152.84 | 2660 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434958 | 1 a +-152.84 | 752.928 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434966 | 1 a +-152.84 | 460 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1434979 | 1 a +-152.84 | 80 | 642.299 | vanduo karštas tiekiamasis - T3 1
1435017 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1435045 | 1 a +-152.84 | 480 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435054 | 1 a +-152.84 | 1167.07 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435057 | 1 a +-152.84 | 80 | 642.299 | vanduo karštas tiekiamasis - T3 1
1435101 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1435123 | 1 a +-152.84 | 662.742 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435140 | 1 a +-152.84 | 2132.54 | 3530 | vanduo karštas tiekiamasis - T3 1
1435145 | 1 a +-152.84 | 740 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435167 | 1 a +-152.84 | 120.636 | 642.299 | vanduo karštas tiekiamasis - T3 1
1435260 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1435406 | 1 a +-152.84 | 750 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435415 | 1 a +-152.84 | 846.456 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435418 | 1 a +-152.84 | 130.636 | 642.299 | vanduo karštas tiekiamasis - T3 1
1435528 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1435564 | 1 a +-152.84 | 740 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435573 | 1 a +-152.84 | 1485.8 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435576 | 1 a +-152.84 | 140.636 | 642.3 | vanduo karštas tiekiamasis - T3 1
1435653 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1435675 | 1 a +-152.84 | 124.13 | 3550 | vanduo karštas tiekiamasis - T3 1
1435709 | 1 a +-152.84 | 3167.82 | 3530 | vanduo karštas tiekiamasis - T3 1
1435714 | 1 a +-152.84 | 866.717 | 3550 | vanduo karštas tiekiamasis - T3 1
1435726 | 1 a +-152.84 | 194 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435778 | 1 a +-152.84 | 63.5669 | 792.3 | vanduo karštas tiekiamasis - T3 1
1435831 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1435853 | 1 a +-152.84 | 228 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435866 | 1 a +-152.84 | 904.864 | 3550 | vanduo karštas tiekiamasis - T3 1
1435869 | 1 a +-152.84 | 50 | 792.3 | vanduo karštas tiekiamasis - T3 1
1435916 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1435938 | 1 a +-152.84 | 223 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1435949 | 1 a +-152.84 | 224.419 | 3550 | vanduo karštas tiekiamasis - T3 1
1435952 | 1 a +-152.84 | 40 | 792.299 | vanduo karštas tiekiamasis - T3 1
1435990 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1436014 | 1 a +-152.84 | 238 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1436025 | 1 a +-152.84 | 161.085 | 3550 | vanduo karštas tiekiamasis - T3 1
1436028 | 1 a +-152.84 | 60 | 642.299 | vanduo karštas tiekiamasis - T3 1
1436097 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1436158 | 1 a +-152.84 | 3869.42 | 17721.6 | vanduo karštas tiekiamasis - T3 1
1436169 | 1 a +-152.84 | 2294.04 | 3530 | vanduo karštas tiekiamasis - T3 1
1436292 | 1 a +-152.84 | 707 | 21609.5 | vanduo karštas tiekiamasis - T3 1
1436341 | 1 a +-152.84 | 3791.42 | 17744.6 | vanduo karštas apytakinis - T4 1
1436352 | 1 a +-152.84 | 2605.11 | 3474.5 | vanduo karštas apytakinis - T4 1
1436355 | 1 a +-152.84 | 787 | 21549 | vanduo karštas apytakinis - T4 1
1436590 | 1 a +-152.84 | 2378 | 3550 | vanduo karštas tiekiamasis - T3 1
1436606 | 1 a +-152.84 | 867.373 | 3550 | vanduo karštas tiekiamasis - T3 1
1436618 | 1 a +-152.84 | 284 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1436630 | 1 a +-152.84 | 73.039 | 792.3 | vanduo karštas tiekiamasis - T3 1
1436674 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1436696 | 1 a +-152.84 | 303 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1436707 | 1 a +-152.84 | 342.739 | 3550 | vanduo karštas tiekiamasis - T3 1
1436710 | 1 a +-152.84 | 65 | 792.299 | vanduo karštas tiekiamasis - T3 1
1436745 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1436767 | 1 a +-152.84 | 298 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1436778 | 1 a +-152.84 | 845.887 | 3550 | vanduo karštas tiekiamasis - T3 1
1436781 | 1 a +-152.84 | 40 | 792.299 | vanduo karštas tiekiamasis - T3 1
1436826 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1436919 | 1 a +-152.84 | 665.956 | 3539.5 | vanduo karštas tiekiamasis - T3 1
1436928 | 1 a +-152.84 | 1004.58 | 3530 | vanduo karštas tiekiamasis - T3 1
1436972 | 1 a +-152.84 | 4282 | 3550 | vanduo karštas tiekiamasis - T3 1
1437014 | 1 a +-152.84 | 2631.05 | 3539.5 | vanduo karštas tiekiamasis - T3 1
1437019 | 1 a +-152.84 | 743.027 | 3550 | vanduo karštas tiekiamasis - T3 1
1437029 | 1 a +-152.84 | 499 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437076 | 1 a +-152.84 | 80 | 642.3 | vanduo karštas tiekiamasis - T3 1
1437119 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1437141 | 1 a +-152.84 | 515 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437150 | 1 a +-152.84 | 820.47 | 3550 | vanduo karštas tiekiamasis - T3 1
1437153 | 1 a +-152.84 | 78 | 642.3 | vanduo karštas tiekiamasis - T3 1
1437191 | 1 a +-152.84 | 2866 | 672 | vanduo karštas tiekiamasis - T3 1
1437225 | 1 a +-152.84 | 560 | 3550 | vanduo karštas tiekiamasis - T3 1
1437238 | 1 a +-152.84 | 49.1337 | 3550 | vanduo karštas tiekiamasis - T3 1
1437241 | 1 a +-152.84 | 62.2688 | 640 | vanduo karštas tiekiamasis - T3 1
1437318 | 1 a +-152.84 | 2866 | 672 | vanduo karštas tiekiamasis - T3 1
1437340 | 1 a +-152.84 | 598 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437349 | 1 a +-152.84 | 852.369 | 3550 | vanduo karštas tiekiamasis - T3 1
1437352 | 1 a +-152.84 | 60 | 642.299 | vanduo karštas tiekiamasis - T3 1
1437419 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1437487 | 1 a +-152.84 | 4468.37 | 7847.68 | vanduo karštas tiekiamasis - T3 1
1437521 | 1 a +-152.84 | 360 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437530 | 1 a +-152.84 | 168.915 | 3530 | vanduo karštas tiekiamasis - T3 1
1437535 | 1 a +-152.84 | 935.499 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437546 | 1 a +-152.84 | 720 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437556 | 1 a +-152.84 | 155 | 642.299 | vanduo karštas tiekiamasis - T3 1
1437637 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1437659 | 1 a +-152.84 | 720 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437668 | 1 a +-152.84 | 936.652 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437671 | 1 a +-152.84 | 60 | 642.3 | vanduo karštas tiekiamasis - T3 1
1437751 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1437777 | 1 a +-152.84 | 710 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437786 | 1 a +-152.84 | 467.85 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1437789 | 1 a +-152.84 | 55 | 642.299 | vanduo karštas tiekiamasis - T3 1
1437952 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1437980 | 1 a +-152.84 | 818.293 | 3547 | vanduo karštas tiekiamasis - T3 1
1437997 | 1 a +-152.84 | 5152.71 | 3530 | vanduo karštas tiekiamasis - T3 1
1438000 | 1 a +-152.84 | 800 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438016 | 1 a +-152.84 | 100 | 792.3 | vanduo karštas tiekiamasis - T3 1
1438075 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1438105 | 1 a +-152.84 | 794 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438118 | 1 a +-152.84 | 885.979 | 3547 | vanduo karštas tiekiamasis - T3 1
1438121 | 1 a +-152.84 | 102.759 | 792.3 | vanduo karštas tiekiamasis - T3 1
1438162 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1438227 | 1 a +-152.84 | 794 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438238 | 1 a +-152.84 | 3406.39 | 3547 | vanduo karštas tiekiamasis - T3 1
1438241 | 1 a +-152.84 | 60 | 792.299 | vanduo karštas tiekiamasis - T3 1
1438289 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1438321 | 1 a +-152.84 | 2794 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438338 | 1 a +-152.84 | 2558.55 | 3547 | vanduo karštas tiekiamasis - T3 1
1438341 | 1 a +-152.84 | 367.036 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438357 | 1 a +-152.84 | 140 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438365 | 1 a +-152.84 | 85 | 792.3 | vanduo karštas tiekiamasis - T3 1
1438477 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1438506 | 1 a +-152.84 | 2974 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438519 | 1 a +-152.84 | 1137.28 | 3547 | vanduo karštas tiekiamasis - T3 1
1438522 | 1 a +-152.84 | 107.653 | 792.3 | vanduo karštas tiekiamasis - T3 1
1438577 | 1 a +-152.84 | 2720 | 820 | vanduo karštas tiekiamasis - T3 1
1438601 | 1 a +-152.84 | 304.618 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438614 | 1 a +-152.84 | 1325.5 | 3547 | vanduo karštas tiekiamasis - T3 1
1438617 | 1 a +-152.84 | 360 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438627 | 1 a +-152.84 | 80 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438638 | 1 a +-152.84 | 45 | 642.299 | vanduo karštas tiekiamasis - T3 1
1438709 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1438763 | 1 a +-152.84 | 210 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438772 | 1 a +-152.84 | 2501.73 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438775 | 1 a +-152.84 | 64.508 | 642.3 | vanduo karštas tiekiamasis - T3 1
1438825 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1438847 | 1 a +-152.84 | 10027.5 | 3492.3 | vanduo karštas apytakinis - T4 1
1438856 | 1 a +-152.84 | 7011.45 | 3474.5 | vanduo karštas apytakinis - T4 1
1438863 | 1 a +-152.84 | 65 | 3492.3 | vanduo karštas apytakinis - T4 1
1438945 | 1 a +-152.84 | 440 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438956 | 1 a +-152.84 | 1806.07 | 3530 | vanduo karštas tiekiamasis - T3 1
1438961 | 1 a +-152.84 | 480 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438969 | 1 a +-152.84 | 2960 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438982 | 1 a +-152.84 | 11240 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1438990 | 1 a +-152.84 | 2480 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439002 | 1 a +-152.84 | 185 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439010 | 1 a +-152.84 | 90 | 642.3 | vanduo karštas tiekiamasis - T3 1
1439083 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439123 | 1 a +-152.84 | 40 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439132 | 1 a +-152.84 | 300.279 | 3534.5 | vanduo karštas tiekiamasis - T3 1
1439166 | 1 a +-152.84 | 10177.7 | 3534.5 | vanduo karštas tiekiamasis - T3 1
1439174 | 1 a +-152.84 | 2040 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439186 | 1 a +-152.84 | 580 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439196 | 1 a +-152.84 | 100 | 642.3 | vanduo karštas tiekiamasis - T3 1
1439257 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439279 | 1 a +-152.84 | 1800 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439288 | 0 a | 8094.61 | 3530 | vanduo karštas tiekiamasis - T3 1
1439293 | 1 a +-152.84 | 200 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439301 | 1 a +-152.84 | 240.108 | 642.299 | vanduo karštas tiekiamasis - T3 1
1439345 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439381 | 1 a +-152.84 | 6600 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439393 | 1 a +-152.84 | 140 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439401 | 1 a +-152.84 | 340 | 642.299 | vanduo karštas tiekiamasis - T3 1
1439489 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439511 | 1 a +-152.84 | 8930.21 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439524 | 1 a +-152.84 | 3511.99 | 3530 | vanduo karštas tiekiamasis - T3 1
1439529 | 1 a +-152.84 | 540 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439539 | 1 a +-152.84 | 140 | 642.3 | vanduo karštas tiekiamasis - T3 1
1439584 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439604 | 1 a +-152.84 | 680 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439613 | 1 a +-152.84 | 409.793 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439616 | 1 a +-152.84 | 80 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439627 | 1 a +-152.84 | 130 | 642.3 | vanduo karštas tiekiamasis - T3 1
1439686 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439710 | 1 a +-152.84 | 6240 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439731 | 1 a +-152.84 | 1111.09 | 3530 | vanduo karštas tiekiamasis - T3 1
1439736 | 1 a +-152.84 | 288.99 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439746 | 1 a +-152.84 | 1060 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439754 | 1 a +-152.84 | 340 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439766 | 1 a +-152.84 | 80 | 642.3 | vanduo karštas tiekiamasis - T3 1
1439821 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439843 | 1 a +-152.84 | 520 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439850 | 1 a +-152.84 | 458.009 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439853 | 1 a +-152.84 | 80 | 642.3 | vanduo karštas tiekiamasis - T3 1
1439899 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1439921 | 1 a +-152.84 | 540 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439930 | 1 a +-152.84 | 413.001 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1439933 | 1 a +-152.84 | 80 | 642.299 | vanduo karštas tiekiamasis - T3 1
1439972 | 1 a +-152.84 | 2870 | 670 | vanduo karštas tiekiamasis - T3 1
1440025 | 1 a +-152.84 | 2520 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1440041 | 1 a +-152.84 | 700 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1440051 | 1 a +-152.84 | 268.543 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1440114 | 1 a +-152.84 | 32 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440127 | 1 a +-152.84 | 4214.68 | 3599 | vanduo karštas tiekiamasis - T3 1
1440154 | 2 a | 176 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440478 | 2 a | 1430.13 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440510 | 2 a | 81.0305 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440520 | 2 a | 190 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1440586 | 2 a | 2636.68 | 5170 | vanduo karštas tiekiamasis - T3 1
1440671 | 2 a | 427.5 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440680 | 2 a | 299.137 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440683 | 2 a | 160 | 7839.98 | vanduo karštas tiekiamasis - T3 5
1440765 | 2 a | 1835 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440774 | 2 a | 526.89 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440777 | 2 a | 276 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440785 | 2 a | 147.094 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1440846 | 2 a | 2636.68 | 5170 | vanduo karštas tiekiamasis - T3 1
1440883 | 2 a | 1695 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440896 | 2 a | 808.97 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440899 | 2 a | 671 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440949 | 2 a | 5016 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440957 | 2 a | 319 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1440967 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441043 | 2 a | 2657.68 | 5170 | vanduo karštas tiekiamasis - T3 1
1441095 | 2 a | 3500 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1441104 | 1 a +-152.84 | 195.494 | 3530 | vanduo karštas tiekiamasis - T3 1
1441109 | 2 a | 360 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1441117 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441224 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1441251 | 1 a +-152.84 | 4285 | 3609 | vanduo karštas tiekiamasis - T3 1
1441260 | 1 a +-152.84 | 942.758 | 3530 | vanduo karštas tiekiamasis - T3 1
1441312 | 2 a | 746.837 | 7907 | vanduo karštas tiekiamasis - T3 1
1441318 | 2 a | 3570.23 | 7910 | vanduo karštas tiekiamasis - T3 1
1441342 | 2 a | 1156 | 7910 | vanduo karštas tiekiamasis - T3 1
1441350 | 2 a | 356 | 7910 | vanduo karštas tiekiamasis - T3 1
1441360 | 2 a | 119 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441450 | 2 a | 2726 | 5172 | vanduo karštas tiekiamasis - T3 1
1441500 | 2 a | 6998 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441527 | 2 a | 2265.5 | 7910 | vanduo karštas tiekiamasis - T3 1
1441530 | 2 a | 416.6 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441540 | 2 a | 620 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441550 | 2 a | 310 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441560 | 2 a | 130 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441602 | 2 a | 2730 | 5170 | vanduo karštas tiekiamasis - T3 1
1441624 | 2 a | 540 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441633 | 2 a | 663.4 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441636 | 2 a | 145 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1441649 | 2 a | 54.8268 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441684 | 2 a | 2730 | 5170 | vanduo karštas tiekiamasis - T3 1
1441709 | 2 a | 1810 | 7910 | vanduo karštas tiekiamasis - T3 1
1441720 | 2 a | 2154.27 | 7910 | vanduo karštas tiekiamasis - T3 1
1441723 | 2 a | 141.796 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441761 | 2 a | 2726 | 5172 | vanduo karštas tiekiamasis - T3 1
1441797 | 2 a | 360 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1441806 | 1 a +-152.84 | 8025.74 | 3530 | vanduo karštas tiekiamasis - T3 1
1441811 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441853 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1441883 | 2 a | 553 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1441892 | 1 a +-152.84 | 64.3905 | 3550 | vanduo karštas tiekiamasis - T3 1
1441895 | 2 a | 125 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1441934 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1442028 | 1 a +-152.84 | 4298.86 | 17806.1 | vanduo karštas tiekiamasis - T3 1
1442088 | 1 a +-152.84 | 4203.51 | 17827.5 | vanduo karštas apytakinis - T4 1
1442097 | 1 a +-152.84 | 12940.7 | 3474.5 | vanduo karštas apytakinis - T4 1
1442100 | 1 a +-152.84 | 51 | 22044 | vanduo karštas apytakinis - T4 1
1442153 | 1 a +-152.84 | 7423.2 | 3530 | vanduo karštas tiekiamasis - T3 1
1442168 | 1 a +-152.84 | 11364.7 | 3530 | vanduo karštas tiekiamasis - T3 1
1442176 | 1 a +-152.84 | 147 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1442205 | 1 a +-152.84 | 4230.36 | 3611 | vanduo karštas tiekiamasis - T3 1
1442254 | 2 a | 52.0167 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1442268 | 2 a | 3880 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442284 | 2 a | 420 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442292 | 2 a | 1060 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442308 | 2 a | 800 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442316 | 2 a | 135 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1442363 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1442434 | 2 a | 510 | 7865.36 | vanduo karštas tiekiamasis - T3 1
1442445 | 2 a | 1699.01 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1442448 | 2 a | 76.633 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1442496 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1442520 | 2 a | 114 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442529 | 2 a | 203.569 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1442532 | 2 a | 740 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442540 | 2 a | 860 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442552 | 2 a | 4620 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442562 | 2 a | 1530 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442589 | 2 a | 140 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442597 | 2 a | 81.25 | 5142.3 | vanduo karštas tiekiamasis - T3 6
1442625 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1442709 | 1 a +-152.84 | 500 | 7933.24 | vanduo karštas apytakinis - T4 1
1442730 | 1 a +-152.84 | 4385.94 | 3534 | vanduo karštas apytakinis - T4 1
1442751 | 2 a | 12540 | 7933.24 | vanduo karštas apytakinis - T4 1
1442771 | 2 a | 30 | 7933.24 | vanduo karštas apytakinis - T4 1
1442829 | 2 a | 1194 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442838 | 2 a | 2017.27 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1442841 | 2 a | 120 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442852 | 2 a | 234.95 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1442911 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1442935 | 2 a | 1474 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442944 | 2 a | 6079.77 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1442947 | 2 a | 140 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1442961 | 2 a | 110 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1443031 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1443096 | 2 a | 2089 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443105 | 2 a | 669.328 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1443108 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1443169 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1443331 | 2 a | 2554 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443340 | 2 a | 1810.03 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1443343 | 2 a | 500 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443351 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1443379 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1443452 | 2 a | 137 | 7865.36 | vanduo karštas tiekiamasis - T3 1
1443463 | 1 a +-152.84 | 147 | 7862.36 | vanduo karštas tiekiamasis - T3 1
1443466 | 2 a | 371 | 7865.36 | vanduo karštas tiekiamasis - T3 1
1443484 | 2 a | 4189.24 | 7865.36 | vanduo karštas tiekiamasis - T3 1
1443504 | 2 a | 1656 | 7865.36 | vanduo karštas tiekiamasis - T3 1
1443514 | 2 a | 39.7797 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443539 | 2 a | 185 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443549 | 2 a | 85 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1443590 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1443612 | 2 a | 100 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443621 | 2 a | 4909.22 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1443624 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1443695 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1443765 | 1 a +-152.84 | 4485.93 | 17167.1 | vanduo karštas tiekiamasis - T3 1
1443774 | 1 a +-152.84 | 6245.49 | 3530 | vanduo karštas tiekiamasis - T3 1
1443800 | 1 a +-152.84 | 65.2909 | 21665.7 | vanduo karštas apytakinis - T4 1
1443809 | 1 a +-152.84 | 11372.3 | 3474.5 | vanduo karštas apytakinis - T4 1
1443812 | 1 a +-152.84 | 46 | 21744 | vanduo karštas apytakinis - T4 1
1443843 | 1 a +-152.84 | 41.5 | 7759.61 | vanduo karštas tiekiamasis - T3 1
1443858 | 1 a +-152.84 | 4127.61 | 3611 | vanduo karštas tiekiamasis - T3 1
1443901 | 2 a | 56.7085 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1443917 | 2 a | 4216 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1443935 | 2 a | 376 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1443943 | 2 a | 776 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1443953 | 2 a | 296 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1443961 | 2 a | 3626 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1443975 | 2 a | 619 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444003 | 2 a | 90 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444040 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1444064 | 2 a | 180 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1444073 | 2 a | 113.291 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1444076 | 2 a | 2756 | 7762.61 | vanduo karštas tiekiamasis - T3 1
1444084 | 2 a | 139 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444101 | 2 a | 9731.57 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444124 | 2 a | 70.4252 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444137 | 2 a | 140 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444148 | 2 a | 85 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444190 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1444223 | 2 a | 95 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444232 | 2 a | 294.575 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444235 | 2 a | 140 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444245 | 2 a | 96.1621 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444278 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1444302 | 2 a | 420 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444311 | 2 a | 144.291 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444314 | 2 a | 87.1338 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444363 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1444385 | 2 a | 365 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444394 | 2 a | 244.139 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444397 | 2 a | 90 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444405 | 2 a | 79.882 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444433 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1444468 | 2 a | 4154 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444495 | 1 a +-152.84 | 41.5 | 7759.61 | vanduo karštas tiekiamasis - T3 1
1444508 | 2 a | 560 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444516 | 2 a | 125 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444526 | 2 a | 77.7471 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444564 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1444592 | 2 a | 4118 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1444603 | 2 a | 4026.76 | 7865.36 | vanduo karštas tiekiamasis - T3 1
1444606 | 2 a | 440 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1444614 | 2 a | 90 | 7867.66 | vanduo karštas tiekiamasis - T3 1
1444624 | 2 a | 73.4493 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444694 | 2 a | 2685.36 | 5170 | vanduo karštas tiekiamasis - T3 1
1444716 | 2 a | 475 | 7807.15 | vanduo šaltas - V1 2
1444729 | 2 a | 2089.78 | 7807.15 | vanduo šaltas - V1 2
1444732 | 2 a | 134 | 5142.3 | vanduo šaltas - V1 2
1444773 | 2 a | 2623.15 | 5172 | vanduo šaltas - V1 2
1444807 | 2 a | 630.408 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444818 | 2 a | 5125.62 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444863 | 2 a | 1714.38 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444897 | 2 a | 25 | 7764.91 | vanduo karštas tiekiamasis - T3 1
1444907 | 2 a | 150.768 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1444945 | 2 a | 2582.61 | 5170 | vanduo karštas tiekiamasis - T3 1
1445001 | 1 a +-152.84 | 9415 | 3611 | vanduo karštas tiekiamasis - T3 1
1445010 | 1 a +-152.84 | 3425 | 3530 | vanduo karštas tiekiamasis - T3 1
1445039 | 1 a +-152.84 | 9447 | 3534 | vanduo karštas apytakinis - T4 1
1445048 | 1 a +-152.84 | 10996.8 | 3474.5 | vanduo karštas apytakinis - T4 1
1445075 | 1 a +-152.84 | 404 | 7618.57 | vanduo karštas tiekiamasis - T3 7
1445124 | 2 a | 164.5 | 7618.57 | vanduo karštas tiekiamasis - T3 7
1445162 | 2 a | 83.8965 | 7618.57 | vanduo karštas tiekiamasis - T3 7
1445624 | 2 a | 332.215 | 7621.57 | vanduo karštas tiekiamasis - T3 7
1445638 | 2 a | 3750.5 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445678 | 2 a | 1480 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445688 | 2 a | 220 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445704 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1445752 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1445775 | 2 a | 43.0074 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445792 | 2 a | 78.3489 | 7621.57 | vanduo karštas tiekiamasis - T3 7
1445795 | 2 a | 200 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445814 | 2 a | 109.072 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1445860 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1445888 | 2 a | 150 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445899 | 2 a | 1314.99 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445902 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1445943 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1445971 | 2 a | 615 | 7621.57 | vanduo karštas tiekiamasis - T3 7
1445982 | 2 a | 1831.94 | 7621.57 | vanduo karštas tiekiamasis - T3 7
1445985 | 2 a | 257 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1445999 | 2 a | 98 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1446042 | 2 a | 2437.57 | 5172 | vanduo karštas tiekiamasis - T3 7
1446075 | 2 a | 254 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446084 | 2 a | 6215.1 | 7618.57 | vanduo karštas tiekiamasis - T3 7
1446087 | 2 a | 1168.46 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446095 | 2 a | 100 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446179 | 2 a | 160 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1446188 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1446213 | 2 a | 276.761 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446222 | 2 a | 71.5388 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446225 | 2 a | 660 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446233 | 2 a | 1860 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446243 | 2 a | 540 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446251 | 2 a | 86.8804 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1446295 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1446343 | 2 a | 48.561 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446369 | 2 a | 180 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446379 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1446447 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1446475 | 2 a | 195 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446484 | 2 a | 2641.94 | 7623.87 | vanduo karštas tiekiamasis - T3 7
1446487 | 2 a | 105 | 5142.3 | vanduo karštas tiekiamasis - T3 7
1446540 | 2 a | 2441.57 | 5170 | vanduo karštas tiekiamasis - T3 7
1446566 | 2 a | 5245 | 3547 | vanduo karštas tiekiamasis - T3 1
1446575 | 0 a | 12073.7 | 3530 | vanduo karštas tiekiamasis - T3 1
1446578 | 2 a | 645.468 | 3547 | vanduo karštas tiekiamasis - T3 1
1446607 | 2 a | 4193 | 3586 | vanduo karštas tiekiamasis - T3 1
1446617 | 2 a | 16 | 7810 | vanduo karštas tiekiamasis - T3 1
1446646 | 2 a | 166.98 | 7810 | vanduo karštas tiekiamasis - T3 1
1446880 | 2 a | 164 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1446889 | 2 a | 162.532 | 3547 | vanduo karštas tiekiamasis - T3 1
1446892 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1446954 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1446978 | 2 a | 4618 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1446999 | 2 a | 685.443 | 7810 | vanduo karštas tiekiamasis - T3 1
1447002 | 2 a | 860 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1447012 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1447059 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 1
1447083 | 2 a | 3663.94 | 7810 | vanduo karštas tiekiamasis - T3 1
1447108 | 2 a | 5828.04 | 7810 | vanduo karštas tiekiamasis - T3 1
1447125 | 2 a | 169 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1447137 | 2 a | 480 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1447199 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 1
1447223 | 2 a | 198 | 7810 | vanduo karštas tiekiamasis - T3 1
1447232 | 2 a | 4024.81 | 7810 | vanduo karštas tiekiamasis - T3 1
1447235 | 2 a | 103.685 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1447276 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 1
1447300 | 2 a | 213 | 7810 | vanduo karštas tiekiamasis - T3 1
1447309 | 2 a | 79.2496 | 7810 | vanduo karštas tiekiamasis - T3 1
1447312 | 2 a | 78.6846 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1447357 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 1
1447394 | 2 a | 2798 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1447413 | 2 a | 2777.49 | 7810 | vanduo karštas tiekiamasis - T3 1
