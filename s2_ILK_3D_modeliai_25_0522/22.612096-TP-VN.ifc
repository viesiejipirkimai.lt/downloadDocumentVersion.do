Properties of the parts of a building model (IFC2X3), part 3 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1160682_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160680_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160688_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160724_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160732_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160724_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160863_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160733_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160902_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160740_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160871_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160861_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160863_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160861_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160871_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160892_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160902_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160918_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160918_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161010_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160926_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161016_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1160926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161008_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161010_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161008_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1161091_0 | SOURCEANDSINK | K1 2
Port_1161532_1 | SOURCEANDSINK | K1 2
Port_1161091_1 | SOURCEANDSINK | K1 2
Port_1161707_2 | SOURCEANDSINK | K1 2
Port_1161532_2 | SOURCEANDSINK | K1 2
Port_1161699_0 | SOURCEANDSINK | K1 2
Port_1161707_1 | SOURCEANDSINK | K1 2
Port_1161699_1 | SOURCEANDSINK | K1 2
Port_1161748_1 | SOURCEANDSINK | K1 2
Port_1161748_2 | SOURCEANDSINK | K1 2
Port_1161968_0 | SOURCEANDSINK | K1 2
Port_1161968_1 | SOURCEANDSINK | K1 2
Port_1161982_1 | SOURCEANDSINK | K1 2
Port_1161982_2 | SOURCEANDSINK | K1 2
Port_1174853_0 | SOURCEANDSINK | K1 2
Port_1162074_0 | SOURCEANDSINK | K1 2
Port_1163080_1 | SOURCEANDSINK | K1 2
Port_1162074_1 | SOURCEANDSINK | K1 2
Port_1162149_1 | SOURCEANDSINK | K1 2
Port_1162108_0 | SOURCEANDSINK | K1 2
Port_1162141_2 | SOURCEANDSINK | K1 2
Port_1162108_1 | SOURCEANDSINK | K1 2
Port_1162149_2 | SOURCEANDSINK | K1 2
Port_1162123_0 | SOURCEANDSINK | K1 2
Port_1162125_2 | SOURCEANDSINK | K1 2
Port_1162123_1 | SOURCEANDSINK | K1 2
Port_1162141_1 | SOURCEANDSINK | K1 2
Port_1162125_1 | SOURCEANDSINK | K1 2
Port_1228830_0 | SOURCEANDSINK | K1 2
Port_1162226_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162299_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162226_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162328_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162237_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162712_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162320_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162328_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162320_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162507_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162507_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162546_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162546_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162560_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162554_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162728_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162554_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162560_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162695_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162720_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162695_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162728_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162710_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162712_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162710_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162720_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1163080_2 | SOURCEANDSINK | K1 2
Port_1163080_3 | SOURCEANDSINK | K1 2
Port_1163081_0 | SOURCEANDSINK | K1 2
Port_1191320_1 | SOURCEANDSINK | K1 2
Port_1163081_1 | SOURCEANDSINK | K1 2
Port_1163230_0 | SOURCEANDSINK | K1 2
Port_1163232_2 | SOURCEANDSINK | K1 2
Port_1163230_1 | SOURCEANDSINK | K1 2
Port_1163240_1 | SOURCEANDSINK | K1 2
Port_1163232_1 | SOURCEANDSINK | K1 2
Port_1163240_2 | SOURCEANDSINK | K1 2
Port_1163478_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 27
Port_1163478_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 27
Port_1163543_1 | SOURCEANDSINK | K1 2
Port_1191321_0 | SOURCEANDSINK | K1 2
Port_1163543_2 | SOURCEANDSINK | K1 2
Port_1163544_1 | SOURCEANDSINK | K1 2
Port_1163543_3 | SOURCEANDSINK | K1 2
Port_1163544_0 | SOURCEANDSINK | K1 2
Port_1165571_1 | SOURCEANDSINK | K1 2
Port_1163553_0 | SOURCEANDSINK | K1 2
Port_1163600_2 | SOURCEANDSINK | K1 2
Port_1163553_1 | SOURCEANDSINK | K1 2
Port_1163590_0 | SOURCEANDSINK | K1 2
Port_1163592_2 | SOURCEANDSINK | K1 2
Port_1163590_1 | SOURCEANDSINK | K1 2
Port_1163600_1 | SOURCEANDSINK | K1 2
Port_1163592_1 | SOURCEANDSINK | K1 2
Port_1165561_0 | SOURCEANDSINK | K1 2
Port_1167846_2 | SOURCEANDSINK | K1 2
Port_1165561_1 | SOURCEANDSINK | K1 2
Port_1165589_2 | SOURCEANDSINK | K1 2
Port_1165571_2 | SOURCEANDSINK | K1 2
Port_1165572_1 | SOURCEANDSINK | K1 2
Port_1165571_3 | SOURCEANDSINK | K1 2
Port_1165577_1 | SOURCEANDSINK | K1 2
Port_1165572_0 | SOURCEANDSINK | K1 2
Port_1174852_1 | SOURCEANDSINK | K1 2
Port_1165577_2 | SOURCEANDSINK | K1 2
Port_1167847_0 | SOURCEANDSINK | K1 2
Port_1165583_0 | SOURCEANDSINK | K1 2
Port_1167263_2 | SOURCEANDSINK | K1 2
Port_1165583_1 | SOURCEANDSINK | K1 2
Port_1165611_1 | SOURCEANDSINK | K1 2
Port_1165589_1 | SOURCEANDSINK | K1 2
Port_1167264_0 | SOURCEANDSINK | K1 2
Port_1165611_2 | SOURCEANDSINK | K1 2
Port_1191807_0 | SOURCEANDSINK | K1 2
Port_1166076_0 | SOURCEANDSINK | K1 2
Port_1166247_2 | SOURCEANDSINK | K1 2
Port_1166076_1 | SOURCEANDSINK | K1 2
Port_1166090_2 | SOURCEANDSINK | K1 2
Port_1166084_0 | SOURCEANDSINK | K1 2
Port_1166090_1 | SOURCEANDSINK | K1 2
Port_1166084_1 | SOURCEANDSINK | K1 2
Port_1166169_1 | SOURCEANDSINK | K1 2
Port_1166167_0 | SOURCEANDSINK | K1 2
Port_1166169_2 | SOURCEANDSINK | K1 2
Port_1166167_1 | SOURCEANDSINK | K1 2
Port_1166216_1 | SOURCEANDSINK | K1 2
Port_1166237_0 | SOURCEANDSINK | K1 2
Port_1166247_3 | SOURCEANDSINK | K1 2
Port_1166237_1 | SOURCEANDSINK | K1 2
Port_1166451_1 | SOURCEANDSINK | K1 2
Port_1166247_1 | SOURCEANDSINK | K1 2
Port_1166248_1 | SOURCEANDSINK | K1 2
Port_1166248_0 | SOURCEANDSINK | K1 2
Port_1166776_2 | SOURCEANDSINK | K1 2
Port_1166449_0 | SOURCEANDSINK | K1 2
Port_1166451_2 | SOURCEANDSINK | K1 2
Port_1166449_1 | SOURCEANDSINK | K1 2
Port_1166457_1 | SOURCEANDSINK | K1 2
Port_1166457_2 | SOURCEANDSINK | K1 2
Port_1166760_0 | SOURCEANDSINK | K1 2
Port_1166776_3 | SOURCEANDSINK | K1 2
Port_1166760_1 | SOURCEANDSINK | K1 2
Port_1166792_1 | SOURCEANDSINK | K1 2
Port_1166776_1 | SOURCEANDSINK | K1 2
Port_1166777_1 | SOURCEANDSINK | K1 2
Port_1166777_0 | SOURCEANDSINK | K1 2
Port_1167059_2 | SOURCEANDSINK | K1 2
Port_1166786_0 | SOURCEANDSINK | K1 2
Port_1166792_2 | SOURCEANDSINK | K1 2
Port_1166786_1 | SOURCEANDSINK | K1 2
Port_1166845_1 | SOURCEANDSINK | K1 2
Port_1166800_0 | SOURCEANDSINK | K1 2
Port_1166853_2 | SOURCEANDSINK | K1 2
Port_1166800_1 | SOURCEANDSINK | K1 2
Port_1166843_0 | SOURCEANDSINK | K1 2
Port_1166845_2 | SOURCEANDSINK | K1 2
Port_1166843_1 | SOURCEANDSINK | K1 2
Port_1166853_1 | SOURCEANDSINK | K1 2
Port_1167043_0 | SOURCEANDSINK | K1 2
Port_1167059_3 | SOURCEANDSINK | K1 2
Port_1167043_1 | SOURCEANDSINK | K1 2
Port_1167177_1 | SOURCEANDSINK | K1 2
Port_1167059_1 | SOURCEANDSINK | K1 2
Port_1167060_1 | SOURCEANDSINK | K1 2
Port_1167060_0 | SOURCEANDSINK | K1 2
Port_1191806_2 | SOURCEANDSINK | K1 2
Port_1167175_0 | SOURCEANDSINK | K1 2
Port_1167177_2 | SOURCEANDSINK | K1 2
Port_1167175_1 | SOURCEANDSINK | K1 2
Port_1167255_0 | SOURCEANDSINK | K1 2
Port_1167438_2 | SOURCEANDSINK | K1 2
Port_1167255_1 | SOURCEANDSINK | K1 2
Port_1167324_1 | SOURCEANDSINK | K1 2
Port_1167263_1 | SOURCEANDSINK | K1 2
Port_1167264_1 | SOURCEANDSINK | K1 2
Port_1167263_3 | SOURCEANDSINK | K1 2
Port_1167634_0 | SOURCEANDSINK | K1 2
Port_1167322_0 | SOURCEANDSINK | K1 2
Port_1167324_2 | SOURCEANDSINK | K1 2
Port_1167322_1 | SOURCEANDSINK | K1 2
Port_1167381_1 | SOURCEANDSINK | K1 2
Port_1167424_0 | SOURCEANDSINK | K1 2
Port_1167438_3 | SOURCEANDSINK | K1 2
Port_1167424_1 | SOURCEANDSINK | K1 2
Port_1167492_1 | SOURCEANDSINK | K1 2
Port_1167438_1 | SOURCEANDSINK | K1 2
Port_1167439_1 | SOURCEANDSINK | K1 2
Port_1167439_0 | SOURCEANDSINK | K1 2
Port_1167633_2 | SOURCEANDSINK | K1 2
Port_1167446_0 | SOURCEANDSINK | K1 2
Port_1167498_2 | SOURCEANDSINK | K1 2
Port_1167446_1 | SOURCEANDSINK | K1 2
Port_1167490_0 | SOURCEANDSINK | K1 2
Port_1167492_2 | SOURCEANDSINK | K1 2
Port_1167490_1 | SOURCEANDSINK | K1 2
Port_1167498_1 | SOURCEANDSINK | K1 2
Port_1167621_0 | SOURCEANDSINK | K1 2
Port_1167633_3 | SOURCEANDSINK | K1 2
Port_1167621_1 | SOURCEANDSINK | K1 2
Port_1167736_1 | SOURCEANDSINK | K1 2
Port_1167633_1 | SOURCEANDSINK | K1 2
Port_1167634_1 | SOURCEANDSINK | K1 2
Port_1167734_0 | SOURCEANDSINK | K1 2
Port_1167736_2 | SOURCEANDSINK | K1 2
Port_1167734_1 | SOURCEANDSINK | K1 2
Port_1167801_1 | SOURCEANDSINK | K1 2
Port_1167834_0 | SOURCEANDSINK | K1 2
Port_1167846_3 | SOURCEANDSINK | K1 2
Port_1167834_1 | SOURCEANDSINK | K1 2
Port_1167862_2 | SOURCEANDSINK | K1 2
Port_1167846_1 | SOURCEANDSINK | K1 2
Port_1167847_1 | SOURCEANDSINK | K1 2
Port_1167856_0 | SOURCEANDSINK | K1 2
Port_1191686_2 | SOURCEANDSINK | K1 2
Port_1167856_1 | SOURCEANDSINK | K1 2
Port_1167915_1 | SOURCEANDSINK | K1 2
Port_1167862_1 | SOURCEANDSINK | K1 2
Port_1191687_0 | SOURCEANDSINK | K1 2
Port_1167870_0 | SOURCEANDSINK | K1 2
Port_1167923_2 | SOURCEANDSINK | K1 2
Port_1167870_1 | SOURCEANDSINK | K1 2
Port_1167913_0 | SOURCEANDSINK | K1 2
Port_1167915_2 | SOURCEANDSINK | K1 2
Port_1167913_1 | SOURCEANDSINK | K1 2
Port_1167923_1 | SOURCEANDSINK | K1 2
Port_1167944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 28
Port_1167944_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 28
OutPort_1167975_1 | SOURCE
OutPort_1167987_1 | SOURCE
OutPort_1167999_1 | SOURCE
Port_1168487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168501_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168636_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168644_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168636_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168871_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168871_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168932_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168932_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169190_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169198_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169377_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169198_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169288_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169264_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169266_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169264_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169288_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169266_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1227984_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169282_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169378_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170866_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169412_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169377_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169378_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169377_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170867_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169406_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170472_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169406_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169426_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169412_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170473_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169420_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169607_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169420_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169480_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169426_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170022_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169478_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169480_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169478_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169517_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169595_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169607_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169595_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169661_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169608_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169608_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169780_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169615_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169667_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169615_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169659_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169661_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169659_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169766_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169780_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169781_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169781_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170021_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169790_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169796_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169804_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169860_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169850_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169852_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1169860_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170007_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170021_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170007_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170021_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170251_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170253_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170464_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170750_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170464_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170472_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170473_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170472_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170586_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170480_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170552_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170480_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170544_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170546_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170544_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170552_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170573_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170585_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170573_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170666_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170585_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170586_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170585_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170751_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170664_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170666_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170736_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192110_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170766_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170751_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170750_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192111_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170760_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170760_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170774_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170835_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170825_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170827_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170856_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171218_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170856_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170866_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170866_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170976_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170965_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170975_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170965_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171040_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170975_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170976_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170975_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171985_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170983_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171046_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1170983_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171038_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171040_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171038_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171046_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171175_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171183_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171208_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192688_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171208_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171281_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171219_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171218_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171219_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171338_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171228_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171289_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171228_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171279_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171281_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171310_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 29
Port_1171310_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 29
Port_1171330_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171514_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171330_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171352_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171338_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171339_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171338_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171853_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171339_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171984_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171346_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171352_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171360_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171417_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171360_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171409_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171498_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171514_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171498_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171530_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171514_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171515_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171515_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171852_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171524_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192481_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171524_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171631_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171530_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171538_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171639_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171629_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171631_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171639_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171666_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 30
Port_1171666_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 30
Port_1171838_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171852_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171838_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171929_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171927_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171929_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171927_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171976_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171984_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171976_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1172078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171984_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1171985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1172076_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1172078_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1172076_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
OutPort_1172215_1 | SOURCE
OutPort_1172229_1 | SOURCE
OutPort_1172245_1 | SOURCE
OutPort_1172257_1 | SOURCE
Port_1172293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226424_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172293_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172293_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173288_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172326_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173765_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172340_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172334_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172340_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172334_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172362_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172356_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172607_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172362_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173146_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172484_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172521_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172599_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172607_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172608_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172608_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172728_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172615_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172657_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172615_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172649_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172649_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172712_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172728_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172712_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172744_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172728_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172729_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172729_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173145_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172738_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192847_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172738_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172744_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172785_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172908_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172785_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172865_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172867_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172865_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172908_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1172929_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 31
Port_1172929_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 31
Port_1173133_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173145_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173133_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173231_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173145_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173146_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173229_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173231_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173279_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173621_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173307_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173287_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173288_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173287_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173766_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173287_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173295_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173295_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173301_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173487_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173301_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173462_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173307_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173488_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173323_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173329_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173323_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173329_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173409_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173471_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173487_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173471_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173548_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173488_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173562_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173546_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173548_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173562_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173607_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173621_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173637_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173631_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193890_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173631_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193891_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173645_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173645_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173706_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173659_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173714_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173659_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173704_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173706_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173704_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173714_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173735_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 32
Port_1173735_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 32
Port_1173755_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173765_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173755_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173781_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173765_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173775_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174536_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173781_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193224_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173842_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173844_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173842_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173881_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173905_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173919_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173905_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173919_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173920_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173919_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174039_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173920_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193223_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173927_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173985_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173927_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173977_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173979_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173977_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1173985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174024_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174038_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174024_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174054_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174038_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174038_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174187_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174048_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174145_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174062_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174153_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174143_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174145_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174153_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174174_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174186_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174174_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174186_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174187_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174186_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174310_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174258_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174260_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174258_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174299_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174309_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174299_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174310_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174309_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174717_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174398_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174400_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174398_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174524_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174536_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174524_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174581_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174536_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174537_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174716_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174544_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174587_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174544_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174579_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174581_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174587_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174704_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174716_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174704_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174716_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174717_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174726_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174732_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174726_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174740_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174788_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174778_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174780_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174788_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1174852_2 | SOURCEANDSINK | K1 2
Port_1174853_1 | SOURCEANDSINK | K1 2
Port_1174852_3 | SOURCEANDSINK | K1 2
Port_1175039_0 | SOURCEANDSINK | K1 2
Port_1175039_1 | SOURCEANDSINK | K1 2
Port_1175095_1 | SOURCEANDSINK | K1 2
Port_1175093_0 | SOURCEANDSINK | K1 2
Port_1175095_2 | SOURCEANDSINK | K1 2
Port_1175093_1 | SOURCEANDSINK | K1 2
Port_1175103_1 | SOURCEANDSINK | K1 2
Port_1175103_2 | SOURCEANDSINK | K1 2
Port_1175255_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 34
Port_1175257_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 34
Port_1175255_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 34
Port_1175263_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 34
Port_1175257_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 34
Port_1175263_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 34
Port_1175326_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175813_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175326_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175489_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175477_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175489_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175477_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175503_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175497_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175503_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175497_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175540_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175538_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175540_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175538_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175860_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175753_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1176012_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175852_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175860_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175852_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175898_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175898_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175990_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175990_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1176020_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175998_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1176012_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175998_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1176020_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1176327_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176335_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176327_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176389_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176807_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176335_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176336_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176375_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176389_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176375_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176403_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176397_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176397_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197239_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176495_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177057_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176738_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176752_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176738_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176784_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176752_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176774_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176784_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176792_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176806_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176792_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176812_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176806_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176807_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177048_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178244_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177056_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177056_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177056_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177131_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177304_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177208_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177144_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177143_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178245_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177143_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177558_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177144_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177889_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177206_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177208_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177258_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177292_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177304_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177348_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177305_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177305_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177557_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177312_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177354_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177312_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177346_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177348_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177354_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177478_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177567_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177478_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177557_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177558_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177557_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177573_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194410_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177573_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194411_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177620_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177666_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177656_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177658_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177656_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177666_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177715_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 33
Port_1177717_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 33
Port_1177715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 33
Port_1177717_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 33
Port_1177889_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177889_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177976_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1177976_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178030_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178032_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
OutPort_1178090_1 | SOURCE
OutPort_1178108_1 | SOURCE
OutPort_1178120_1 | SOURCE
OutPort_1178134_1 | SOURCE
OutPort_1178152_1 | SOURCE
Port_1178236_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178582_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178236_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178245_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178244_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194062_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178287_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178289_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178287_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178340_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178388_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178400_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178388_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178401_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178400_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178583_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178401_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179039_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178408_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178463_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178455_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178457_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178463_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178570_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178582_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178570_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178598_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178582_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178583_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178598_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178814_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178835_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178814_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178825_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178827_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1178956_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 35
Port_1178956_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 35
Port_1179025_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179039_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179025_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179040_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179040_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194061_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179197_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179199_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1179197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
OutPort_1179306_1 | SOURCE
Port_1179402_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179402_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195080_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179403_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224731_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179458_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195079_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179472_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179466_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180273_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179466_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179858_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179472_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179903_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179850_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179858_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179892_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179902_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179950_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179902_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180127_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179910_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179956_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179910_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179950_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179956_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180112_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195662_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180112_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180126_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180126_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180274_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180126_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195663_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180136_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180136_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180150_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180209_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180150_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180199_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180201_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180209_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180255_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180273_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180255_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180273_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180274_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180488_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1180488_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
OutPort_1180544_1 | SOURCE
Port_1180613_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180621_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180706_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180621_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180697_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180909_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180697_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180705_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224262_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180705_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180706_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180705_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180803_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180742_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
