Properties of the parts of a building model (IFC2X3), part 6 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1206974_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207012_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207022_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207012_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207023_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207030_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207036_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207044_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207125_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207117_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207119_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207117_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207125_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1208447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1208447_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209004_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209004_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209134_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209155_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209155_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209221_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209219_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209219_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209221_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209674_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209376_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1209424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1209376_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1209661_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211078_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209661_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209673_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209674_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209673_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209732_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210036_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209754_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209740_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210680_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209748_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209754_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209829_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209762_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209835_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209762_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209827_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209829_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1209835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210036_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211785_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210037_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210516_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210431_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210516_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210431_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210600_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210516_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210517_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210517_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210679_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210598_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210600_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210598_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210606_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210657_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210679_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210695_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210679_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210680_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210709_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210703_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210709_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210769_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210767_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210769_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210767_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210775_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210901_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210911_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210927_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210911_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210911_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211079_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210921_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210927_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210980_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210978_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210980_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210978_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210986_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1210986_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211021_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 44
Port_1211021_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 44
Port_1211066_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211078_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211066_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211094_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211088_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211094_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211088_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211184_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211184_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211190_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211223_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 45
Port_1211223_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 45
Port_1211785_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211827_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211795_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211813_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211795_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211811_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1211813_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1212022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212102_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212094_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212102_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212094_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212215_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212215_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212247_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212237_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212247_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212237_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212333_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212333_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212335_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212945_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212936_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213900_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212944_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212945_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212944_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213901_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212963_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213284_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212963_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212971_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213285_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212979_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213009_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213106_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213009_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213104_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213106_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213104_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213112_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213112_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213244_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213633_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213285_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213284_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213634_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213314_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213308_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213314_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213542_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213565_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213542_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213557_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213559_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213557_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213565_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213593_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213641_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213593_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213653_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213633_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213633_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213641_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213647_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213653_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213647_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213739_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213694_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213739_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213694_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213809_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213807_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213809_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213807_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213817_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213817_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213864_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213900_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213864_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213935_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213921_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213935_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213949_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213943_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213949_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1213943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214024_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214022_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214024_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214032_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1214138_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1498709_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214138_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214719_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214291_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214299_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214291_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214362_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214346_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214362_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214346_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214425_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214370_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214425_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214370_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214485_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214483_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214485_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214483_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214667_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214659_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214667_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214659_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214697_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214689_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214697_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214689_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214727_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214705_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214719_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214705_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214727_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214971_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259879_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1214971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216858_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215440_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215448_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215483_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215475_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215483_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215475_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215497_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215535_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215529_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215535_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215529_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215724_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215722_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215724_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215722_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216632_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216624_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216632_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216710_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217139_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216710_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216734_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216720_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217140_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216728_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216734_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216728_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216866_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216842_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216858_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216842_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1216866_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217131_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217620_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217155_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217139_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217139_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217405_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217149_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217155_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217367_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217163_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217373_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217163_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217365_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217367_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217365_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217373_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217394_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217412_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217404_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217405_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217404_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217404_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217412_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217418_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217424_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217418_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217509_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217507_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217509_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217507_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217515_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217515_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217536_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 46
Port_1217536_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 46
Port_1217606_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217628_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217739_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217620_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217634_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217739_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217859_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217780_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217865_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217857_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217859_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217857_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217865_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217888_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218128_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217888_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217902_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217968_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217968_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217984_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217978_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217984_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1217978_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218084_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218082_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218084_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218082_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1259815_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218120_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218128_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218128_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218129_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218167_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218341_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218183_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218736_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218276_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218278_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218327_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218341_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218327_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218341_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218342_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218342_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218457_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218351_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218357_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218351_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218365_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218371_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218365_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218379_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218425_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218415_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218417_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218415_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218425_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218457_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218473_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218458_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218626_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218467_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218473_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218467_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218487_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218481_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218481_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218501_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218586_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218509_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218592_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218509_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218584_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218586_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218584_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218592_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218614_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218626_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218670_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218626_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218627_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218735_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218668_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218670_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218668_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218676_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218697_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 47
Port_1218697_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 47
Port_1218723_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218735_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218723_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218735_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218743_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1218743_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219296_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219290_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219531_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219310_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219296_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219532_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219304_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219310_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219365_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219318_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219371_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219363_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219365_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219363_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219527_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219531_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219527_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219539_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219528_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219539_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219578_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219578_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219584_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219584_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219755_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219761_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219755_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219843_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219769_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219849_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219769_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219841_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219843_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219841_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219849_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 11
Port_1219957_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220028_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1219957_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220521_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1219966_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220028_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220322_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220521_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220322_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220527_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220481_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220483_3 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220481_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220527_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220483_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220484_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220563_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220596_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220563_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220963_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220572_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220596_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220953_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220963_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220953_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221110_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221108_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221108_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221110_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221191_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221190_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221190_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221214_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221230_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221224_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221230_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221281_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221279_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221281_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221289_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1221549_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221629_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221549_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221765_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221558_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221757_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221765_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221757_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221793_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221771_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222898_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221771_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221793_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221785_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250945_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221785_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222899_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221806_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221896_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221806_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221935_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221815_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221896_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221929_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221935_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221929_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222012_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222010_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222012_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222010_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222813_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222140_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222142_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222140_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222807_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222336_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222807_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222336_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222813_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222898_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222914_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222898_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222899_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222908_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222914_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222908_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222922_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223000_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222922_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222992_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223111_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222992_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223000_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1222994_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223293_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223103_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223111_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223103_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223125_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223111_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223112_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223112_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223292_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223119_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223125_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223137_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223137_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223284_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224030_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223323_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223292_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224031_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223315_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223803_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223337_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223323_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223521_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223331_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223331_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223432_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223345_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223438_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223345_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223430_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223432_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223438_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223492_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 48
Port_1223492_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 48
Port_1223512_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223528_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223512_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223578_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223520_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223521_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223520_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223804_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223520_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223534_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223617_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223534_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223576_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223578_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223576_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223617_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223791_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223803_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223791_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223915_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223803_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223811_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223921_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223913_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223915_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223913_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1223921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224020_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224030_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224020_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224044_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224038_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224038_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224058_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224052_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224058_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224052_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224144_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224144_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224216_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224152_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224222_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224152_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224214_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224216_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224222_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1224253_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224261_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224429_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224261_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224319_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224429_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224319_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224341_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224335_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224341_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224355_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224349_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224355_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224349_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224398_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224400_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224398_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224408_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224429_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224442_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224442_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224454_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224460_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224454_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224503_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224468_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224511_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224501_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224503_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224511_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224533_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 49
Port_1224533_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 49
Port_1224731_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224731_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225318_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224732_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224784_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225317_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224784_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225273_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224792_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224798_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224792_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1224798_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225173_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225175_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225173_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225183_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 50
Port_1225220_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 50
Port_1225309_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225523_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225331_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225317_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225691_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225325_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225331_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225325_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225345_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225339_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225345_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225339_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225353_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225438_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225428_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225430_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225428_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225438_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225513_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225523_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225513_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225523_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225524_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225524_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225690_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225604_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225606_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225604_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225678_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225794_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225706_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225690_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225691_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225690_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225795_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225700_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225706_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225700_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225753_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225714_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225761_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225714_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225751_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225753_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225751_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225782_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225794_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225782_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225808_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225795_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225822_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225816_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225822_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225830_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225900_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225892_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1225900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1226415_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226966_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226415_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226524_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226516_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226524_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226516_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226532_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226538_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226574_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226572_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226574_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1226572_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227118_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227118_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227229_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227293_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227285_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227500_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227285_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227453_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227501_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227453_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249821_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227492_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227500_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227492_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227516_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227500_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227510_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227516_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227510_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227538_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227546_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227560_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227554_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227560_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227554_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227674_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227676_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227674_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227684_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1227975_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228613_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1227975_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1227983_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249440_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1227983_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1227984_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1227983_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228480_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228008_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228157_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228008_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228074_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228016_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228327_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228072_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228074_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228149_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228157_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228249_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228158_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228158_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228326_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228247_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228249_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228247_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228257_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228257_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 51
Port_1228279_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 51
Port_1228318_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228326_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228327_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228336_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
