Properties of the parts of a building model (IFC2X3), part 17 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1357650_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357715_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357653_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357687_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357681_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357683_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357681_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357705_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357715_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357705_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357727_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357715_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357716_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357719_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357735_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357729_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357735_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357737_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357776_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357737_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357770_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357772_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357776_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357813_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358347_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357813_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358166_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357821_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358045_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357821_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357863_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357829_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357865_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357829_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357875_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357863_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357865_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357869_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357875_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357915_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357877_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357919_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357877_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357913_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357915_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357913_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357919_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357943_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357953_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357943_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357963_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357953_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358046_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357953_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357954_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357954_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358166_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358013_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357965_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358017_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358011_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358013_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358011_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358017_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358037_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358045_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358037_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358080_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358045_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358046_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358049_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358084_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358049_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358078_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358080_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358078_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358084_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358166_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358177_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358213_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358199_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358281_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358199_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358213_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358282_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358215_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358245_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358215_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358241_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358243_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358241_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358245_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358285_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358279_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358281_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358279_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358285_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358281_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358282_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358337_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358347_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358337_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358359_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358347_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358348_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358351_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358359_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358361_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358413_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358367_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358633_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358369_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358417_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358411_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358413_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358624_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358632_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358632_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358633_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358636_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358642_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358636_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358681_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358644_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358685_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358679_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358681_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358679_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358685_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358734_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359688_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358779_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358780_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358779_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359853_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358780_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389440_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358788_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358828_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358816_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358816_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359532_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358817_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359852_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358830_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358871_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358887_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358887_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358889_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358941_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358889_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358935_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358937_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358941_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358965_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359019_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358965_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358966_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358966_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358969_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359023_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359017_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359019_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359017_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359023_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359044_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359052_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359044_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359139_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359052_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359053_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359053_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359257_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359056_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359139_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359056_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359111_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359064_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359115_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359064_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359109_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359111_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359139_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359167_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359183_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359177_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359185_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359241_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359235_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359237_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359235_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359241_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359257_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359426_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359257_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359284_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359278_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359355_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359284_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359286_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359339_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359286_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359333_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359335_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359339_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359411_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359475_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359491_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359426_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359475_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359475_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359480_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359495_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359480_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359489_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359491_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359495_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359523_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359531_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359523_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359544_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359531_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359532_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359535_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359544_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359546_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359557_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359546_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359565_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359559_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359559_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359612_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359567_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359616_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359567_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359610_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359612_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359616_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359678_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359688_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359722_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359690_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359726_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359690_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359720_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359722_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359720_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359726_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359836_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359836_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359852_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359853_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359852_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360035_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359856_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359937_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359856_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359931_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359933_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359931_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1359937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360026_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360034_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360026_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360044_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360034_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360035_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360038_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360044_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360090_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360046_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360094_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360046_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360088_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360090_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360088_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360094_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360127_0 | SOURCEANDSINK | vanduo šaltas - V1 7
Port_1360127_1 | SOURCEANDSINK | vanduo šaltas - V1 7
Port_1360317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360317_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361039_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360318_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390716_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360326_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360334_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360326_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360546_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360334_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360336_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360336_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360340_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360546_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360340_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360367_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360359_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360359_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360407_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360369_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360411_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360405_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360407_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360405_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360546_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360557_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360590_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360567_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360590_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360567_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360592_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360600_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360608_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360602_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360602_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360658_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360608_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360718_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360610_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360660_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360656_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360658_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360656_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360660_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360709_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360717_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360709_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360717_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360718_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360721_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360727_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360721_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360737_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360729_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360737_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360782_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360739_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360786_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360739_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360780_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360782_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360780_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360850_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360858_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360868_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360858_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360859_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360859_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360862_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360862_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360870_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360911_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360870_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360905_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360907_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360905_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360911_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360935_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360935_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360962_0 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360979_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360962_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1472019_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360971_0 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360979_2 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360971_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361010_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360981_0 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361014_2 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1360981_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361008_0 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361010_2 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361008_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361014_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1361030_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472187_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361030_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361175_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361038_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361039_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361038_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361108_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361042_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361048_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361042_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361079_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361050_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361083_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361077_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361079_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361077_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361083_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361099_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361107_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361099_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361146_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361107_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472188_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361107_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361108_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361111_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361150_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361111_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361144_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361146_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361144_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361150_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361166_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361261_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361166_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361184_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361174_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361175_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361174_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361362_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361178_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361184_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361178_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361186_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361224_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361186_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361218_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361220_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361251_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361261_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361295_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361261_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361262_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361265_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361299_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361265_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361293_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361295_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361293_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361299_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361355_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361361_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361407_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361361_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361362_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361365_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361411_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361365_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361405_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361407_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361405_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361454_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470420_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361566_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361464_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361464_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470504_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361465_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392238_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361556_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361745_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361556_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361624_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361564_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361566_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361564_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361962_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361570_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361626_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361570_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361638_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361626_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361630_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361638_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361630_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361691_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361640_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361695_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361640_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361689_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361691_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361689_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361695_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361731_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361745_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361731_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361757_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361745_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361746_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361749_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361757_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361796_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361759_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361800_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361759_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361794_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361796_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361800_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361846_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361858_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361846_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361858_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361859_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361859_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361862_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361876_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361862_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361915_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361878_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361919_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361878_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361913_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361915_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361913_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361919_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361937_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361961_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361961_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361962_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361965_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361975_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361985_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361973_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361975_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361985_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361987_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361995_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362049_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361997_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362053_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361997_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362047_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362049_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362047_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362053_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362085_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362086_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362085_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363054_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362108_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363053_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362108_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362116_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362410_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362116_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362124_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362126_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362130_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362233_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362130_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362243_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362237_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362330_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362253_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362331_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362245_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362253_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362245_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362303_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362255_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362307_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362255_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362301_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362303_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362322_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362330_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362322_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362381_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362330_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362334_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362385_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362334_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362379_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362381_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362379_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362385_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362400_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362487_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362410_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362410_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362488_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362414_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362422_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362414_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362460_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362424_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362464_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362458_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362460_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362458_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362464_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362479_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362487_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362479_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362487_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362491_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362539_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362491_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362533_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362535_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362539_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362553_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362703_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362610_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362702_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362744_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362641_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362702_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362702_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362703_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362707_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362947_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362707_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362744_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362948_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362760_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362875_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362760_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362784_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362770_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362772_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362876_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362776_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362784_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362776_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362786_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362858_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362816_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362818_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362867_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362875_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362915_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362875_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362879_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362919_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362913_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362915_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362913_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362919_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362937_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362947_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362947_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362948_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362951_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362965_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362951_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362973_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362967_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362986_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362975_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362986_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362975_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363026_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362988_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363030_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362988_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363024_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363026_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363030_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363045_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363140_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363045_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363073_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363053_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363053_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363220_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363057_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363075_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363057_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363112_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363073_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363075_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363079_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363116_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363079_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363110_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363112_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363110_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363116_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363132_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363140_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363132_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363140_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363141_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363141_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363144_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363183_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363144_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363177_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363179_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363201_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363219_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363201_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363231_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363219_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363223_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363231_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363233_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363296_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363290_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363292_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363290_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363296_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363316_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363356_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363576_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363356_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363568_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364161_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363568_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363604_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363576_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364162_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363578_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363602_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363578_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363954_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363602_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363604_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363608_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363954_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363608_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363618_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363618_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363624_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363898_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363626_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363819_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363626_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363663_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363648_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363820_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363652_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363663_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363652_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363700_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363665_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363704_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363698_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363700_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363698_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363704_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363719_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363727_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363727_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363728_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363728_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363731_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363776_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363731_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363770_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363772_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363776_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363811_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363819_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363811_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363819_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363820_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363823_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363873_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363823_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363867_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363869_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363873_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363889_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363897_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363889_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363897_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363898_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363901_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363937_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363931_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363933_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363931_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363954_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364068_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363977_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364067_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363977_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364006_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363998_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364039_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364008_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364043_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364008_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364037_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364039_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364037_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364043_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364059_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364067_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364059_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364077_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364067_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364068_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364071_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364077_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364071_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364128_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364079_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364132_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364079_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364126_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364128_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364132_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364153_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364161_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364153_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364161_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364162_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364173_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364297_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364175_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364297_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364175_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364194_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364183_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364196_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364255_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364194_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364196_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364200_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364259_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364200_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364253_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364255_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364253_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364259_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364297_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364308_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364308_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364362_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364318_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364367_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364360_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364362_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364400_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1366309_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364400_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1365540_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364401_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1397277_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364459_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1365271_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364459_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364804_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364467_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364710_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364467_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364485_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364515_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364485_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364527_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364513_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364519_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364620_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364519_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364527_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364621_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364529_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364535_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364529_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364583_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364537_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364587_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364581_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364583_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364581_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364610_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364620_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364674_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364620_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364621_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364624_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364678_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364672_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364674_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364696_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364710_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364696_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364722_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364710_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364711_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364711_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1365124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364714_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364722_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364714_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364724_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364730_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364724_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364732_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364776_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364732_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364770_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364772_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364776_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364804_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364815_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364804_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1365125_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364815_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364853_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364861_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364853_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364869_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364863_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364863_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364871_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1365040_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364898_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1364879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
