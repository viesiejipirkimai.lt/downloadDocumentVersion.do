Properties of the parts of a building model (IFC2X3), part 11 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1286059_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286045_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286065_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286059_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286117_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286059_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286101_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286108_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286174_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286108_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286128_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286117_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286174_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286128_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286542_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286134_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286378_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286134_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286154_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286154_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286368_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286378_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286368_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286444_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286436_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416272_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286436_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416119_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286444_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416273_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286533_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287488_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286533_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286738_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286541_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286541_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286542_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286541_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287489_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286726_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286978_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286726_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286839_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286738_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286979_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286746_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286845_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286746_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286837_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286839_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286837_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286845_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286970_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287041_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286970_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287014_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286978_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286979_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286978_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287042_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286988_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287006_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286988_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287014_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287004_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287006_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287041_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287042_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287041_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287388_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287221_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287387_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287221_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287235_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287229_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287235_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287229_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287274_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287243_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287282_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287243_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287272_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287274_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287272_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287282_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287377_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287387_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287377_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287431_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287387_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287388_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287395_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287439_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287395_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287429_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287431_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287429_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287439_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287466_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287980_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287466_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287504_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287488_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287489_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287488_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288207_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287498_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287504_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287498_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287518_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287518_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287724_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287724_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287807_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287732_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287813_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287732_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287805_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287807_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287805_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287813_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287972_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287988_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287972_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288040_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287980_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287981_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287980_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287988_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287981_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288206_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287994_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288081_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287994_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288038_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288040_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288038_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288081_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288198_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288214_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288198_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288226_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288206_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288207_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288206_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288214_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288220_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288226_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288220_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288304_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288267_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288310_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288267_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288302_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288304_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288302_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288310_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1288808_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288830_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288872_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288864_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288872_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288864_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288959_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1288959_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289826_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289817_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290150_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289817_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289826_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290150_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289831_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289831_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289837_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289837_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290448_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289843_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289843_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290199_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289851_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1289851_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295079_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290191_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291411_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290251_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417260_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1290448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291396_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291410_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291396_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291410_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291754_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292384_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291754_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291792_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291786_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291942_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291786_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291872_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291792_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292233_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291800_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291878_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291800_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291870_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291872_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291870_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291878_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291934_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291942_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291942_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291943_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292232_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291952_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292075_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291952_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291958_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292076_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291966_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292043_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1291966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292035_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292037_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292043_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292064_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292083_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292064_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292073_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292075_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292073_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292083_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292075_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292076_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292224_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292232_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292248_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292242_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292242_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292302_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292304_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292302_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1292352_1 | SOURCE
Port_1292372_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292384_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292372_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292384_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292385_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293561_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292394_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292461_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292453_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292455_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292453_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292736_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292533_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292494_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292494_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294677_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292494_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292692_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293041_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292502_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292539_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292531_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292533_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292539_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292691_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292701_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292691_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292692_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292691_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292737_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292701_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292728_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292746_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292728_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292856_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292737_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292736_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292746_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292854_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292856_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1292854_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1292996_1 | SOURCE
Port_1293029_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293041_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293029_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293041_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293042_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293042_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293186_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293051_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293057_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293051_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293065_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293149_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293065_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293139_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293141_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293139_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293182_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293395_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293182_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293186_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293213_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293307_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293213_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293233_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293227_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293227_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293241_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293278_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293241_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293268_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293299_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293307_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293299_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293307_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293308_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293394_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293317_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293361_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293351_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293353_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293351_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293361_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293382_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293394_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293395_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293404_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297086_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293404_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293483_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293410_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297087_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293481_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293483_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293481_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1293523_1 | SOURCE
Port_1293547_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293561_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293858_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293562_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293562_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294676_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293836_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293858_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293836_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293872_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293866_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294288_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293866_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1293872_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294541_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294140_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294148_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294148_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294280_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294288_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294280_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294288_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294289_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294540_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294298_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294304_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294298_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294341_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294339_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294341_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294339_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1294383_1 | SOURCE
Port_1294532_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294540_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294556_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294540_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294541_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294550_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294629_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294550_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294589_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294556_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294630_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294564_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294595_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294564_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294587_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294589_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294587_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294595_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294616_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294637_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294616_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294627_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294629_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294630_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294658_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294676_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294782_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294677_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294725_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294782_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294725_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294790_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294980_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294910_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294796_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294981_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294902_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294910_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1294949_1 | SOURCE
Port_1294972_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294980_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294972_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294980_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294988_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294994_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1294988_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295002_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295045_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295037_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295039_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295045_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295078_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295078_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295202_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295193_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295379_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295193_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295202_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295201_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295314_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295201_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295380_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295380_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295379_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295555_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295555_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295563_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295569_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295563_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295601_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295577_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295601_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295577_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295607_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295613_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295695_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295764_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295764_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295886_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295785_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296119_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295785_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295799_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295793_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295799_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295793_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295842_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295807_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295848_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295807_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295840_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295842_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295840_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295885_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295901_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295885_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295886_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295885_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296120_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295895_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295998_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295895_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295959_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295999_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295909_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295967_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295909_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295957_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295959_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295957_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295967_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295988_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296006_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295988_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295998_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295999_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1295998_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296006_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296012_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296076_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296012_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296035_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296037_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296076_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296097_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296119_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296097_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296135_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296129_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296358_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296129_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296135_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296359_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296268_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1296322_1 | SOURCE
Port_1296346_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296552_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296380_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296358_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296359_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296358_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296368_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296368_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296553_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296374_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296926_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296374_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296427_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296380_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296927_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296427_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296435_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296435_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296511_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296441_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296517_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296441_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296509_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296511_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296509_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296517_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296544_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296584_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296544_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296552_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296552_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296584_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296627_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296629_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296670_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296670_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296926_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296927_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296934_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297015_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297023_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1296948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297013_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297015_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297013_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297023_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297074_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297086_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297074_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297102_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297086_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297087_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297096_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297102_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297096_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297177_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297143_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297183_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297175_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297177_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1297260_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297268_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297312_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297269_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297269_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297312_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297400_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299276_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297467_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297459_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298568_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297459_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297737_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297467_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297998_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297537_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297553_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297653_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297651_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297653_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297758_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297766_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297758_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297838_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297767_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297766_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297767_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297883_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297774_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297844_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297836_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297838_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297836_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297865_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297883_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297865_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297953_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297884_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297884_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297997_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297951_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297953_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297951_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297959_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297959_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297987_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297997_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297987_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298061_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297997_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297998_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298005_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298067_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298059_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298061_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298059_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298067_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298130_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298150_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298130_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298140_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299277_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298140_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298150_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298156_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302030_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298156_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298162_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302031_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298236_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298238_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298236_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 78
Port_1298292_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 78
OutPort_1298332_1 | SOURCE
OutPort_1298356_1 | SOURCE
Port_1298568_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298568_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298576_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298576_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299006_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298742_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298879_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298756_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298750_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298756_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298801_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298799_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298801_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298799_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298809_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298809_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298871_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298879_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298871_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298895_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298879_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298880_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298880_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299005_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298889_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298895_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298889_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298938_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298936_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298938_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298944_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298991_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299005_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1298991_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299049_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299006_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299015_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299057_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299015_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299047_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299049_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299047_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299246_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 79
Port_1299246_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 79
Port_1299266_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299276_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299266_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299277_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299284_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299639_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299330_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299290_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299513_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299298_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299336_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299298_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299328_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299330_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299328_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299382_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299403_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299393_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299395_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299393_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299395_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299396_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299395_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299640_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299396_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299512_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299502_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299512_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299512_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299513_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299522_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299528_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299522_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299571_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299536_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299577_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299536_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299571_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299577_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299629_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299639_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299655_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299639_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299640_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299649_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299649_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299729_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299696_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299768_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299696_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299727_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299729_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299768_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1299803_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 80
Port_1299803_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 80
Port_1299869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1299869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300089_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300089_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300186_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300186_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300200_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300194_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300200_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1504146_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300324_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300332_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300467_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300332_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300333_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300333_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300459_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301132_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300459_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300658_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300467_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300990_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300650_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300650_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300699_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300666_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300705_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300666_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300697_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300699_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300697_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300705_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300981_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300989_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301029_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300989_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300990_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300989_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302854_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300997_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301035_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1300997_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301027_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301029_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301027_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301122_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302733_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301122_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301148_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301132_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301133_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301132_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302734_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301133_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302853_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301142_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302624_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301148_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302625_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301156_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301156_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301162_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301692_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301205_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301207_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301205_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
OutPort_1301274_1 | SOURCE
Port_1301375_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301487_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301375_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301399_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301384_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
