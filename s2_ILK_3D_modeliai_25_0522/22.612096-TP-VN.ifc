Properties of the parts of a building model (IFC2X3), part 14 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1335189_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335190_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335193_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335236_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335193_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335232_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335236_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335256_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335264_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335256_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335264_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335265_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335265_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335571_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335319_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335313_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335315_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335313_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335319_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335334_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335425_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335334_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335391_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335344_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335572_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335344_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335345_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335344_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335497_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335345_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335348_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335395_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335348_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335389_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335391_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335389_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335395_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335417_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335425_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335469_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335425_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335426_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335426_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335429_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335473_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335429_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335467_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335469_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335467_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335473_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335488_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335496_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335496_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335497_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335500_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335545_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335500_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335539_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335541_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335539_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335545_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335563_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335571_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335563_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335625_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335571_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335572_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335575_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335629_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335575_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335623_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335625_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335629_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335646_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335748_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335646_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335667_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335654_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335654_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335749_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335655_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336089_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335658_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335667_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335658_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335706_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335669_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335708_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335669_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335704_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335706_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335704_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335708_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335738_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335748_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335748_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1491614_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335752_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335763_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335752_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335765_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335841_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335835_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335837_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335835_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335841_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335857_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335867_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335857_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336031_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335871_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335914_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335918_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335912_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335914_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335912_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335934_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335942_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335934_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335997_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335942_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335943_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335943_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336030_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335946_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336001_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335946_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335995_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335997_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336001_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336020_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336030_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336030_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336031_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336043_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336058_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336043_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336052_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336054_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336081_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336089_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336081_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336099_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336089_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336090_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336093_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336099_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336093_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336118_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336101_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336118_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336101_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336139_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336120_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336143_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336120_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336137_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336139_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336137_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336143_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336193_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336187_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336193_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336187_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336223_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1366856_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336384_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336231_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336233_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336231_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1369044_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336384_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336382_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337270_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336403_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336403_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336550_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336436_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337959_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336436_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337659_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336459_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336894_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336459_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336460_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336459_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337395_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336460_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337269_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336542_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336552_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336542_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336550_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336552_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336556_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336598_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336556_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336592_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336594_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336613_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336623_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336636_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336623_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336624_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336627_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336636_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336627_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336683_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336638_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336687_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336638_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336681_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336683_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336681_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336705_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336713_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336705_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336723_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336713_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336714_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336714_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336717_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336723_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336758_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336725_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336762_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336725_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336756_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336758_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336756_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336762_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336780_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336788_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336780_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336804_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336788_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336789_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336893_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336792_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336804_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336792_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336864_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336806_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336868_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336806_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336862_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336864_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336862_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336885_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336893_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336885_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336903_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336893_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336894_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336897_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336903_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336905_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337180_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336905_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336975_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336921_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337181_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336923_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336977_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336923_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336973_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336975_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336977_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337174_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337180_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337195_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337180_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337181_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337184_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337195_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337184_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337197_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337240_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337197_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337236_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337238_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337236_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337240_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337259_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337269_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337259_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337314_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337269_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337270_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337273_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337316_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337273_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337312_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337314_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337338_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337572_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337338_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337423_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337394_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338124_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337394_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337395_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337394_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337496_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337398_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337425_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337398_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337435_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337423_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337425_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337429_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337429_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337468_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337437_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337472_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337437_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337468_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337472_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337487_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337495_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337487_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337538_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337495_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337573_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337495_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337499_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337542_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337499_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337536_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337538_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337542_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337564_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337572_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337564_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337572_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337573_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337576_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337621_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337576_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337615_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337617_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337621_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337657_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337873_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337657_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337659_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337663_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337764_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337663_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337684_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337676_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337684_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337686_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337729_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337686_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337725_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337727_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337725_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337754_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337764_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337754_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337792_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337764_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337765_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337872_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337784_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337792_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337784_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337794_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337841_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337835_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337837_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337835_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337841_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337864_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337872_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337864_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337930_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337872_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337873_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337876_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337934_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337928_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337930_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337928_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337934_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337949_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337959_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337949_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338007_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337959_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337960_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337960_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337963_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338009_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1337963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338005_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338007_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338005_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338009_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338034_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338048_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338088_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338048_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338049_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338049_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338052_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338090_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338086_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338088_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338086_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338090_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338111_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490171_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338111_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338187_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338123_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338123_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490172_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338127_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338191_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338127_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338185_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338187_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338191_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338223_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1396380_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338227_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338229_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338227_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338229_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386030_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338229_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387815_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338233_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348678_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338238_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1401711_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1396380_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338319_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1401734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338319_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338704_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338704_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338705_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338704_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362086_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338705_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403176_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338717_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339795_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338779_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338789_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338779_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338854_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339044_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338854_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339683_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338868_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339681_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338870_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338900_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338870_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338964_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338900_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339683_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338908_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338968_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338908_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338962_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338964_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338962_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338968_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338983_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338983_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339073_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339044_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339045_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339044_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339164_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339045_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339299_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339050_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339075_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339073_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339075_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339079_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339119_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339079_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339113_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339115_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339113_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339119_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339140_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339163_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339140_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339202_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339163_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339164_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339167_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339204_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339204_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339208_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339251_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339245_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339247_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339245_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339289_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339608_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339289_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339313_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339299_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339300_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339299_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339609_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339300_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339681_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339305_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339461_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339305_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339333_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339313_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339577_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339315_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339335_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339433_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339339_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339437_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339339_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339431_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339433_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339431_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339437_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339453_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339461_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339453_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339545_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339461_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339462_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339462_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339576_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339465_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339549_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339543_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339545_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339565_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339580_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339574_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339576_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339574_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339580_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339576_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339577_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339596_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339608_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339620_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339608_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339609_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339612_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339620_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339612_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339663_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339622_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339667_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339622_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339661_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339663_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339667_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339747_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340291_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339747_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339795_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339796_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339795_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341334_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339796_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1362085_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339818_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339826_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339838_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339826_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339828_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339832_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339838_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339832_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339872_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339866_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339868_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339866_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339872_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339896_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339904_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339896_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339956_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340292_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339904_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339905_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339905_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339908_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339960_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339908_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339954_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339956_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339954_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1339960_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340281_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340291_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340281_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340344_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340291_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340295_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340348_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340295_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340342_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340344_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340342_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340348_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340363_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340371_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340412_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340371_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340372_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340372_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340440_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340375_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340416_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340375_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340410_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340412_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340410_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340416_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340432_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340440_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340432_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340482_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340440_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340441_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340441_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340444_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340486_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340480_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340482_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340480_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340501_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340880_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340501_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340523_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340509_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340510_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340509_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340955_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340510_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340513_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340539_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340523_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340802_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340525_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340541_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340525_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340539_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340545_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340554_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340545_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340653_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340661_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340705_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340663_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340707_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340663_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340703_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340705_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340703_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340707_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340722_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340730_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340722_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340730_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340731_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340731_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340801_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340734_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340776_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340770_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340772_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340776_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340793_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340801_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340847_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340801_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340802_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340805_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340851_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340805_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340845_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340847_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340845_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340851_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340872_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340880_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340872_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340920_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340880_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340954_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340884_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340924_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340884_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340918_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340920_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340944_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340954_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340944_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340993_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340954_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340955_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340958_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340997_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340958_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340991_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340993_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1340997_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341012_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488154_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341012_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341032_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341020_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341020_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488155_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341021_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341024_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341032_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341042_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341034_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341187_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341058_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341042_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341259_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341044_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341060_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341044_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341072_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341060_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341064_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341072_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341064_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341138_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341074_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341142_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341074_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341136_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341138_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341136_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341142_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341173_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341187_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341228_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341187_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341188_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341188_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341258_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341191_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341232_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341191_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341226_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341228_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341226_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341232_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341248_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341258_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341248_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341258_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341259_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341262_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341305_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341299_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341301_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341299_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341305_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341325_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488226_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341325_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341343_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341333_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341334_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341333_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1488227_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341337_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341343_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341337_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341358_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341345_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341345_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341366_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341358_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341541_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341360_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341366_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341376_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341368_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341376_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341419_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341378_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341423_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341378_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341417_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341419_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341423_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341448_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341454_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341448_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341454_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341540_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341458_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341511_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341458_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341505_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341507_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341505_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341528_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341540_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341528_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341552_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341540_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341544_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341552_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341544_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341554_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341591_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341585_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341587_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341591_1 | SOURCEANDSINK | vanduo šaltas - V1 2
InPort_1341658_0 | SINK | vanduo šaltas - V1 2
OutPort_1341827_2 | SOURCE | vanduo šaltas - V1 2
InPort_1341744_1 | SINK | vanduo šaltas - V1 2
OutPort_1341658_1 | SOURCE | vanduo šaltas - V1 2
Port_1341666_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404167_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341666_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344071_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341666_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393362_0 | SOURCEANDSINK | vanduo šaltas - V1 2
InPort_1341720_0 | SINK | vanduo šaltas - V1 2
OutPort_1341744_2 | SOURCE | vanduo šaltas - V1 2
InPort_1341763_1 | SINK | vanduo šaltas - V1 2
OutPort_1341720_1 | SOURCE | vanduo šaltas - V1 2
Port_1341782_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341827_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341782_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341895_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341827_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341828_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395062_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341873_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341873_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341905_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341895_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341978_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341897_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342618_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342680_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341905_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342537_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341907_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343207_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343030_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341933_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346136_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341942_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346116_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341942_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343286_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341969_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342287_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341977_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341977_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341978_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341977_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342369_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341981_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342024_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1341981_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342018_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342020_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342018_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342261_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342287_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342261_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342328_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342287_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342288_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342288_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342291_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342332_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342291_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342326_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342328_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342326_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342332_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342362_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342368_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342362_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342383_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342368_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342372_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342383_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342372_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342426_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342385_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342430_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342385_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342424_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342426_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342430_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342465_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342494_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342465_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342469_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342498_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342469_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342492_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342494_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342492_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342498_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342522_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342536_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342522_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342588_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342619_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342536_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342540_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342592_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342540_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342586_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342588_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342586_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342608_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342618_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342608_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342659_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342618_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342622_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342663_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342622_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342657_0 | SOURCEANDSINK | vanduo šaltas - V1 2
