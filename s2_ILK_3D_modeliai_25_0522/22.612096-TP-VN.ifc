Properties of the parts of a building model (IFC2X3), part 13 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1313770_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313764_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313765_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313765_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313796_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313778_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313788_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313780_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313782_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313788_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313794_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313796_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313806_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313797_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313797_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313852_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313812_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313804_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313806_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313818_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313820_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313818_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313828_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313820_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313820_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313853_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313821_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313890_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313826_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313828_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313826_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313838_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313834_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313844_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313834_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313836_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313838_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313836_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313850_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313858_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313864_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313852_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313858_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313864_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313870_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313870_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313872_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313882_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313872_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313874_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313876_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313874_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313888_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313890_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313888_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313898_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313891_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313896_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313930_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313896_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313898_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313955_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313904_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313906_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313904_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313916_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313922_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313914_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313916_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313914_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313922_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313928_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313930_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313930_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313931_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313931_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313954_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313936_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313946_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313938_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313938_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313946_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313952_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313954_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313952_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313964_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313954_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313955_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313960_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313970_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313960_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313962_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313964_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313962_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313970_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313976_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313978_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313976_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313986_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313978_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313984_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313986_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313984_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313996_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313992_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1314002_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313992_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313994_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313996_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1314002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1314993_1 | SOURCEANDSINK | K1 2
Port_1315109_0 | SOURCEANDSINK | K1 2
Port_1317329_2 | SOURCEANDSINK | K1 2
Port_1315109_1 | SOURCEANDSINK | K1 2
Port_1316265_1 | SOURCEANDSINK | K1 2
Port_1315117_2 | SOURCEANDSINK | K1 2
Port_1315118_0 | SOURCEANDSINK | K1 2
Port_1315117_3 | SOURCEANDSINK | K1 2
Port_1315118_1 | SOURCEANDSINK | K1 2
Port_1316235_0 | SOURCEANDSINK | K1 2
Port_1316829_2 | SOURCEANDSINK | K1 2
Port_1316235_1 | SOURCEANDSINK | K1 2
Port_1316362_1 | SOURCEANDSINK | K1 2
Port_1316265_2 | SOURCEANDSINK | K1 2
Port_1317208_0 | SOURCEANDSINK | K1 2
Port_1316311_0 | SOURCEANDSINK | K1 2
Port_1316362_2 | SOURCEANDSINK | K1 2
Port_1316311_1 | SOURCEANDSINK | K1 2
Port_1316352_1 | SOURCEANDSINK | K1 2
Port_1316517_0 | SOURCEANDSINK | K1 2
Port_1316525_3 | SOURCEANDSINK | K1 2
Port_1316517_1 | SOURCEANDSINK | K1 2
Port_1316588_1 | SOURCEANDSINK | K1 2
Port_1316525_1 | SOURCEANDSINK | K1 2
Port_1316526_1 | SOURCEANDSINK | K1 2
Port_1316525_2 | SOURCEANDSINK | K1 2
Port_1317458_0 | SOURCEANDSINK | K1 2
Port_1316526_0 | SOURCEANDSINK | K1 2
Port_1317207_2 | SOURCEANDSINK | K1 2
Port_1316533_0 | SOURCEANDSINK | K1 2
Port_1316596_2 | SOURCEANDSINK | K1 2
Port_1316533_1 | SOURCEANDSINK | K1 2
Port_1316586_0 | SOURCEANDSINK | K1 2
Port_1316588_2 | SOURCEANDSINK | K1 2
Port_1316586_1 | SOURCEANDSINK | K1 2
Port_1316596_1 | SOURCEANDSINK | K1 2
Port_1316617_0 | SOURCEANDSINK | K1 2
Port_1316629_3 | SOURCEANDSINK | K1 2
Port_1316617_1 | SOURCEANDSINK | K1 2
Port_1316707_1 | SOURCEANDSINK | K1 2
Port_1316629_1 | SOURCEANDSINK | K1 2
Port_1316630_1 | SOURCEANDSINK | K1 2
Port_1316629_2 | SOURCEANDSINK | K1 2
Port_1317011_0 | SOURCEANDSINK | K1 2
Port_1316630_0 | SOURCEANDSINK | K1 2
Port_1317457_2 | SOURCEANDSINK | K1 2
Port_1316637_0 | SOURCEANDSINK | K1 2
Port_1316715_2 | SOURCEANDSINK | K1 2
Port_1316637_1 | SOURCEANDSINK | K1 2
Port_1316705_0 | SOURCEANDSINK | K1 2
Port_1316707_2 | SOURCEANDSINK | K1 2
Port_1316705_1 | SOURCEANDSINK | K1 2
Port_1316715_1 | SOURCEANDSINK | K1 2
Port_1316737_0 | SOURCEANDSINK | K1 2
Port_1316749_3 | SOURCEANDSINK | K1 2
Port_1316737_1 | SOURCEANDSINK | K1 2
Port_1316788_1 | SOURCEANDSINK | K1 2
Port_1316749_1 | SOURCEANDSINK | K1 2
Port_1316750_1 | SOURCEANDSINK | K1 2
Port_1316749_2 | SOURCEANDSINK | K1 2
Port_1317603_0 | SOURCEANDSINK | K1 2
Port_1316750_0 | SOURCEANDSINK | K1 2
Port_1317010_2 | SOURCEANDSINK | K1 2
Port_1316757_0 | SOURCEANDSINK | K1 2
Port_1316796_2 | SOURCEANDSINK | K1 2
Port_1316757_1 | SOURCEANDSINK | K1 2
Port_1316786_0 | SOURCEANDSINK | K1 2
Port_1316788_2 | SOURCEANDSINK | K1 2
Port_1316786_1 | SOURCEANDSINK | K1 2
Port_1316796_1 | SOURCEANDSINK | K1 2
Port_1316817_0 | SOURCEANDSINK | K1 2
Port_1316829_3 | SOURCEANDSINK | K1 2
Port_1316817_1 | SOURCEANDSINK | K1 2
Port_1316889_1 | SOURCEANDSINK | K1 2
Port_1316829_1 | SOURCEANDSINK | K1 2
Port_1316830_1 | SOURCEANDSINK | K1 2
Port_1316830_0 | SOURCEANDSINK | K1 2
Port_1317602_2 | SOURCEANDSINK | K1 2
Port_1316839_0 | SOURCEANDSINK | K1 2
Port_1316897_2 | SOURCEANDSINK | K1 2
Port_1316839_1 | SOURCEANDSINK | K1 2
Port_1316887_0 | SOURCEANDSINK | K1 2
Port_1316889_2 | SOURCEANDSINK | K1 2
Port_1316887_1 | SOURCEANDSINK | K1 2
Port_1316897_1 | SOURCEANDSINK | K1 2
Port_1317002_0 | SOURCEANDSINK | K1 2
Port_1317115_2 | SOURCEANDSINK | K1 2
Port_1317002_1 | SOURCEANDSINK | K1 2
Port_1317026_2 | SOURCEANDSINK | K1 2
Port_1317010_1 | SOURCEANDSINK | K1 2
Port_1317011_1 | SOURCEANDSINK | K1 2
Port_1317010_3 | SOURCEANDSINK | K1 2
Port_1317116_0 | SOURCEANDSINK | K1 2
Port_1317020_0 | SOURCEANDSINK | K1 2
Port_1317026_1 | SOURCEANDSINK | K1 2
Port_1317020_1 | SOURCEANDSINK | K1 2
Port_1317076_1 | SOURCEANDSINK | K1 2
Port_1317034_0 | SOURCEANDSINK | K1 2
Port_1317082_2 | SOURCEANDSINK | K1 2
Port_1317034_1 | SOURCEANDSINK | K1 2
Port_1317074_0 | SOURCEANDSINK | K1 2
Port_1317076_2 | SOURCEANDSINK | K1 2
Port_1317074_1 | SOURCEANDSINK | K1 2
Port_1317082_1 | SOURCEANDSINK | K1 2
Port_1317103_0 | SOURCEANDSINK | K1 2
Port_1317115_3 | SOURCEANDSINK | K1 2
Port_1317103_1 | SOURCEANDSINK | K1 2
Port_1317129_2 | SOURCEANDSINK | K1 2
Port_1317115_1 | SOURCEANDSINK | K1 2
Port_1317116_1 | SOURCEANDSINK | K1 2
Port_1317123_0 | SOURCEANDSINK | K1 2
Port_1317129_1 | SOURCEANDSINK | K1 2
Port_1317123_1 | SOURCEANDSINK | K1 2
Port_1317169_1 | SOURCEANDSINK | K1 2
Port_1317137_0 | SOURCEANDSINK | K1 2
Port_1317177_2 | SOURCEANDSINK | K1 2
Port_1317137_1 | SOURCEANDSINK | K1 2
Port_1317167_0 | SOURCEANDSINK | K1 2
Port_1317169_2 | SOURCEANDSINK | K1 2
Port_1317167_1 | SOURCEANDSINK | K1 2
Port_1317177_1 | SOURCEANDSINK | K1 2
Port_1317199_0 | SOURCEANDSINK | K1 2
Port_1317207_3 | SOURCEANDSINK | K1 2
Port_1317199_1 | SOURCEANDSINK | K1 2
Port_1317289_1 | SOURCEANDSINK | K1 2
Port_1317207_1 | SOURCEANDSINK | K1 2
Port_1317208_1 | SOURCEANDSINK | K1 2
Port_1317278_0 | SOURCEANDSINK | K1 2
Port_1317295_2 | SOURCEANDSINK | K1 2
Port_1317278_1 | SOURCEANDSINK | K1 2
Port_1317287_0 | SOURCEANDSINK | K1 2
Port_1317289_2 | SOURCEANDSINK | K1 2
Port_1317287_1 | SOURCEANDSINK | K1 2
Port_1317295_1 | SOURCEANDSINK | K1 2
Port_1317317_0 | SOURCEANDSINK | K1 2
Port_1317329_3 | SOURCEANDSINK | K1 2
Port_1317317_1 | SOURCEANDSINK | K1 2
Port_1317378_1 | SOURCEANDSINK | K1 2
Port_1317329_1 | SOURCEANDSINK | K1 2
Port_1317337_0 | SOURCEANDSINK | K1 2
Port_1317384_2 | SOURCEANDSINK | K1 2
Port_1317337_1 | SOURCEANDSINK | K1 2
Port_1317376_0 | SOURCEANDSINK | K1 2
Port_1317378_2 | SOURCEANDSINK | K1 2
Port_1317376_1 | SOURCEANDSINK | K1 2
Port_1317384_1 | SOURCEANDSINK | K1 2
Port_1317447_0 | SOURCEANDSINK | K1 2
Port_1317457_3 | SOURCEANDSINK | K1 2
Port_1317447_1 | SOURCEANDSINK | K1 2
Port_1317473_2 | SOURCEANDSINK | K1 2
Port_1317457_1 | SOURCEANDSINK | K1 2
Port_1317458_1 | SOURCEANDSINK | K1 2
Port_1317467_0 | SOURCEANDSINK | K1 2
Port_1317473_1 | SOURCEANDSINK | K1 2
Port_1317467_1 | SOURCEANDSINK | K1 2
Port_1317562_1 | SOURCEANDSINK | K1 2
Port_1317514_0 | SOURCEANDSINK | K1 2
Port_1317568_2 | SOURCEANDSINK | K1 2
Port_1317514_1 | SOURCEANDSINK | K1 2
Port_1317560_0 | SOURCEANDSINK | K1 2
Port_1317562_2 | SOURCEANDSINK | K1 2
Port_1317560_1 | SOURCEANDSINK | K1 2
Port_1317568_1 | SOURCEANDSINK | K1 2
Port_1317590_0 | SOURCEANDSINK | K1 2
Port_1317612_2 | SOURCEANDSINK | K1 2
Port_1317590_1 | SOURCEANDSINK | K1 2
Port_1317624_1 | SOURCEANDSINK | K1 2
Port_1317602_1 | SOURCEANDSINK | K1 2
Port_1317603_1 | SOURCEANDSINK | K1 2
Port_1317602_3 | SOURCEANDSINK | K1 2
Port_1317612_1 | SOURCEANDSINK | K1 2
Port_1317618_0 | SOURCEANDSINK | K1 2
Port_1317624_2 | SOURCEANDSINK | K1 2
Port_1317618_1 | SOURCEANDSINK | K1 2
Port_1317669_1 | SOURCEANDSINK | K1 2
Port_1317663_0 | SOURCEANDSINK | K1 2
Port_1317669_2 | SOURCEANDSINK | K1 2
Port_1317663_1 | SOURCEANDSINK | K1 2
Port_1317783_1 | SOURCEANDSINK | K1 2
Port_1317781_0 | SOURCEANDSINK | K1 2
Port_1317783_2 | SOURCEANDSINK | K1 2
Port_1317781_1 | SOURCEANDSINK | K1 2
OutPort_1317862_1 | SOURCE
Port_1317906_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1868035_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318003_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317914_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317915_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317914_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318196_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317981_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318003_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318088_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318090_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318088_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
OutPort_1318155_1 | SOURCE
Port_1318181_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318195_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318211_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318195_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318195_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1868036_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318205_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318382_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318205_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318307_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318211_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318425_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318219_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318313_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318219_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318305_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318307_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318305_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318313_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318340_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 88
Port_1318340_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 88
Port_1318367_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318390_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318367_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318380_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318382_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318380_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318390_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318383_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318383_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318424_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318412_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318424_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318412_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318471_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318425_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318432_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318477_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318432_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318469_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318471_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318469_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318477_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1318547_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318644_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318741_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318556_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318741_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318763_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318763_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318828_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318830_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318828_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318881_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318881_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318912_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318898_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318898_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318906_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318900_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319034_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1318900_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319944_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319034_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319053_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319053_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319805_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319061_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319385_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319061_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319246_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319254_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319246_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319319_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319262_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319327_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319317_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319319_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319327_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319386_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319385_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319613_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319386_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320219_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319756_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319746_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319748_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319746_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319756_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319796_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319804_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319905_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319805_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319804_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320220_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319812_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319913_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319903_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319905_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319913_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319933_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319943_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319933_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320045_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319943_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319967_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320053_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1319967_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320043_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320045_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320043_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320053_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320449_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320233_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320219_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320219_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320348_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320227_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320227_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320272_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320241_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320278_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320241_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320270_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320272_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320337_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320347_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320347_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320348_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320347_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320658_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320357_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320415_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320409_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320415_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320437_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320449_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320437_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320465_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320450_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320657_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320459_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320569_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320459_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320479_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320465_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320570_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320473_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320479_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320473_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320526_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320524_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320526_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320524_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320532_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320532_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320559_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320569_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320610_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320570_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320608_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320610_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320608_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320616_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320616_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320643_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320657_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320643_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320721_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320667_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320727_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320719_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320721_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320719_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1320727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1328765_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328767_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1371930_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328767_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1370621_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328767_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329948_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328778_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407334_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328778_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354794_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328900_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328941_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328900_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328911_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423675_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328911_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328941_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423676_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328941_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328942_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329590_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329596_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329590_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329953_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329600_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329953_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329979_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329948_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404473_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1329979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330229_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330137_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1370620_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330137_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330160_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330160_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336179_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330185_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395707_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330329_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330228_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1400456_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330228_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330229_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330228_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1396675_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330304_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330329_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330304_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330456_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330444_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330456_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330521_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330513_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363356_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330521_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1363357_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330604_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330606_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330604_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332390_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330732_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330786_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330732_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330827_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331175_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330821_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331323_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330821_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330827_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331324_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1330998_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331000_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331000_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331103_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331051_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331107_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331051_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331101_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331103_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331101_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331107_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331123_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331204_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331217_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331175_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331204_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331204_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331205_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331205_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331499_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331209_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331217_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331209_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331219_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331280_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331276_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331278_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331276_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331280_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331323_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331324_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331323_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331327_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331327_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331333_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331371_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331367_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331369_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331427_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331802_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331427_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331554_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331499_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331500_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331499_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489601_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331500_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331503_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331625_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331503_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331558_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331558_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331673_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331562_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331598_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331562_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331592_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331594_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331614_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331629_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331614_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331623_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331625_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331629_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331625_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331626_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331626_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331655_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331676_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331670_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331672_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331670_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331672_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331673_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331694_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331729_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331694_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331762_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331803_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331729_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331730_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1489600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331733_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331766_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331733_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331760_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331762_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331760_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331766_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331794_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331802_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331863_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331802_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331803_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331806_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331806_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331863_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331949_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331949_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332062_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331961_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331962_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331961_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332092_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331962_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331965_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332066_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1331965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332060_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332062_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332060_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332066_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332083_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332158_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332083_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332091_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332092_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332091_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332159_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332104_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332119_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332104_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332113_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332115_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332113_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332119_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332152_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332158_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332152_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332170_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332158_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332159_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332162_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332170_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332162_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332172_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332237_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332172_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332231_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332233_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332231_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332255_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332278_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332255_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332314_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332487_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332278_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332279_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332279_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332303_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332345_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332303_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332312_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332314_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332316_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332346_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332339_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332345_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332339_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332363_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332345_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332346_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332349_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332349_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332377_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332389_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332377_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332425_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332389_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332654_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332389_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332390_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332393_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332429_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332393_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332423_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332425_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332423_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332429_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332519_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332486_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332487_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332486_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332552_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332490_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332521_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332490_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332517_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332519_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332517_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332521_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332543_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332551_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332579_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332551_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332552_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332555_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332579_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332555_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332581_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332619_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332581_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332615_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332617_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332635_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332653_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332695_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332653_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332657_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332657_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332693_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332695_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332693_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332781_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1400913_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332781_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1370823_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332789_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1338223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332789_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1371281_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332850_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1366308_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333410_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1332858_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1397278_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333396_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333396_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333494_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333408_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333410_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333408_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333666_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333486_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333494_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333514_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333508_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335942_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333508_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333514_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335868_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333596_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333754_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333701_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333665_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333666_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333665_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333755_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333701_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333849_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333719_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333754_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333754_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333755_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333758_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333794_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333758_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333789_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333838_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333848_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333838_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333890_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333848_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333942_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333848_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333849_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333852_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333894_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333852_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333888_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333890_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333888_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333894_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333933_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334005_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333942_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334005_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333945_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333977_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333945_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333971_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333973_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333971_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1333977_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334036_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334631_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334036_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334122_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1336090_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334054_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334058_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334082_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334082_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334120_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334557_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334120_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334122_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334126_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334171_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334167_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334171_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334208_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334218_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334527_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334218_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334219_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334556_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334516_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334531_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334516_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334525_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334527_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334525_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334548_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490986_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334548_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334603_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334556_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334556_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1490987_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334560_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334607_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334560_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334601_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334603_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334607_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334623_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334631_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334631_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334735_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334635_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334641_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334643_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334689_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334643_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334685_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334687_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334685_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334689_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334726_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334734_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334726_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334734_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334735_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334738_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334749_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334751_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334793_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334789_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334809_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335189_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334809_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334853_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334817_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334817_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334894_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334818_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334821_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334857_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334821_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334851_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334853_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334851_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334857_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334885_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334893_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334885_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334938_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334893_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335190_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334893_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334894_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334897_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334942_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334938_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1334942_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335183_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335189_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1335232_1 | SOURCEANDSINK | vanduo šaltas - V1 2
