Properties of the parts of a building model (IFC2X3), part 16 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1350932_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350933_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351005_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350973_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350967_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350969_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350997_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351005_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350997_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351005_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351006_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351088_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351009_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351042_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351009_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351036_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351038_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351036_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351042_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351078_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351191_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351078_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351112_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351088_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351089_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351088_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351266_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351092_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351114_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351092_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351112_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351114_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351118_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351124_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351118_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351126_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351167_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351161_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351163_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351161_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351183_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351191_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351226_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351191_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351192_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351192_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351265_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351195_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351230_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351195_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351224_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351226_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351257_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351265_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351257_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351303_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351265_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351266_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351269_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351307_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351269_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351301_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351303_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351345_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351683_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351345_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351370_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351361_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351370_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351404_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351372_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351408_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351372_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351402_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351404_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351402_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351408_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351437_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351437_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351459_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351447_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351727_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351447_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351448_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351447_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351618_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351451_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351459_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351451_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351498_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351461_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351502_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351461_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351496_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351498_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351502_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351527_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351537_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351527_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351547_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351537_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351538_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351538_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351541_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351547_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351549_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351591_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351585_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351587_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351591_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351609_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351617_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351609_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351664_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351617_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351618_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351621_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351668_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351621_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351660_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351662_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351660_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351668_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351662_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351664_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351716_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351726_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351716_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351756_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351726_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351730_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351760_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351754_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351756_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351754_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351760_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351778_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352184_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351778_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351831_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351786_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351786_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351902_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352266_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351792_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351833_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351792_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351831_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351833_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351837_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351871_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351865_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351865_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351889_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351901_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351889_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351942_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352185_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351901_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351902_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351905_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351946_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351905_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351940_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351942_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351940_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351946_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352174_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352184_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352196_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352184_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352188_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352196_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352188_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352235_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352198_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352239_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352233_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352235_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352239_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352258_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352266_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352258_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352266_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352267_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352310_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352316_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352310_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352353_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352318_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352357_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352351_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352353_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352383_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352391_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352383_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352468_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352391_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1371935_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352391_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352392_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352392_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386029_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352822_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352538_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352468_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389441_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352524_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352524_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352538_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352536_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353432_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352583_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353909_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352583_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352624_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352635_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352624_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353968_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354140_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352669_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354485_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352669_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352687_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352677_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352677_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352689_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352689_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354550_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352693_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352693_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352745_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352701_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352749_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352701_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352743_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352745_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352743_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352823_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352822_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352996_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352823_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358779_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352860_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352860_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352874_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352868_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354000_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352886_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352874_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354001_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352876_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352886_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352894_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352888_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352894_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352888_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352912_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352896_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352912_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352896_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352914_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352967_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352914_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352961_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352963_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352985_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353092_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352985_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352995_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352996_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352995_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353735_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352999_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353054_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352999_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353048_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353050_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353084_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353092_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353084_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353330_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353092_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353093_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353093_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353096_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353330_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353096_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353136_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353104_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353140_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353104_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353134_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353136_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353134_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353140_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353330_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353341_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353341_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353363_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353351_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353365_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353405_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353365_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353399_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353401_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353399_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353405_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353421_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353431_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353421_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353431_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353645_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353431_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353432_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353435_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353511_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353505_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353507_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353505_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353630_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353644_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353630_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353682_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353645_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353648_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353686_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353680_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353682_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353680_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353686_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353726_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353734_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353726_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353744_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353734_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353735_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353738_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353744_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353776_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353746_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353778_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353774_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353776_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353774_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353778_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353807_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353815_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353815_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353817_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353821_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353862_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353821_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353856_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353858_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353856_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353862_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353898_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353913_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353898_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353907_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353909_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353913_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353909_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353910_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353910_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353924_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353939_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353933_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353935_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353939_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353935_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353936_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353952_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353971_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353952_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353965_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353967_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353971_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353967_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353968_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353992_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354000_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1353992_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354014_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354000_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354001_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354004_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354014_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354004_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354024_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354016_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354117_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354016_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354118_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354026_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354054_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354026_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354050_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354052_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354106_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354121_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354106_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354115_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354117_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354121_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354117_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354118_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354140_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354263_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354140_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354151_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354151_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354176_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354176_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354210_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354178_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354214_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354178_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354208_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354210_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354214_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354254_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354262_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354299_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354326_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354262_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354263_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354266_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354301_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354266_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354297_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354299_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354297_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354317_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354325_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354354_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354325_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354383_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354325_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354326_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354329_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354356_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354329_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354352_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354354_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354356_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354374_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354382_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354392_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354486_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354382_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354383_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354386_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354392_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354386_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354394_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354438_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354394_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354432_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354434_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354432_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354438_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354477_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354485_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354477_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354517_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354485_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354489_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354521_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354515_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354517_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354521_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354537_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354549_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354549_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354550_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354553_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354593_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354587_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354589_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354593_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354734_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354768_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354766_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354766_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354768_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354809_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356332_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354809_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354859_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354817_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354834_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354834_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356656_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354851_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354859_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354851_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354951_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355425_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354869_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354877_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354889_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354877_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354883_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354889_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354883_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354928_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354891_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354932_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354891_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354926_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354928_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354926_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354932_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354951_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354962_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354951_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356244_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354962_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355067_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354974_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355067_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354974_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354996_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354982_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354998_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354982_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355043_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354996_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355002_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355047_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355002_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355041_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355043_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355041_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355047_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355067_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355078_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355078_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355100_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355216_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355100_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355129_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355123_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355129_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355131_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355177_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355131_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355171_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355173_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355171_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355200_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355216_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355200_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355228_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355216_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355217_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355217_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355307_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355220_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355228_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355236_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355236_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355274_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355238_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355278_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355272_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355274_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355272_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355307_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355318_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355353_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355361_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355353_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355363_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355369_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355397_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355371_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355401_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355395_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355397_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355395_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355417_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355425_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355425_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355426_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355426_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355508_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355429_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355435_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355429_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355478_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355437_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355482_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355437_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355478_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355482_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355500_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355508_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355500_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355508_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355509_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355588_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355512_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355518_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355512_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355560_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355520_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355564_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355558_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355560_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355558_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355564_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355580_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355588_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355580_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355588_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355589_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355849_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355592_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355598_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355803_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355790_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355807_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355790_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355801_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355803_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355801_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355839_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355849_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355839_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355859_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355849_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355850_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355853_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355859_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355853_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355905_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355899_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355901_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355899_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355905_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355949_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355957_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355949_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355967_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355957_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356042_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355961_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356005_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355969_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356009_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1355969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356003_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356005_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356003_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356009_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356031_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356109_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356031_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356125_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356042_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356109_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356110_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356110_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356114_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356129_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356114_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356123_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356125_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356129_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356169_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356177_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356169_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356206_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356177_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356178_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356178_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356181_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356210_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356181_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356204_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356206_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356204_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356210_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356235_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356243_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356235_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356253_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356243_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356244_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356247_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356253_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356294_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356255_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356298_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356255_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356292_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356294_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356298_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356324_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356332_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356324_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356372_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356332_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356333_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356336_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356487_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356336_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356386_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356372_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356374_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356554_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356378_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356386_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356378_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356388_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356400_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356388_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356436_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356402_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356470_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356402_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356434_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356436_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356470_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356479_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356487_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356479_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356525_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356487_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356488_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356491_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356529_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356491_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356523_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356525_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356523_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356529_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356545_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356553_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356545_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356563_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356553_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356557_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356563_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356595_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356565_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356599_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356593_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356595_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356593_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356599_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356647_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356655_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356647_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356665_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356655_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356656_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356659_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356659_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356689_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357070_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356667_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356667_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356687_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356689_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356693_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356693_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356701_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356733_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356701_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356727_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356729_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356733_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356757_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356765_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356757_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356775_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356765_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356766_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356766_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356914_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356769_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356846_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356769_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356775_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356847_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356777_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356790_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356777_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356788_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356790_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356794_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356822_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356816_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356818_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356838_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356846_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356838_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356878_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356846_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356847_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356850_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356882_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356876_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356878_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356882_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356904_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356914_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356927_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356914_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356915_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356915_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356918_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356927_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356929_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356969_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356929_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356963_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356965_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356990_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356998_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356990_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357008_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356998_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356999_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1356999_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357069_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357002_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357008_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357002_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357041_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357010_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357045_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357010_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357039_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357041_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357039_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357045_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357061_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357069_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357061_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357079_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357069_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357070_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357073_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357079_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357073_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357081_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357119_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357081_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357113_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357115_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357113_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357119_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357235_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357234_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357374_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357235_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1374600_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357373_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1358348_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357373_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357373_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357377_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357377_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357439_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357427_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357427_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357460_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357439_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357554_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357441_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357462_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357441_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357474_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357460_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357462_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357474_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357516_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357520_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357514_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357516_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357514_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357541_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357553_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357568_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357553_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357557_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357649_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357580_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357568_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357570_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357570_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357716_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357574_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357580_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357574_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357582_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357623_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357582_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357617_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357619_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357639_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357649_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357639_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357683_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357649_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357650_1 | SOURCEANDSINK | vanduo šaltas - V1 2
