Properties of the parts of a building model (IFC2X3), part 23 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1403515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403533_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403525_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403525_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403582_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403535_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403586_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403580_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403582_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403580_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403586_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403606_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403626_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403626_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403627_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403650_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403642_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404037_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403644_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403652_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403709_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403650_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403652_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403656_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403811_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403656_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403725_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403707_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403709_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403707_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403713_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403812_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403717_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403725_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403771_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403727_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403775_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403769_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403771_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403769_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403775_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403803_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403811_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403803_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403848_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403811_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403812_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403815_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403852_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403815_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403846_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403848_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403846_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403852_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403868_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403876_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403914_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403876_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403877_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403877_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403903_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403918_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403903_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403912_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403914_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403912_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403967_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403967_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403968_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403968_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404036_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403971_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404010_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1403971_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404004_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404006_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404004_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404010_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404026_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404036_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404026_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404083_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404036_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404037_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404040_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404087_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404040_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404081_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404083_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404081_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404087_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404150_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404166_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404150_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404184_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404166_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404172_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404260_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404172_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404192_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404184_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404332_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404186_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404194_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404186_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404232_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404192_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404194_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404198_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404236_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404232_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404236_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404252_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404260_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404252_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404260_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404261_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404261_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404264_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404296_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404290_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404292_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404290_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404296_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404323_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404331_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404323_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404375_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404331_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404332_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404335_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404379_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404373_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404375_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404373_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404379_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404446_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404473_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404446_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404726_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404473_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404474_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404477_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405397_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404477_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404724_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404726_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404724_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404730_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406886_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404734_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404975_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404734_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404780_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404770_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405316_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404774_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404782_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404774_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404827_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404780_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404782_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404786_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404831_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404825_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404827_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404825_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404831_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404967_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404975_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405013_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404975_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404976_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404976_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405017_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1404979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405011_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405013_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405011_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405017_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405305_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405315_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405305_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405315_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405319_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405361_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405319_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405355_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405357_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405377_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405485_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405377_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405409_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405397_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405398_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405397_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405486_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405398_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405550_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405401_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405409_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405457_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405411_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405461_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405457_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405461_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405477_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405485_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405477_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405485_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405489_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405524_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405518_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405520_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405524_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405542_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405550_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405542_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405550_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405551_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405664_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405554_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405600_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405594_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405596_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405654_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405664_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405740_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405664_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405665_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405783_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405668_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405744_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405668_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405738_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405740_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405744_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405773_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405783_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405773_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405783_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405784_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405784_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405826_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405820_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405822_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405820_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405826_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405842_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405868_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405842_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405976_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405868_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405869_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406085_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405872_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405976_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405872_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405895_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405882_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405897_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405882_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405950_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405895_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405901_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405954_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405948_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405950_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405948_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405954_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405976_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405995_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1405995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406007_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406057_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406007_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406050_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406052_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406057_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406073_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406085_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406073_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406097_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406085_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406086_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406086_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406169_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406089_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406097_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406089_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406105_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406099_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406105_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406099_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406139_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406107_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406143_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406107_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406137_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406139_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406137_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406143_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406159_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406169_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406159_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406212_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406169_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406170_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406170_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406204_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406212_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406204_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406220_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406214_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406214_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406266_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406222_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406270_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406264_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406266_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406270_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406288_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406302_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406288_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406302_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406303_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406303_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406885_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406306_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406710_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406306_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406324_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406316_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406784_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406324_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406618_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406326_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406452_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406326_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406380_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406360_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406382_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406380_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406386_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406428_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406386_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406422_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406424_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406444_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406452_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406452_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406453_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406453_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406456_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406513_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406456_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406507_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406509_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406535_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406543_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406543_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406544_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406544_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406547_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406593_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406547_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406587_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406589_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406593_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406609_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406617_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406609_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406633_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406617_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406618_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406621_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406633_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406621_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406680_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406635_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406684_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406678_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406680_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406684_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406700_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406710_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406700_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406710_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406711_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406711_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406783_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406714_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406755_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406714_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406749_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406751_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406755_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406771_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406783_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406771_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406827_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406783_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406784_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406787_0 | SOURCEANDSINK | vanduo šaltas - V1 5
Port_1406787_1 | SOURCEANDSINK | vanduo šaltas - V1 5
Port_1406825_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406827_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406825_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406871_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406960_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406897_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406885_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406886_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406885_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407248_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406889_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406889_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406932_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406899_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406936_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406899_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406930_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406932_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406930_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406936_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406952_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406960_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406952_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407007_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406960_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406961_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407035_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406964_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407011_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1406964_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407005_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407007_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407005_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407011_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407027_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407035_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407027_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407087_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407035_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407036_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407036_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407153_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407039_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407091_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407039_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407085_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407087_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407085_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407145_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407153_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407145_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407153_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407154_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407154_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407157_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407163_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407157_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407217_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407221_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407215_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407217_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407215_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407221_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407237_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407247_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407257_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407247_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407248_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407251_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407257_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407288_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407259_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407292_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407259_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407286_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407288_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407286_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407326_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407334_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407326_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407346_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407334_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407335_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407340_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407442_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407340_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407358_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407346_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407443_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407348_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407358_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407348_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407366_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407360_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407366_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407410_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407368_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407414_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407408_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407410_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407408_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407414_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407434_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407442_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407452_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407442_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407443_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407446_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407452_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407446_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407512_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407454_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407516_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407510_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407512_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407510_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407516_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407543_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407698_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407563_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408207_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407563_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408590_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407569_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407594_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407569_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407604_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407592_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407598_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407604_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407598_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407640_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407606_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407638_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407640_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407638_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407690_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407698_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407690_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407733_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407698_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407699_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407761_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407702_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407737_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407702_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407731_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407733_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407731_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407737_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407753_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407761_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407753_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407796_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407761_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407762_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407762_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407824_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407765_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407800_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407794_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407796_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407800_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407816_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407824_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408104_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407824_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407825_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407825_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408134_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408093_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408108_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408093_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408102_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408104_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408102_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408108_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408126_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408134_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408170_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408134_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408135_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408135_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408138_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408174_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408138_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408168_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408170_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408168_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408190_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408190_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408262_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408207_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408247_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408248_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408247_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408368_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408248_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408254_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408264_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408274_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408274_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408316_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408276_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408320_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408276_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408314_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408316_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408314_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408320_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408359_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408359_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408380_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408367_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408367_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408531_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408371_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408382_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408400_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408380_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408386_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408386_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408402_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408439_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408402_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408433_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408435_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408433_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408439_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408465_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408498_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408465_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408530_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408469_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408502_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408469_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408496_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408498_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408502_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408520_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408530_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408530_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408534_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408565_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408534_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408559_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408561_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408559_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408581_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408589_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408581_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408599_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408589_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408590_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408593_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408599_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408593_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408601_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408648_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408642_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1408648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409054_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409068_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409181_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409068_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409069_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409069_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410081_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409074_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409272_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409074_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409197_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409179_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409181_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409185_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409273_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409189_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409197_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409189_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409229_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409199_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409233_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409199_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409227_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409229_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409227_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409264_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409272_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409264_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409308_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409272_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409273_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409276_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409312_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409276_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409306_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409308_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409306_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1409312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410069_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410081_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410069_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410319_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410081_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410082_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410097_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410325_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410097_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410317_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410319_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410325_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410399_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410401_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410399_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410523_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410523_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424034_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410627_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424033_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410627_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410643_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410637_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410643_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410637_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410653_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420429_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1410661_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423533_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411050_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411058_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411138_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423169_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411136_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411138_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411136_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411390_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411400_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411390_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411526_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411440_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411526_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411440_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411528_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411521_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411528_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411528_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411529_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411529_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425319_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1411610_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1411647_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1411610_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1411619_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1411647_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1411742_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411743_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411742_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414576_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411743_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411780_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412035_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411794_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411788_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411788_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411859_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411851_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411853_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411851_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411859_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412035_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412036_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412845_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412206_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412248_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412260_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412453_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412461_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412453_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412540_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412461_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412462_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412540_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412548_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412548_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412668_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412662_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413709_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412662_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414017_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412668_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413625_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412676_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414017_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413241_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412837_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412845_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412837_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412877_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412846_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412846_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418845_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412877_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
OutPort_1412918_1 | SOURCE
Port_1412962_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
OutPort_1412984_1 | SOURCE
Port_1413002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413016_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415853_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
OutPort_1413030_1 | SOURCE
OutPort_1413048_1 | SOURCE
Port_1413068_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416794_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
OutPort_1413082_1 | SOURCE
Port_1413094_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417454_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1413106_1 | SOURCE
OutPort_1413120_1 | SOURCE
Port_1413136_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417891_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
OutPort_1413150_1 | SOURCE
OutPort_1413166_1 | SOURCE
Port_1413214_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413247_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413239_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413241_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413239_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413247_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413367_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414719_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413367_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413423_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413411_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414719_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413423_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413423_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418846_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413424_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414575_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413624_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413625_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413624_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414271_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413634_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413733_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413707_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413709_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413707_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413709_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413710_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1413710_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414017_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414059_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414030_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414059_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414069_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414168_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414069_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414160_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414162_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414160_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414168_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414250_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414439_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414250_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414271_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414270_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414440_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414308_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414364_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414354_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414356_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414354_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414364_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414403_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414439_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414522_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414530_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414520_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414522_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414520_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414530_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414563_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414875_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414563_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414591_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414576_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414575_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414876_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
