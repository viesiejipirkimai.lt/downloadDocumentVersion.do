Properties of the parts of a building model (IFC2X3), part 47 of 57

# IfcFlowFitting: Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):1 - M5 (443)
Name (Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):1 - M5:...) | In
1347056 | 4 a V1
1347516 | 4 a V1
1349394 | 4 a V1
1349424 | 4 a V1
1349560 | 4 a V1
1349672 | 4 a V1
1350626 | 4 a V1
1351116 | 4 a V1
1351666 | 4 a V1
1351709 | 4 a V1
1351790 | 4 a V1
1351835 | 4 a V1
1352306 | 4 a V1
1352308 | 4 a V1
1352667 | 4 a V1
1352691 | 4 a V1
1352826 | 2 a
1353819 | 4 a V1
1354881 | 4 a V1
1354972 | 4 a V1
1355000 | 4 a V1
1356376 | 4 a V1
1356691 | 4 a V1
1356792 | 4 a V1
1357238 | 1 a +-152.84
1357464 | 3 a
1357572 | 3 a
1357867 | 3 a
1358783 | 2 a
1358869 | 3 a
1359395 | 3 a
1359669 | 3 a
1360321 | 2 a
1360338 | 2 a
1361468 | 2 a
1361568 | 2 a
1361628 | 3 a
1361977 | 3 a
1362089 | 2 a
1362128 | 3 a
1362235 | 3 a
1362603 | 3 a
1362774 | 3 a
1363077 | 3 a
1363360 | 3 a
1363606 | 3 a
1363650 | 3 a
1364198 | 3 a
1364404 | 2 a
1364517 | 3 a
1364902 | 3 a
1365686 | 3 a
1366312 | 2 a
1366352 | 2 a
1366445 | 3 a
1366860 | 2 a
1366966 | 3 a
1367302 | 3 a
1367557 | 3 a
1368033 | 2 a
1368395 | 3 a
1369047 | 2 a
1369155 | 2 a
1369258 | 2 a
1369829 | 2 a
1370624 | 2 a
1370826 | 2 a
1370840 | 2 a
1371151 | 2 a
1371153 | 2 a
1371284 | 2 a
1371286 | 2 a
1372236 | 2 a
1372547 | 2 a
1372600 | 2 a
1372881 | 2 a
1373250 | 2 a
1373727 | 2 a
1375326 | 2 a
1375328 | 2 a
1375434 | 2 a
1377272 | 2 a
1377515 | 2 a
1377749 | 2 a
1378942 | 2 a
1379600 | 2 a
1380290 | 2 a
1380646 | 2 a
1381089 | 2 a
1381890 | 2 a
1382016 | 2 a
1382366 | 2 a
1383659 | 2 a
1383947 | 2 a
1385275 | 2 a
1385399 | 2 a
1385612 | 2 a
1386484 | 2 a
1387039 | 2 a
1387313 | 2 a
1387963 | 2 a
1388018 | 2 a
1388852 | 2 a
1389444 | 2 a
1389461 | 2 a
1390264 | 2 a
1390720 | 2 a
1390791 | 2 a
1390793 | 2 a
1391005 | 2 a
1391095 | 2 a
1392242 | 2 a
1392324 | 2 a
1392658 | 2 a
1392763 | 2 a
1392847 | 2 a
1393365 | 2 a
1394054 | 2 a
1394108 | 2 a
1395066 | 2 a
1395085 | 2 a
1395107 | 2 a
1395711 | 1 a +-152.84
1395774 | 2 a
1396202 | 2 a
1396384 | 2 a
1396678 | 1 a +-152.84
1396778 | 2 a
1397281 | 2 a
1397439 | 2 a
1397459 | 2 a
1398313 | 2 a
1398661 | 1 a +-152.84
1399234 | 1 a +-152.84
1400459 | 1 a +-152.84
1400494 | 1 a +-152.84
1400917 | 1 a +-152.84
1400950 | 1 a +-152.84
1401738 | 1 a +-152.84
1402059 | 1 a +-152.84
1402474 | 1 a +-152.84
1402636 | 1 a +-152.84
1402914 | 1 a +-152.84
1403180 | 1 a +-152.84
1403219 | 1 a +-152.84
1403630 | 1 a +-152.84
1403654 | 1 a +-152.84
1404170 | 1 a +-152.84
1404196 | 1 a +-152.84
1404772 | 1 a +-152.84
1404784 | 1 a +-152.84
1405899 | 1 a +-152.84
1406384 | 1 a +-152.84
1407338 | 1 a +-152.84
1407567 | 1 a +-152.84
1407596 | 1 a +-152.84
1408251 | 1 a +-152.84
1408266 | 1 a +-152.84
1408384 | 1 a +-152.84
1409072 | 1 a +-152.84
1420432 | 0 a
1420434 | 0 a
1420826 | 0 a
1420828 | 0 a
1420943 | 0 a
1420945 | 0 a
1421054 | 0 a
1421056 | 0 a
1421150 | 0 a
1421152 | 0 a
1421271 | 0 a
1421273 | 0 a
1421364 | 0 a
1421366 | 0 a
1421499 | 0 a
1421501 | 0 a
1421935 | 0 a
1421937 | 0 a
1422052 | 0 a
1422054 | 0 a
1422175 | 0 a
1422177 | 0 a
1422285 | 0 a
1422287 | 0 a
1422397 | 0 a
1422399 | 0 a
1422739 | 0 a
1422741 | 0 a
1423009 | 0 a
1423011 | 0 a
1423199 | 0 a
1423201 | 0 a
1423360 | 0 a
1423362 | 0 a
1423536 | 0 a
1423538 | 0 a
1423781 | 0 a
1424124 | 0 a
1424163 | 0 a
1424205 | 0 a
1424305 | 0 a
1424361 | 0 a
1424413 | 0 a
1427079 | 0 a
1427114 | 1 a +-152.84
1428506 | 0 a
1428508 | 0 a
1428643 | 0 a
1428645 | 0 a
1428703 | 0 a
1428705 | 0 a
1428811 | 0 a
1428813 | 0 a
1428959 | 0 a
1428961 | 0 a
1429256 | 0 a
1429258 | 0 a
1429483 | 0 a
1429485 | 0 a
1429657 | 0 a
1429741 | 0 a
1429743 | 0 a
1429853 | 0 a
1429855 | 0 a
1429984 | 0 a
1429986 | 0 a
1430117 | 0 a
1430119 | 0 a
1430694 | 0 a
1430696 | 0 a
1431195 | 0 a
1431197 | 0 a
1431386 | 0 a
1431388 | 0 a
1431657 | 0 a
1431659 | 0 a
1433229 | 1 a +-152.84
1433710 | 1 a +-152.84
1434229 | 1 a +-152.84
1434430 | 1 a +-152.84
1435143 | 1 a +-152.84
1435712 | 1 a +-152.84
1435776 | 1 a +-152.84
1436604 | 1 a +-152.84
1436628 | 1 a +-152.84
1437017 | 1 a +-152.84
1437074 | 1 a +-152.84
1437533 | 1 a +-152.84
1438014 | 1 a +-152.84
1438859 | 1 a +-152.84
1438861 | 1 a +-152.84
1438959 | 1 a +-152.84
1439169 | 1 a +-152.84
1439171 | 1 a +-152.84
1439291 | 1 a +-152.84
1439527 | 1 a +-152.84
1439734 | 1 a +-152.84
1440130 | 1 a +-152.84
1440592 | 2 a
1440701 | 2 a
1440852 | 2 a
1441049 | 2 a
1441107 | 2 a
1441340 | 2 a
1441491 | 2 a
1441790 | 2 a
1441809 | 2 a
1442208 | 1 a +-152.84
1442282 | 2 a
1442502 | 2 a
1443537 | 2 a
1443861 | 1 a +-152.84
1443915 | 1 a +-152.84
1444001 | 2 a
1444099 | 2 a
1444800 | 2 a
1445636 | 2 a
1445676 | 2 a
1446062 | 2 a
1446367 | 2 a
1446627 | 2 a
1447123 | 2 a
1447282 | 2 a
1447363 | 2 a
1447614 | 2 a
1448234 | 2 a
1448281 | 2 a
1448283 | 2 a
1448955 | 2 a
1449438 | 2 a
1450306 | 2 a
1451293 | 1 a +-152.84
1452161 | 2 a
1452186 | 2 a
1452773 | 2 a
1452937 | 2 a
1453404 | 2 a
1453567 | 2 a
1454871 | 2 a
1454885 | 2 a
1457132 | 2 a
1457217 | 2 a
1457710 | 2 a
1459677 | 2 a
1459812 | 2 a
1460063 | 2 a
1460360 | 2 a
1460549 | 2 a
1460739 | 2 a
1460815 | 2 a
1460928 | 2 a
1461052 | 2 a
1461162 | 2 a
1461224 | 2 a
1461338 | 2 a
1461647 | 2 a
1461838 | 1 a +-152.84
1461900 | 2 a
1462309 | 2 a
1462361 | 2 a
1462710 | 2 a
1463035 | 2 a
1463132 | 2 a
1463296 | 2 a
1463407 | 2 a
1463409 | 2 a
1463536 | 2 a
1463943 | 3 a
1464635 | 1 a +-152.84
1464890 | 3 a
1465189 | 3 a
1465487 | 2 a
1465612 | 2 a
1465669 | 3 a
1467007 | 1 a +-152.84
1467409 | 3 a
1467579 | 3 a
1467880 | 3 a
1468212 | 1 a +-152.84
1468808 | 3 a
1469132 | 3 a
1469240 | 3 a
1469927 | 1 a +-152.84
1469997 | 3 a
1470025 | 3 a
1471364 | 3 a
1471408 | 3 a
1471661 | 3 a
1472446 | 1 a +-152.84
1472448 | 1 a +-152.84
1472707 | 2 a
1473195 | 3 a
1473246 | 3 a
1473625 | 3 a
1474224 | 1 a +-152.84
1474768 | 3 a
1474800 | 3 a
1475380 | 3 a
1475937 | 3 a
1476566 | 1 a +-152.84
1476568 | 1 a +-152.84
1477025 | 4 a V1
1477071 | 4 a V1
1477677 | 4 a V1
1478026 | 4 a V1
1478187 | 4 a V1
1478328 | 4 a V1
1479181 | 2 a
1479183 | 2 a
1479627 | 4 a V1
1479661 | 4 a V1
1480146 | 4 a V1
1481185 | 3 a
1481187 | 3 a
1481388 | 3 a
1481440 | 4 a V1
1482156 | 4 a V1
1482316 | 4 a V1
1483401 | 1 a +-152.84
1483471 | 1 a +-152.84
1483493 | 4 a V1
1483822 | 4 a V1
1484165 | 4 a V1
1484526 | 4 a V1
1485335 | 1 a +-152.84
1485395 | 1 a +-152.84
1485472 | 4 a V1
1486055 | 4 a V1
1486829 | 1 a +-152.84
1487009 | 4 a V1
1487307 | 4 a V1
1487812 | 4 a V1
1487978 | 4 a V1
1489212 | 3 a
1489266 | 4 a V1
1490591 | 2 a
1490804 | 4 a V1
1491477 | 4 a V1
1491604 | 4 a V1
1492242 | 1 a +-152.84
1492256 | 4 a V1
1492543 | 4 a V1
1492701 | 4 a V1
1492767 | 4 a V1
1492915 | 4 a V1
1493093 | 4 a V1
1493499 | 1 a +-152.84
1493533 | 5 a V1
1494157 | 5 a V1
1494292 | 1 a +-152.84
1494294 | 1 a +-152.84
1494455 | 1 a +-152.84
1494519 | 5 a V1

# IfcFlowFitting: Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):3 - M1 (33)
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: Steel WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 3 - M1; sets with these values: 2
Name (Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):3 - M1:...) | In
1330608 | 3 a
1333412 | 2 a
1336244 | 2 a
1336386 | 2 a
1339716 | 2 a
1341747 | 2 a
1344102 | 2 a
1350607 | 4 a V1
1351342 | 4 a V1
1352540 | 2 a
1354770 | 1 a +-152.84
1354836 | 1 a +-152.84
1383424 | 1 a +-152.84
1383430 | 2 a
1426801 | 0 a
1426803 | 0 a
1427112 | 1 a +-152.84
1432927 | 1 a +-152.84
1433008 | 1 a +-152.84
1433227 | 1 a +-152.84
1433702 | 1 a +-152.84
1433708 | 1 a +-152.84
1450230 | 2 a
1451236 | 1 a +-152.84
1451375 | 1 a +-152.84
1465431 | 1 a +-152.84
1471296 | 1 a +-152.84
1476254 | 1 a +-152.84
1479230 | 2 a
1481386 | 3 a
1492240 | 1 a +-152.84
1493497 | 1 a +-152.84
1494374 | 1 a +-152.84

# IfcFlowSegment: Pipe Types:Mapress St-Steel (DN) (467)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Category: Pipes
Pset_DistributionFlowElementCommon - Reference: Mapress St-Steel (DN); sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00159 mm
Name (Pipe Types:Mapress St-Steel (DN):...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1829583 | 0 a | 9900 | -4979.13 | F1 2
1829634 | 0 a | 2300 | -1036.05 | F1 3
1830306 | 0 a | 1398 | -2749 | V2 7
1830439 | 0 a | 1278 | -2952 | V2 7
1830449 | 0 a | 2263.12 | -2952 | V2 7
1830473 | 0 a | 49 | -1052 | V2 1
1830525 | 0 a | 5207 | -2749 | V2 7
1830533 | 0 a | 98 | 2557 | V2 7
1830543 | 0 a | 998 | 2760 | V2 7
1830586 | 1 a +-152.84 | 15166.2 | 3857 | V2 7
1830614 | 1 a +-152.84 | 3655.53 | 3857 | V2 7
1830647 | 1 a +-152.84 | 4818 | -1060 | V2 7
1830741 | 0 a | 39198 | -1263 | V2 7
1830749 | 0 a | 4634.71 | -1263 | V2 7
1830864 | 0 a | 1387 | -2749 | V2 7
1830875 | 0 a | 71 | -2952 | V2 7
1830895 | 0 a | 71 | -2952 | V2 7
1830904 | 0 a | 4705.71 | -2952 | V2 7
1830908 | 0 a | 1460 | -2749 | V2 7
1830911 | 0 a | 763.293 | -1263 | V2 7
1830921 | 0 a | 203.293 | -2952 | V2 7
1830931 | 0 a | 3128 | -2536.05 | V2 3
1830955 | 0 a | 414.877 | -2952 | V2 7
1830965 | 0 a | 1016 | -2536.05 | V2 3
1831328 | 0 a | 184.5 | -2952 | V2 7
1831485 | 0 a | 148 | -2942.45 | V2 5
1831511 | 0 a | 184.5 | -2952 | V2 7
1831521 | 0 a | 172 | -2942.45 | V2 5
1831532 | 0 a | 452 | -2942.45 | V2 5
1831585 | 0 a | 1572 | -2776 | V2 5
1831646 | 0 a | 10983.5 | -1122.45 | V2 5
1831654 | 0 a | 796 | -2536.05 | V2 4
1831718 | 0 a | 1212 | -2396 | V2 4
1831764 | 0 a | 682 | -1116.05 | V2 6
1831778 | 0 a | 3204.46 | -1122.45 | V2 5
1831865 | 0 a | 410 | -2536.05 | V2 5
1831880 | 0 a | 1198 | -2346 | V2 5
1831883 | 0 a | 18786.6 | -1122.45 | V2 5
1832021 | 0 a | 6579.5 | -1116.05 | V2 5
1832035 | 0 a | 3792 | -1116.05 | V2 5
1832043 | 0 a | 2652 | -1116.05 | V2 5
1832053 | 0 a | 756 | -2536.05 | V2 5
1832101 | 0 a | 1212 | -2396 | V2 5
1832776 | 1 a +-152.84 | 351 | 3857 | V2 7
1832785 | 1 a +-152.84 | 262.622 | 3857 | V2 7
1832788 | 1 a +-152.84 | 238 | 3857 | V2 7
1832798 | 1 a +-152.84 | 17.6245 | 3857 | V2 7
1832806 | 1 a +-152.84 | 538 | 3857 | V2 7
1832816 | 1 a +-152.84 | 238 | 3857 | V2 7
1832869 | 1 a +-152.84 | 195.459 | 17131.3 | V2 7
1833002 | 1 a +-152.84 | 7807.08 | 3866.55 | V2 2
1833086 | 1 a +-152.84 | 68.5532 | 3866.55 | V2 2
1833176 | 1 a +-152.84 | 4212 | -427 | V2 2
1833318 | 0 a | 4166.54 | -593.45 | V2 2
1833326 | 0 a | 52 | -593.45 | V2 2
1833334 | 0 a | 332 | -593.45 | V2 2
1833350 | 0 a | 132 | -593.45 | V2 2
1833358 | 0 a | 8219.9 | -593.45 | V2 2
1833370 | 0 a | 6426.94 | -593.45 | V2 2
1833378 | 0 a | 337 | -593.45 | V2 2
1833485 | 1 a +-152.84 | 2302.75 | 3857 | V2 7
1833586 | 0 a | 117.291 | -593.45 | V2 2
1833596 | 0 a | 58 | -587.05 | V2 8
1833623 | 0 a | 343.467 | -587.05 | V2 8
1833633 | 0 a | 2653.1 | -587.05 | V2 8
1833641 | 0 a | 177.07 | -2536.05 | V2 8
1833679 | 0 a | 1741 | -2396 | V2 8
1833733 | 0 a | 112 | -587.05 | V2 8
1833747 | 0 a | 230.901 | -587.05 | V2 8
1833750 | 0 a | 432 | -587.05 | V2 8
1833758 | 0 a | 112 | -587.05 | V2 8
1833842 | 0 a | 158 | -587.05 | V2 9
1833851 | 0 a | 802.429 | -593.45 | V2 2
1833861 | 0 a | 712 | -587.05 | V2 9
1833871 | 0 a | 216 | -2536.05 | V2 9
1833909 | 0 a | 1741 | -2396 | V2 9
1833959 | 0 a | 6158 | -587.05 | V2 10
1833972 | 0 a | 12436.5 | -593.45 | V2 2
1833982 | 0 a | 387.679 | -2536.05 | V2 10
1834048 | 0 a | 1741 | -2396 | V2 10
1834197 | 0 a | 10873.2 | -593.45 | V2 2
1834207 | 0 a | 345.147 | -587.05 | V2 11
1834267 | 0 a | 20.211 | -2536.05 | V2 11
1834311 | 0 a | 1741 | -2396 | V2 11
1834352 | 0 a | 7278 | -587.05 | V2 2
1834361 | 0 a | 3025.06 | -593.45 | V2 2
1834371 | 0 a | 290.328 | -587.05 | V2 2
1834379 | 0 a | 36 | -2536.05 | V2 2
1834446 | 0 a | 1741 | -2396 | V2 2
1834594 | 1 a +-152.84 | 837.351 | 3857 | V2 7
1834616 | 1 a +-152.84 | 1113.27 | 3857 | V2 7
1834802 | 0 a | 4201.02 | -427 | V2 2
1834820 | 0 a | 349.159 | 3855.57 | V2 2
1835130 | 1 a +-152.84 | 4412.01 | 3872.95 | V2 12
1835149 | 1 a +-152.84 | 224.654 | 3857 | V2 7
1835162 | 1 a +-152.84 | 32 | 3872.95 | V2 12
1835198 | 1 a +-152.84 | 22.2498 | 1313.95 | V2 12
1835211 | 1 a +-152.84 | 2351 | 1454 | V2 12
1835491 | 1 a +-152.84 | 99 | 3872.95 | V2 12
1835500 | 1 a +-152.84 | 3271.99 | 3872.95 | V2 12
1835506 | 1 a +-152.84 | 221 | 1313.95 | V2 12
1835578 | 1 a +-152.84 | 2351 | 1454 | V2 12
1835629 | 1 a +-152.84 | 8148 | 3872.95 | V2 13
1835640 | 1 a +-152.84 | 6486.74 | 3857 | V2 7
1835650 | 1 a +-152.84 | 6392 | 3872.95 | V2 13
1835718 | 1 a +-152.84 | 92 | 3872.95 | V2 13
1835751 | 1 a +-152.84 | 276 | 1313.95 | V2 13
1835766 | 1 a +-152.84 | 2351 | 1454 | V2 13
1835813 | 1 a +-152.84 | 3488 | 3872.95 | V2 7
1835822 | 1 a +-152.84 | 3904.66 | 3857 | V2 7
1835832 | 1 a +-152.84 | 16 | 1313.95 | V2 7
1835870 | 1 a +-152.84 | 2351 | 1454 | V2 7
1836100 | 1 a +-152.84 | 2268 | 3872.95 | V2 7
1836111 | 1 a +-152.84 | 581.775 | 3857 | V2 19
1836121 | 1 a +-152.84 | 5094.31 | 3872.95 | V2 7
1836129 | 1 a +-152.84 | 152 | 3872.95 | V2 7
1836139 | 1 a +-152.84 | 78.1398 | 1313.95 | V2 7
1836205 | 1 a +-152.84 | 2351 | 1454 | V2 7
1836227 | 1 a +-152.84 | 99 | 3872.95 | V2 7
1836236 | 1 a +-152.84 | 153.685 | 3872.95 | V2 7
1836239 | 1 a +-152.84 | 1632 | 3872.95 | V2 7
1836247 | 1 a +-152.84 | 4792 | 3872.95 | V2 7
1836257 | 1 a +-152.84 | 1252 | 3872.95 | V2 7
1836265 | 1 a +-152.84 | 2592 | 3872.95 | V2 7
1836275 | 1 a +-152.84 | 1852 | 3872.95 | V2 7
1836283 | 1 a +-152.84 | 16 | 1313.95 | V2 7
1836337 | 1 a +-152.84 | 2351 | 1454 | V2 7
1836428 | 1 a +-152.84 | 3468 | 3872.95 | V2 14
1836439 | 1 a +-152.84 | 5728.49 | 3857 | V2 7
1836449 | 1 a +-152.84 | 36 | 1313.95 | V2 14
1836499 | 1 a +-152.84 | 2351 | 1454 | V2 14
1836525 | 1 a +-152.84 | 248 | 3872.95 | V2 15
1836534 | 1 a +-152.84 | 5645.98 | 3857 | V2 7
1836544 | 1 a +-152.84 | 56 | 1313.95 | V2 15
1836607 | 1 a +-152.84 | 2351 | 1454 | V2 15
1836666 | 1 a +-152.84 | 248 | 3872.95 | V2 16
1836670 | 1 a +-152.84 | 56 | 1313.95 | V2 16
1836672 | 1 a +-152.84 | 2351 | 1454 | V2 16
1836736 | 1 a +-152.84 | 970 | 3872.95 | V2 7
1836747 | 1 a +-152.84 | 1220.38 | 3857 | V2 7
1836757 | 1 a +-152.84 | 419 | 3872.95 | V2 7
1836765 | 1 a +-152.84 | 16 | 1313.95 | V2 7
1836807 | 1 a +-152.84 | 2351 | 1454 | V2 7
1836959 | 1 a +-152.84 | 1778.98 | 3872.95 | V2 7
1836969 | 1 a +-152.84 | 137.14 | 3872.95 | V2 7
1836977 | 1 a +-152.84 | 132 | 3872.95 | V2 7
1836987 | 1 a +-152.84 | 16 | 1313.95 | V2 7
1837026 | 1 a +-152.84 | 2351 | 1454 | V2 7
1837074 | 1 a +-152.84 | 6859 | 3872.95 | V2 7
1837085 | 1 a +-152.84 | 236.251 | 3872.95 | V2 7
1837088 | 1 a +-152.84 | 2452 | 3872.95 | V2 7
1837096 | 1 a +-152.84 | 52 | 3872.95 | V2 7
1837216 | 1 a +-152.84 | 176 | 1313.95 | V2 7
1837229 | 1 a +-152.84 | 2351 | 1454 | V2 7
1837316 | 1 a +-152.84 | 7756.71 | 3872.95 | V2 18
1837327 | 1 a +-152.84 | 7461.07 | 3857 | V2 7
1837337 | 1 a +-152.84 | 36 | 1313.95 | V2 18
1837372 | 1 a +-152.84 | 2351 | 1454 | V2 18
1837504 | 1 a +-152.84 | 373.782 | 3857 | V2 7
1837514 | 2 a | 48 | 3872.95 | V2 21
1837525 | 2 a | 3196 | 3872.95 | V2 21
1837533 | 2 a | 172 | 3872.95 | V2 53
1837545 | 2 a | 190 | 5813.95 | V2 20
1837592 | 2 a | 1733 | 4013 | V2 53
1837739 | 1 a +-152.84 | 850.886 | 3857 | V2 7
1837749 | 2 a | 96 | 5813.95 | V2 22
1837780 | 2 a | 1733 | 4013 | V2 22
1837832 | 2 a | 96 | 5813.95 | V2 25
1837834 | 2 a | 1733 | 4013 | V2 25
1837875 | 2 a | 96 | 5813.95 | V2 28
1837877 | 2 a | 1733 | 4013 | V2 28
1837953 | 2 a | 279 | 3872.95 | V2 7
1837962 | 1 a +-152.84 | 11250.6 | 3872.95 | V2 7
1837965 | 2 a | 196 | 5813.95 | V2 7
1838037 | 2 a | 1733 | 4013 | V2 7
1838137 | 2 a | 419 | 3872.95 | V2 7
1838146 | 1 a +-152.84 | 213.019 | 3872.95 | V2 7
1838149 | 2 a | 12 | 3872.95 | V2 7
1838159 | 2 a | 136 | 5813.95 | V2 7
1838192 | 2 a | 1733 | 4013 | V2 7
1838237 | 2 a | 218 | 3872.95 | V2 29
1838246 | 1 a +-152.84 | 3160.92 | 3866.55 | V2 2
1838256 | 2 a | 96 | 5813.95 | V2 29
1838287 | 2 a | 1733 | 4013 | V2 29
1838342 | 2 a | 7251.7 | 3872.95 | V2 7
1838351 | 1 a +-152.84 | 9617.72 | 3857 | V2 7
1838361 | 2 a | 36 | 5813.95 | V2 7
1838398 | 2 a | 1733 | 4013 | V2 7
1838441 | 2 a | 2264.15 | 3872.95 | V2 30
1838450 | 1 a +-152.84 | 148.29 | 3857 | V2 7
1838460 | 2 a | 56 | 5813.95 | V2 30
1838495 | 2 a | 1733 | 4013 | V2 30
1838652 | 2 a | 2268 | 3872.95 | V2 7
1838665 | 1 a +-152.84 | 6771.17 | 3857 | V2 7
1838675 | 2 a | 216 | 5813.95 | V2 7
1838711 | 2 a | 1733 | 4013 | V2 7
1838756 | 2 a | 428.426 | 3872.95 | V2 31
1838765 | 1 a +-152.84 | 3132.75 | 3857 | V2 7
1838775 | 2 a | 116 | 5813.95 | V2 31
1838814 | 2 a | 1733 | 4013 | V2 31
1838900 | 2 a | 20515.5 | 3872.95 | V2 32
1838917 | 1 a +-152.84 | 4252.36 | 3857 | V2 7
1838927 | 2 a | 136 | 5813.95 | V2 32
1838960 | 2 a | 1733 | 4013 | V2 32
1839049 | 2 a | 118 | 3861.97 | V2 33
1839058 | 0 a | 706.841 | 3855.57 | V2 2
1839068 | 2 a | 10030.7 | 3861.97 | V2 33
1839081 | 2 a | 176 | 5813.95 | V2 33
1839107 | 2 a | 1743.98 | 4002.02 | V2 33
1839194 | 2 a | 1011 | 3857 | V2 7
1839203 | 1 a +-152.84 | 3892.22 | 3857 | V2 7
1839206 | 2 a | 98 | 3857 | V2 7
1839245 | 2 a | 241.51 | 17076.5 | V2 7
1839306 | 2 a | 1751 | 8209.17 | V2 7
1839351 | 2 a | 4121.17 | 4060 | V2 7
1839499 | 2 a | 178 | 8209.17 | V2 7
1839509 | 2 a | 3558 | 8209.17 | V2 7
1839517 | 2 a | 10575 | 8218.72 | V2 35
1839564 | 2 a | 2232 | 8218.72 | V2 35
1839576 | 2 a | 32.9273 | 8218.72 | V2 35
1839612 | 2 a | 21492 | 8225.12 | V2 36
1839673 | 2 a | 358 | 8225.12 | V2 37
1839682 | 2 a | 6229.07 | 8218.72 | V2 35
1839692 | 2 a | 12 | 8225.12 | V2 37
1839798 | 2 a | 132 | 8225.12 | V2 36
1839879 | 2 a | 96 | 5813.95 | V2 36
1839888 | 2 a | 2203.17 | 5954 | V2 36
1839944 | 2 a | 132 | 8225.12 | V2 38
1839948 | 2 a | 96 | 5813.95 | V2 38
1839950 | 2 a | 2203.17 | 5954 | V2 38
1839970 | 2 a | 132 | 8225.12 | V2 39
1839974 | 2 a | 96 | 5813.95 | V2 39
1839976 | 2 a | 2203.17 | 5954 | V2 39
1840002 | 2 a | 215.927 | 8225.12 | V2 37
1840006 | 2 a | 96 | 5813.95 | V2 37
1840008 | 2 a | 2203.17 | 5954 | V2 37
1840040 | 2 a | 178 | 8225.12 | V2 37
1840050 | 2 a | 3354 | 8225.12 | V2 37
1840088 | 2 a | 948 | 3872.95 | V2 40
1840097 | 1 a +-152.84 | 6933.84 | 3857 | V2 7
1840107 | 2 a | 136 | 5813.95 | V2 40
1840141 | 2 a | 1733 | 4013 | V2 40
1840190 | 2 a | 968 | 3872.95 | V2 41
1840199 | 1 a +-152.84 | 559.744 | 3857 | V2 7
1840209 | 2 a | 56 | 5813.95 | V2 41
1840245 | 2 a | 1733 | 4013 | V2 41
1840306 | 2 a | 3091 | 3857 | V2 7
1840315 | 1 a +-152.84 | 13219.2 | 3857 | V2 7
1840366 | 2 a | 3649 | 4060 | V2 7
1840418 | 2 a | 7913.41 | 7752.95 | V2 42
1840498 | 2 a | 5129 | 7869 | V2 7
1840553 | 2 a | 5392 | 7752.95 | V2 42
1840563 | 2 a | 172 | 7752.95 | V2 42
1840571 | 2 a | 96 | 5813.95 | V2 42
1840613 | 2 a | 1731 | 5954 | V2 42
1840668 | 2 a | 4739 | 7752.95 | V2 42
1840677 | 2 a | 558.592 | 7752.95 | V2 42
1840680 | 2 a | 5372 | 7752.95 | V2 42
1840688 | 2 a | 16 | 5813.95 | V2 42
1840718 | 2 a | 1731 | 5954 | V2 42
1840825 | 1 a +-152.84 | 3381.84 | 3857 | V2 7
1840916 | 2 a | 149 | 17178.3 | V2 23
1840941 | 2 a | 296 | 8225.48 | V2 43
1840950 | 2 a | 4121.53 | 4060 | V2 23
1841077 | 2 a | 2120.41 | 8225.48 | V2 43
1841087 | 2 a | 201.852 | 8225.48 | V2 43
1841097 | 2 a | 48.9261 | 5813.95 | V2 43
1841123 | 2 a | 2203.53 | 5954 | V2 43
1841196 | 2 a | 7399 | 8225.48 | V2 43
1841207 | 2 a | 13237.9 | 8225.48 | V2 43
1841210 | 2 a | 76 | 5813.95 | V2 43
1841238 | 2 a | 2203.53 | 5954 | V2 43
1841288 | 2 a | 3132 | 13080.6 | V2 44
1841303 | 2 a | 4701.51 | 8341.53 | V2 23
1841366 | 3 a | 1296 | 13087 | V2 45
1841387 | 3 a | 42.5113 | 13087 | V2 45
1841395 | 3 a | 4332 | 13087 | V2 45
1841446 | 3 a | 112 | 13087 | V2 45
1841458 | 3 a | 116 | 10613.9 | V2 45
1841506 | 3 a | 2265.04 | 10754 | V2 45
1841619 | 3 a | 2081.03 | 13087 | V2 44
1841744 | 3 a | 7654 | 13087 | V2 44
1841756 | 3 a | 11.3945 | 13087 | V2 44
1841844 | 3 a | 2265.04 | 10754 | V2 44
1841894 | 3 a | 336 | 13087 | V2 44
1841904 | 3 a | 12 | 13087 | V2 44
1841952 | 3 a | 2265.04 | 10754 | V2 44
1841980 | 3 a | 3390.36 | 13087 | V2 44
1841989 | 3 a | 3887.97 | 13087 | V2 44
1841992 | 3 a | 236 | 10613.9 | V2 44
1842031 | 3 a | 2265.04 | 10754 | V2 44
1842190 | 1 a +-152.84 | 867.608 | 13006.2 | V2 47
1842234 | 1 a +-152.84 | 8902.25 | 4060 | V2 7
1842269 | 3 a | 32 | 13006.2 | V2 47
1842279 | 3 a | 13012 | 13006.2 | V2 47
1842294 | 3 a | 27 | 13006.2 | V2 47
1842523 | 3 a | 2184.25 | 10754 | V2 47
1842560 | 3 a | 2681 | 13006.2 | V2 47
1842569 | 1 a +-152.84 | 116.392 | 13006.2 | V2 47
1842572 | 3 a | 3339 | 13006.2 | V2 47
1842580 | 3 a | 42 | 13006.2 | V2 47
1842647 | 3 a | 2184.25 | 10754 | V2 47
1842687 | 3 a | 656 | 13006.2 | V2 47
1842697 | 3 a | 5152 | 13006.2 | V2 47
1842705 | 3 a | 5492 | 13006.2 | V2 47
1842715 | 3 a | 692 | 13006.2 | V2 47
1842723 | 3 a | 72 | 13006.2 | V2 47
1842945 | 3 a | 96 | 10614 | V2 47
1842954 | 3 a | 2184.25 | 10754 | V2 47
1843113 | 2 a | 8 | 13097 | V2 7
1843330 | 3 a | 277 | 13097 | V2 7
1843346 | 3 a | 79 | 13097 | V2 7
1843412 | 3 a | 329.171 | 16988.8 | V2 7
1844320 | 3 a | 162.959 | 13112.9 | V2 46
1844328 | 3 a | 9192 | 13112.9 | V2 46
1844338 | 3 a | 7 | 13112.9 | V2 46
1844583 | 3 a | 56 | 10613.9 | V2 46
1844596 | 3 a | 2291 | 10754 | V2 46
1844619 | 3 a | 39 | 13112.9 | V2 46
1844628 | 3 a | 119.324 | 13112.9 | V2 46
1844631 | 3 a | 1100.63 | 13112.9 | V2 46
1844649 | 3 a | 2880.41 | 13112.9 | V2 46
1844671 | 3 a | 56 | 10613.9 | V2 46
1844711 | 3 a | 2291 | 10754 | V2 46
1844742 | 3 a | 2802.81 | 13112.9 | V2 46
1844745 | 3 a | 139 | 13112.9 | V2 46
1844756 | 3 a | 492 | 13112.9 | V2 46
1844764 | 3 a | 132 | 13112.9 | V2 46
1844774 | 3 a | 3692 | 13112.9 | V2 46
1844784 | 3 a | 1372 | 13112.9 | V2 46
1844794 | 3 a | 972 | 13112.9 | V2 46
1844802 | 3 a | 2272 | 13112.9 | V2 46
1844812 | 3 a | 13.0113 | 13112.9 | V2 46
1844854 | 3 a | 2291 | 10754 | V2 46
1845092 | 2 a | 3969.92 | 8341.17 | V2 7
1845148 | 3 a | 2652 | 12355 | V2 34
1845157 | 3 a | 152 | 12355 | V2 34
1845200 | 3 a | 1533.09 | 10754 | V2 34
1845255 | 3 a | 12875.2 | 12355 | V2 34
1845278 | 3 a | 73.3809 | 12355 | V2 34
1845287 | 3 a | 12356.6 | 12355 | V2 34
1845290 | 3 a | 56 | 10613.9 | V2 34
1845348 | 3 a | 1533.09 | 10754 | V2 34
1845466 | 2 a | 2335 | 17062.2 | V2 23
1845475 | 2 a | 3815.23 | 13203 | V2 23
1845568 | 4 a V1 | 3976 | 17062.2 | V2 23
1845578 | 4 a V1 | 7147.8 | 17062.2 | V2 23
1845586 | 4 a V1 | 1027.7 | 17062.2 | V2 23
1845596 | 4 a V1 | 156 | 15114 | V2 23
1845631 | 4 a V1 | 1740.27 | 15254 | V2 23
1845683 | 4 a V1 | 2096.35 | 17062.2 | V2 23
1845693 | 4 a V1 | 508.813 | 17062.2 | V2 23
1845713 | 4 a V1 | 87 | 17062.2 | V2 23
1845721 | 4 a V1 | 77.2855 | 15114 | V2 23
1845756 | 4 a V1 | 1740.27 | 15254 | V2 23
1845792 | 4 a V1 | 8896 | 17062.2 | V2 23
1845802 | 4 a V1 | 37.3724 | 17062.2 | V2 23
1845812 | 4 a V1 | 256 | 15114 | V2 23
1845841 | 4 a V1 | 1740.27 | 15254 | V2 23
1845937 | 2 a | 9 | 17426.3 | V2 48
1845960 | 4 a V1 | 118 | 17426.3 | V2 48
1845970 | 4 a V1 | 23027 | 17426.3 | V2 48
1846392 | 1 a +-152.84 | 233 | 17425.7 | V2 7
1846562 | 4 a V1 | 2749 | 17426.3 | V2 48
1846678 | 4 a V1 | 109 | 17425.7 | V2 7
1846731 | 1 a +-152.84 | 146.447 | 17015.2 | V2 49
1846750 | 1 a +-152.84 | 3849.04 | 13122.3 | V2 7
1846794 | 4 a V1 | 2296.9 | 17015.2 | V2 49
1846804 | 4 a V1 | 8859.15 | 17015.2 | V2 49
1846812 | 4 a V1 | 5732 | 17015.2 | V2 49
1846824 | 4 a V1 | 6472 | 17015.2 | V2 49
1846834 | 4 a V1 | 152 | 17015.2 | V2 49
1846895 | 4 a V1 | 356 | 15114 | V2 49
1846906 | 4 a V1 | 1693.29 | 15254 | V2 49
1846931 | 4 a V1 | 499 | 17015.2 | V2 49
1846940 | 1 a +-152.84 | 497.553 | 17015.2 | V2 49
1846943 | 4 a V1 | 392 | 17015.2 | V2 49
1846951 | 4 a V1 | 216 | 15114 | V2 49
1846977 | 4 a V1 | 1693.29 | 15254 | V2 49
1847001 | 4 a V1 | 4639 | 17015.2 | V2 49
1847014 | 4 a V1 | 671.1 | 17015.2 | V2 49
1847017 | 4 a V1 | 1692 | 17015.2 | V2 49
1847027 | 4 a V1 | 9892 | 17015.2 | V2 49
1847035 | 4 a V1 | 2777.11 | 17015.2 | V2 49
1847047 | 4 a V1 | 892 | 17015.2 | V2 49
1847055 | 4 a V1 | 172 | 17015.2 | V2 49
1847125 | 4 a V1 | 376 | 15114 | V2 49
1847134 | 4 a V1 | 1693.29 | 15254 | V2 49
1847241 | 4 a V1 | 2883.94 | 17062.2 | V2 23
1847251 | 4 a V1 | 812 | 17062.2 | V2 23
1847259 | 4 a V1 | 6692 | 17062.2 | V2 23
1847271 | 4 a V1 | 2134 | 17062.2 | V2 23
1847279 | 4 a V1 | 1539 | 17062.2 | V2 23
1847289 | 4 a V1 | 92 | 17062.2 | V2 23
1847297 | 4 a V1 | 176 | 15114 | V2 23
1847329 | 4 a V1 | 1740.27 | 15254 | V2 23
1847936 | 3 a | 42.34 | 17417 | V2 7
1848435 | 4 a V1 | 13297.2 | 17417 | V2 7
1848485 | 4 a V1 | 2012.66 | 17417 | V2 7
1848519 | 3 a | 1232.41 | 16872.8 | V2 50
1848532 | 3 a | 3601.83 | 13227 | V2 7
1848728 | 4 a V1 | 574.727 | 16872.8 | V2 50
1848738 | 4 a V1 | 1336.74 | 16872.8 | V2 50
1848746 | 4 a V1 | 1987.17 | 16872.8 | V2 50
1848756 | 4 a V1 | 2034 | 16872.8 | V2 50
1848764 | 4 a V1 | 3792 | 16872.8 | V2 50
1848782 | 4 a V1 | 3693.78 | 16872.8 | V2 50
1848795 | 4 a V1 | 2099.22 | 16872.8 | V2 50
1848805 | 4 a V1 | 86.5653 | 16872.8 | V2 50
1848815 | 4 a V1 | 196 | 15114 | V2 50
1848846 | 4 a V1 | 1550.83 | 15254 | V2 50
1848894 | 4 a V1 | 4481 | 16872.8 | V2 50
1848903 | 3 a | 433.586 | 16872.8 | V2 50
1848906 | 4 a V1 | 5839 | 16872.8 | V2 50
1848914 | 4 a V1 | 12.9948 | 16872.8 | V2 50
1848924 | 4 a V1 | 132.559 | 16872.8 | V2 50
1848957 | 4 a V1 | 1550.83 | 15254 | V2 50
1849022 | 4 a V1 | 76 | 16872.8 | V2 50
1849032 | 4 a V1 | 9741.99 | 16872.8 | V2 50
1849040 | 4 a V1 | 172 | 16872.8 | V2 50
1849050 | 4 a V1 | 94 | 15114 | V2 50
1849079 | 4 a V1 | 1550.83 | 15254 | V2 50
1849207 | 2 a | 4445.4 | 12471.1 | V2 7
1849381 | 4 a V1 | 1588 | 16960.4 | V2 51
1849391 | 4 a V1 | 1484.63 | 16960.4 | V2 51
1849401 | 4 a V1 | 6379 | 16960.4 | V2 51
1849411 | 4 a V1 | 52 | 16960.4 | V2 51
1849421 | 4 a V1 | 17112 | 16960.4 | V2 51
1849429 | 4 a V1 | 952 | 16960.4 | V2 51
1849439 | 4 a V1 | 7 | 16960.4 | V2 51
1849447 | 4 a V1 | 191 | 15114 | V2 51
1849482 | 4 a V1 | 1638.49 | 15254 | V2 51
1849611 | 4 a V1 | 3577.24 | 16960.4 | V2 51
1849621 | 4 a V1 | 4892 | 16960.4 | V2 51
1849629 | 4 a V1 | 312.631 | 16960.4 | V2 51
1849639 | 4 a V1 | 96 | 15114 | V2 51
1849680 | 4 a V1 | 1638.49 | 15254 | V2 51
1849756 | 5 a V1 | 2879 | 17062.2 | V2 23
1849765 | 4 a V1 | 3293.59 | 17062.2 | V2 23
1849768 | 5 a V1 | 152 | 17062.2 | V2 23
1849799 | 5 a V1 | 2343.73 | 17202.3 | V2 23
1849894 | 5 a V1 | 2196 | 17062.2 | V2 23
1849904 | 5 a V1 | 1832 | 17062.2 | V2 23
1849912 | 5 a V1 | 56 | 19613.9 | V2 23
1849934 | 5 a V1 | 2343.73 | 17202.3 | V2 23
1849996 | 5 a V1 | 703 | 17062.2 | V2 23
1850006 | 5 a V1 | 494 | 17062.2 | V2 23
1850016 | 5 a V1 | 12 | 17062.2 | V2 23
1850024 | 5 a V1 | 236 | 19614 | V2 23
1850056 | 5 a V1 | 2343.73 | 17202.3 | V2 23
1850113 | 5 a V1 | 3456 | 17062.2 | V2 23
1850123 | 5 a V1 | 2112 | 17062.2 | V2 23
1850143 | 5 a V1 | 219.296 | 17062.2 | V2 23
1850161 | 5 a V1 | 436 | 19614 | V2 23
1850186 | 5 a V1 | 2343.73 | 17202.3 | V2 23
1850242 | 5 a V1 | 1096 | 16872.8 | V2 50
1850252 | 5 a V1 | 392 | 16872.8 | V2 50
1850262 | 5 a V1 | 144 | 19614 | V2 50
1850287 | 5 a V1 | 2533.17 | 17012.8 | V2 50
1850358 | 5 a V1 | 856 | 16872.8 | V2 50
1850368 | 5 a V1 | 314.913 | 16872.8 | V2 50
1850378 | 5 a V1 | 76 | 19614 | V2 50
1850418 | 5 a V1 | 2533.17 | 17012.8 | V2 50
1850509 | 5 a V1 | 219 | 16872.8 | V2 50
1850516 | 4 a V1 | 2055.01 | 16872.8 | V2 50
1850519 | 5 a V1 | 160 | 19613.9 | V2 52
1850548 | 5 a V1 | 2533.17 | 17012.8 | V2 50

# IfcFlowSegment: Pipe Types:Standard (217)
Type - Pset_ProductRequirements - Category: Pipes
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00254 mm
Name (Pipe Types:Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1115007 | 0 a | 10097 | -1038.96 | vanduo šaltas - V1 1
1115288 | 0 a | 8530 | -1013.56 | vanduo šaltas - V1 1
1115322 | 0 a | 8870 | -1013.56 | vanduo šaltas - V1 1
1115441 | 0 a | 7118 | -1013.56 | vanduo šaltas - V1 1
1115534 | 0 a | 57048 | -1013.56 | vanduo šaltas - V1 4
1115628 | 0 a | 7118 | -1013.56 | vanduo šaltas - V1 1
1115727 | 0 a | 2234 | -3377 | vanduo šaltas - V1 1
1115739 | 0 a | 33588.6 | -3678.96 | vanduo šaltas - V1 1
1115800 | 0 a | 1294 | -2437 | vanduo šaltas - V1 1
1115810 | 0 a | 12097 | -2738.96 | vanduo šaltas - V1 1
1117425 | 0 a | 291.914 | -1038.96 | vanduo šaltas - V1 1
1117450 | 0 a | 1873.53 | -1038.96 | vanduo šaltas - V1 1
1117577 | 0 a | 13.6913 | -1038.96 | vanduo šaltas - V1 1
1117770 | 0 a | 38248.6 | -1038.96 | vanduo šaltas - V1 1
1425637 | 0 a | 343.914 | -1013.56 | vanduo šaltas - V1 1
1829796 | 0 a | 56748 | -1013.56 | vanduo šaltas - V1 3
1857078 | 5 a V1 | 7891.65 | 21794.6 | K1 3
1857086 | 5 a V1 | 4395.88 | 21705.7 | K1 3
1857110 | 5 a V1 | 3034.91 | 21938.6 | K1 3
1857123 | 5 a V1 | 3.81002 | 21952.4 | K1 3
1857124 | 5 a V1 | 18.4819 | 21972.6 | K1 3
1857128 | 5 a V1 | 2408.27 | 21954 | K1 3
1857141 | 5 a V1 | 2507.12 | 21884.1 | K1 3
1857165 | 5 a V1 | 2986.57 | 21876.1 | K1 3
1857174 | 5 a V1 | 92.4206 | 21935.8 | K1 3
1857180 | 5 a V1 | 1551.51 | 21841.8 | K1 3
1857208 | 5 a V1 | 2937.57 | 21815.6 | K1 3
1857217 | 5 a V1 | 40.1157 | 21874.3 | K1 3
1857222 | 5 a V1 | 1675.34 | 21781.1 | K1 3
1857342 | 5 a V1 | 2069.52 | 17345.3 | K1 4
1857372 | 5 a V1 | 5350.2 | 17374.2 | K1 4
1857387 | 5 a V1 | 4508.52 | 17252.6 | K1 4
1857406 | 5 a V1 | 1933.91 | 17488 | K1 4
1857449 | 5 a V1 | 2035.17 | 17266 | K1 4
1857462 | 5 a V1 | 3026.74 | 17311.2 | K1 4
1857517 | 5 a V1 | 1940.44 | 17313.8 | K1 4
1857528 | 5 a V1 | 2482.86 | 17259.1 | K1 4
1857549 | 5 a V1 | 5623.3 | 17490.5 | K1 4
1857632 | 5 a V1 | 20388.4 | 17252.6 | K1 1
1857646 | 5 a V1 | 1454.15 | 17664.1 | K1 1
1858663 | 4 a V1 | 4798.46 | 12963.1 | F1 n.p. 1
1858671 | 4 a V1 | 556.138 | 12947.9 | F1 n.p. 1
1858721 | 4 a V1 | 7915.73 | -4605.03 | F1 n.p. 1
1858796 | 4 a V1 | 16739.6 | -5092.56 | F1 n.p. 1
1858950 | 4 a V1 | 3256 | 12906.2 | F1 n.p. 2
1858958 | 4 a V1 | 4067.2 | 8783.72 | F1 n.p. 2
1858977 | 4 a V1 | 1337.48 | 8604.17 | F1 n.p. 2
1858989 | 4 a V1 | 13468.7 | -4919.82 | F1 n.p. 2
1859371 | 4 a V1 | 2796.6 | 12975.4 | F1 n.p. 2
1859383 | 4 a V1 | 916.224 | 13035.4 | F1 n.p. 2
1859393 | 4 a V1 | 378.096 | 13057.8 | F1 n.p. 2
1859450 | 0 a | 158.444 | -5395.52 | F1 n.p. 2
1859462 | 0 a | 299.557 | -5405.59 | F1 n.p. 2
1859540 | 0 a | 218.849 | -5622.14 | F1 n.p. 2
1859599 | 0 a | 122.82 | -5099.1 | F1 n.p. 1
1859640 | 0 a | 127.81 | -5250.63 | F1 n.p. 1
1859895 | 0 a | 3768.02 | 12794.2 | F1 n.p. 2
1859966 | 4 a V1 | 376.116 | 12782.6 | F1 n.p. 2
1860042 | 4 a V1 | 527.833 | 7771.34 | F1 n.p. 2
1860134 | 4 a V1 | 518 | 7620.57 | F1 n.p. 2
1860154 | 4 a V1 | 1396.3 | -5387.78 | F1 n.p. 2
1860217 | 0 a | 1016.28 | -5412.18 | F1 n.p. 2
1860229 | 0 a | 27202.2 | -5960.19 | F1 n.p. 2
1860239 | 0 a | 331.477 | -5976.49 | F1 n.p. 2
1860255 | 0 a | 380.919 | -5828.06 | F1 n.p. 2
1860256 | 0 a | 25.4017 | -5979.09 | F1 n.p. 2
1860260 | 0 a | 15768 | -5388.15 | F1 n.p. 2
1860290 | 0 a | 536.328 | 17221 | K1 5
1860323 | 4 a V1 | 1275 | 17194.5 | K1 5
1860385 | 0 a | 536.328 | 17221 | K1 6
1860387 | 4 a V1 | 1275 | 17194.5 | K1 6
1860401 | 0 a | 536.328 | 17221 | K1 7
1860403 | 4 a V1 | 1275 | 17194.5 | K1 7
1860421 | 0 a | 536.328 | 17221 | K1 8
1860423 | 4 a V1 | 1275 | 17194.5 | K1 8
1860441 | 0 a | 536.328 | 17221 | K1 9
1860443 | 4 a V1 | 1275 | 17194.5 | K1 9
1860459 | 0 a | 536.328 | 17221 | K1 10
1860461 | 4 a V1 | 1275 | 17194.5 | K1 10
1860479 | 0 a | 536.328 | 17221 | K1 11
1860481 | 4 a V1 | 1275 | 17194.5 | K1 11
1860700 | 4 a V1 | 4275 | 17220.5 | K1 12
1860753 | 4 a V1 | 4300 | 17220 | K1 13
1860763 | 4 a V1 | 8700 | 17220 | K1 14
1860804 | 4 a V1 | 1750.36 | 17220.5 | K1 12
1860819 | 4 a V1 | 13777.8 | 17256.5 | K1 12
1860871 | 4 a V1 | 2773.21 | 17220 | K1 15
1860905 | 4 a V1 | 2773.21 | 17220 | K1 16
1860917 | 4 a V1 | 2773.21 | 17220 | K1 17
1860927 | 4 a V1 | 2773.21 | 17220 | K1 18
1860939 | 4 a V1 | 2773.21 | 17220 | K1 19
1860949 | 4 a V1 | 2773.21 | 17220 | K1 20
1860961 | 4 a V1 | 2773.21 | 17220 | K1 21
1860971 | 4 a V1 | 2773.21 | 17220 | K1 22
1860981 | 4 a V1 | 2773.21 | 17220 | K1 23
1860991 | 4 a V1 | 2773.21 | 17220 | K1 24
1861077 | 4 a V1 | 2773.21 | 17220 | K1 25
1861121 | 4 a V1 | 2773.21 | 17220 | K1 26
1861133 | 4 a V1 | 2773.21 | 17220 | K1 27
1861149 | 4 a V1 | 2773.21 | 17220 | K1 28
1861159 | 4 a V1 | 2773.21 | 17220 | K1 29
1861169 | 4 a V1 | 2773.21 | 17220 | K1 30
1861181 | 4 a V1 | 2773.21 | 17220 | K1 31
1861220 | 4 a V1 | 2773.21 | 17220 | K1 32
1861278 | 4 a V1 | 753.848 | 8559.81 | F1 n.p. 1
1861287 | 4 a V1 | 4181.14 | 8711.47 | F1 n.p. 1
1861305 | 3 a | 916.224 | 8578.96 | F1 n.p. 1
1861317 | 3 a | 258 | 8601.36 | F1 n.p. 1
1861877 | 4 a V1 | 4218.17 | 8509.18 | F1 n.p. 2
1861899 | 3 a | 16725.6 | 8357.52 | F1 n.p. 2
1861907 | 3 a | 2798.58 | 8696.04 | F1 n.p. 2
1861972 | 3 a | 14431.2 | 8725.86 | F1 n.p. 3
1862070 | 3 a | 596 | -4505.61 | F1 n.p. 3
1862234 | 0 a | 4167.02 | -4593.01 | F1 n.p. 3
1862250 | 0 a | 243.655 | -4827.28 | F1 n.p. 3
1862354 | 3 a | 693.18 | 8574.2 | F1 n.p. 3
1862363 | 3 a | 12856.8 | -4340.89 | F1 n.p. 3
1862381 | 3 a | 7177.48 | 8592.14 | F1 n.p. 3
1862393 | 3 a | 1052.09 | 8739.74 | F1 n.p. 3
1862476 | 2 a | 23952.5 | 12780 | K1 33
1862656 | 3 a | 1012.75 | 12780.5 | K1 33
1862671 | 3 a | 9251.86 | 12801.8 | K1 33
1862681 | 3 a | 847.353 | 12987.8 | K1 33
1862734 | 3 a | 5476.1 | 9288.72 | K1 34
1862742 | 3 a | 2662.89 | 9399.22 | K1 34
1862817 | 3 a | 28755 | 11653.1 | K1 35
1862874 | 3 a | 1735.35 | 12229 | K1 35
1862960 | 3 a | 1975.4 | 11653.1 | K1 36
1862968 | 3 a | 3775.76 | 11693.6 | K1 36
1863006 | 3 a | 6351.28 | 11653.6 | K1 37
1863012 | 3 a | 1055.05 | 11781.6 | K1 37
1863022 | 3 a | 188.53 | 11803.7 | K1 37
1863046 | 3 a | 375.08 | 11653.6 | K1 37
1863092 | 4 a V1 | 8674.73 | -5207.06 | F1 n.p. 2
1863545 | 4 a V1 | 3993 | 3526.01 | F1 n.p. 2
1863575 | 4 a V1 | 3876.47 | 3677.67 | F1 n.p. 2
1863879 | 2 a | 6220.86 | 3616.66 | F1 n.p. 2
1863934 | 2 a | 324.453 | 3885.14 | F1 n.p. 2
1863977 | 2 a | 126.414 | 3609.93 | F1 n.p. 2
1863984 | 2 a | 4997.04 | 3895.7 | F1 n.p. 2
1863999 | 2 a | 638.148 | 3999.7 | F1 n.p. 2
1864023 | 2 a | 3069.89 | 3626.48 | F1 n.p. 2
1864033 | 2 a | 3.80994 | 3796.77 | F1 n.p. 2
1864034 | 2 a | 45.2152 | 3709.77 | F1 n.p. 2
1864038 | 2 a | 8798.66 | 3616.66 | F1 n.p. 2
1864084 | 2 a | 2393.52 | 3885.14 | F1 n.p. 2
1864093 | 2 a | 4209.88 | 3796.77 | F1 n.p. 2
1864099 | 2 a | 1108.98 | 3937.08 | F1 n.p. 2
1864179 | 4 a V1 | 4980.76 | 3520.7 | F1 n.p. 1
1864323 | 2 a | 5494.14 | 3369.04 | F1 n.p. 1
1864333 | 2 a | 2096.46 | 3482.98 | F1 n.p. 1
1864343 | 2 a | 8617.65 | 3528.98 | F1 n.p. 1
1864353 | 2 a | 9299.88 | 3705.38 | F1 n.p. 1
1864496 | 2 a | 7150 | 8198.92 | K1 38
1864504 | 2 a | 1915.67 | 8294.65 | K1 38
1864575 | 2 a | 1325.34 | 8199.09 | K1 38
1864623 | 2 a | 1183.24 | 7893.81 | K1 39
1864631 | 2 a | 5259.06 | 7918.47 | K1 39
1864641 | 2 a | 1103.37 | 8024.63 | K1 39
1864741 | 2 a | 6707.31 | 7918.47 | K1 40
1864861 | 2 a | 6133.78 | 8052.59 | K1 41
1864869 | 2 a | 1187.91 | 8176.24 | K1 41
1864917 | 2 a | 7634.56 | 7985.92 | K1 42
1865025 | 2 a | 5003.01 | 7985.92 | K1 42
1865036 | 2 a | 3933.84 | 7905.74 | K1 42
1865075 | 2 a | 422.721 | 7996.12 | K1 42
1865090 | 2 a | 5779.61 | 7788.65 | K1 42
1865109 | 2 a | 1322.27 | 7996.12 | K1 42
1865118 | 2 a | 4444.27 | 7905.74 | K1 42
1865153 | 2 a | 16403.3 | 7985.92 | K1 43
1865174 | 2 a | 7894.16 | 8104.06 | K1 44
1865196 | 2 a | 4357.88 | 8104.06 | K1 44
1865207 | 2 a | 5832.6 | 7985.92 | K1 44
1865212 | 2 a | 155.036 | 8192.2 | K1 44
1865275 | 2 a | 7976.6 | 8104.06 | K1 45
1865283 | 2 a | 8975 | 8264.56 | K1 45
1865306 | 2 a | 1492.3 | 8440.52 | K1 45
1865566 | 2 a | 6176.24 | 8104.06 | K1 46
1865574 | 2 a | 350.08 | 8228.56 | K1 46
1865584 | 2 a | 389.949 | 8236.56 | K1 46
1865626 | 2 a | 6776.36 | 7985.92 | K1 47
1865634 | 2 a | 8071.56 | 8122.42 | K1 47
1865644 | 2 a | 1883.56 | 8284.81 | K1 47
1865749 | 2 a | 15078 | 7985.92 | K1 48
1865757 | 2 a | 5339.76 | 8288.42 | K1 48
1865767 | 2 a | 6072.25 | 8396.19 | K1 48
1865790 | 2 a | 6601.32 | 7985.92 | K1 49
1865829 | 2 a | 4840.97 | 7985.92 | K1 50
1865856 | 2 a | 20300 | 7985.92 | K1 51
1865903 | 2 a | 20834 | 7985.92 | K1 52
1865941 | 2 a | 8771.65 | 2881.15 | K1 53
1867251 | 1 a +-152.84 | 2716.34 | 2969.36 | K1 53
1867328 | 2 a | 4085.72 | 2928 | K1 54
1867330 | 1 a +-152.84 | 875 | 2969.36 | K1 54
1867402 | 1 a +-152.84 | 6795.35 | 2881.15 | K1 55
1867410 | 1 a +-152.84 | 4474.73 | 2949.6 | K1 55
1867478 | 1 a +-152.84 | 5215.28 | 2956.74 | K1 56
1867486 | 1 a +-152.84 | 1060.48 | 3009.39 | K1 56
1867609 | 1 a +-152.84 | 5764.09 | 2881.15 | K1 54
1867616 | 2 a | 4609.93 | 2881.15 | K1 54
1867638 | 1 a +-152.84 | 5305.4 | 2910.09 | K1 57
1867663 | 1 a +-152.84 | 586.264 | 2882.68 | K1 57
1867673 | 1 a +-152.84 | 3.81002 | 2910.09 | K1 57
1867674 | 1 a +-152.84 | 6.63658 | 2896.24 | K1 57
1867678 | 1 a +-152.84 | 2819.01 | 2881.15 | K1 57
1867899 | 1 a +-152.84 | 6248.23 | 2881.15 | K1 59
1868033 | 1 a +-152.84 | 3423.71 | -493.088 | K1 59
1868121 | 1 a +-152.84 | 6679.18 | 2863.64 | K1 60
1868129 | 1 a +-152.84 | 2474.33 | 2930.93 | K1 60
1868202 | 1 a +-152.84 | 6679.18 | 2863.64 | K1 58
1868204 | 1 a +-152.84 | 2474.33 | 2930.93 | K1 58
1868217 | 1 a +-152.84 | 6679.18 | 2863.64 | K1 61
1868219 | 1 a +-152.84 | 1675 | 2913.68 | K1 61
1868316 | 1 a +-152.84 | 6679.18 | 2863.64 | K1 62
1868318 | 1 a +-152.84 | 3775 | 2930.93 | K1 62
1868399 | 1 a +-152.84 | 21081.4 | 2863.64 | K1 63
1868444 | 0 a | 3539.62 | -1066.87 | K1 64

# IfcFlowSegment: Pipe Types:Wavin AS+ (socket end) OD (3301)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipes
Pset_DistributionFlowElementCommon - Reference: Wavin AS+ (socket end) OD; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.046 mm
Name (Pipe Types:Wavin AS+ (socket end) OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1103431 | 0 a | 18056.3 | 163.171 | Lietaus nuotekos - L1 1
1103487 | 0 a | 18746 | -326.565 | Lietaus nuotekos - L1 1
1103802 | 0 a | 18288.9 | 28.0988 | Lietaus nuotekos - L1 2
1103913 | 0 a | 18786 | -469.024 | Lietaus nuotekos - L1 2
1103968 | 0 a | 14786 | 3530.98 | Lietaus nuotekos - L1 4
1103989 | 0 a | 18288.9 | 28.0988 | Lietaus nuotekos - L1 6
1103991 | 0 a | 17572 | -469.024 | Lietaus nuotekos - L1 6
1104008 | 0 a | 18657.6 | 28.0988 | Lietaus nuotekos - L1 8
1104010 | 0 a | 17271 | -469.024 | Lietaus nuotekos - L1 8
1104088 | 0 a | 6658.47 | -891.611 | Lietaus nuotekos - L1 1
1104281 | 0 a | 113.978 | -416.739 | Lietaus nuotekos - L1 1
1104282 | 0 a | 294.864 | -216.988 | Lietaus nuotekos - L1 1
1104286 | 0 a | 6722.31 | -752.31 | Lietaus nuotekos - L1 1
1104408 | 0 a | 6647.1 | -1035.01 | Lietaus nuotekos - L1 2
1104535 | 0 a | 120.161 | -560.365 | Lietaus nuotekos - L1 2
1104536 | 0 a | 298.216 | -354.431 | Lietaus nuotekos - L1 2
1104540 | 0 a | 6780.65 | -895.936 | Lietaus nuotekos - L1 2
1104631 | 0 a | 298.169 | 3233.69 | Lietaus nuotekos - L1 4
1104647 | 0 a | 3624.84 | -469.024 | Lietaus nuotekos - L1 4
1104724 | 0 a | 6657.68 | -1035.22 | Lietaus nuotekos - L1 6
1104762 | 0 a | 120.161 | -560.365 | Lietaus nuotekos - L1 6
1104763 | 0 a | 298.216 | -354.431 | Lietaus nuotekos - L1 6
1104767 | 0 a | 6780.65 | -895.936 | Lietaus nuotekos - L1 6
1104852 | 0 a | 6866.19 | -1039.39 | Lietaus nuotekos - L1 4
1104872 | 0 a | 18517.6 | 65.5913 | Lietaus nuotekos - L1 4
1104882 | 0 a | 132.659 | -560.365 | Lietaus nuotekos - L1 4
1104883 | 0 a | 333.565 | -341.934 | Lietaus nuotekos - L1 4
1104887 | 0 a | 6780.65 | -895.936 | Lietaus nuotekos - L1 4
1105041 | 0 a | 6657.68 | -1035.22 | Lietaus nuotekos - L1 8
1105069 | 0 a | 120.161 | -560.365 | Lietaus nuotekos - L1 8
1105070 | 0 a | 298.216 | -354.431 | Lietaus nuotekos - L1 8
1105074 | 0 a | 6780.65 | -895.936 | Lietaus nuotekos - L1 8
1105173 | 0 a | 5265.04 | 17700.4 | Lietaus nuotekos - L1 3
1105321 | 0 a | 23651.4 | -584.041 | Lietaus nuotekos - L1 9
1105353 | 0 a | 1286.02 | 21784.6 | Lietaus nuotekos - L1 11
1105385 | 0 a | 1086.02 | 21704.6 | Lietaus nuotekos - L1 9
1105397 | 0 a | 683.613 | 22107 | Lietaus nuotekos - L1 11
1106663 | 0 a | 5186.02 | 17604.6 | Lietaus nuotekos - L1 3
1106739 | 0 a | 3558.82 | 17242.1 | Lietaus nuotekos - L1 3
1106767 | 0 a | 17499.6 | -335.443 | Lietaus nuotekos - L1 3
1107010 | 0 a | 8909.92 | -804.932 | Lietaus nuotekos - L1 3
1107020 | 0 a | 383.32 | -815.612 | Lietaus nuotekos - L1 3
1107065 | 0 a | 12211.7 | -1077.78 | Lietaus nuotekos - L1 3
1107120 | 0 a | 3.89826 | -491.864 | Lietaus nuotekos - L1 3
1107121 | 0 a | 478.492 | -402.193 | Lietaus nuotekos - L1 3
1107125 | 0 a | 440.46 | -827.435 | Lietaus nuotekos - L1 3
1107351 | 0 a | 4216.11 | 21328.9 | Lietaus nuotekos - L1 9
1107367 | 0 a | 21567.7 | -316.698 | Lietaus nuotekos - L1 9
1107467 | 0 a | 8931.12 | -786.61 | Lietaus nuotekos - L1 9
1107509 | 0 a | 358.955 | -796.803 | Lietaus nuotekos - L1 9
1107527 | 0 a | 14033.3 | -1095.77 | Lietaus nuotekos - L1 9
1107725 | 0 a | 20.254 | -808.976 | Lietaus nuotekos - L1 9
1107728 | 0 a | 459.341 | -809.004 | Lietaus nuotekos - L1 9
1107965 | 0 a | 4111.36 | 21733.4 | Lietaus nuotekos - L1 11
1108167 | 0 a | 7716.13 | -850.161 | Lietaus nuotekos - L1 11
1108177 | 0 a | 912.954 | -871.431 | Lietaus nuotekos - L1 11
1108226 | 0 a | 5062.54 | 17728 | Lietaus nuotekos - L1 11
1108236 | 0 a | 120.994 | -552.438 | Lietaus nuotekos - L1 11
1108237 | 0 a | 254.855 | -345.672 | Lietaus nuotekos - L1 11
1108241 | 0 a | 678.234 | -888.009 | Lietaus nuotekos - L1 11
1108354 | 0 a | 2418.59 | 21444.9 | Lietaus nuotekos - L1 11
1108370 | 0 a | 21905.4 | -538.436 | Lietaus nuotekos - L1 11
1109074 | 0 a | 202.079 | -826.83 | Lietaus nuotekos - L1 13
1109129 | 0 a | 184.99 | -913.199 | Lietaus nuotekos - L1 13
1109445 | 5 a V1 | 3597.3 | 13384.1 | Lietaus nuotekos - L1 10
1109463 | 5 a V1 | 21613.2 | -4785.35 | Lietaus nuotekos - L1 10
1109477 | 5 a V1 | 23918.8 | -4971.67 | Lietaus nuotekos - L1 10
1109503 | 5 a V1 | 730.077 | 18217 | Lietaus nuotekos - L1 10
1109673 | 5 a V1 | 1386.02 | 17561.1 | Lietaus nuotekos - L1 7
1109709 | 0 a | 7311.12 | -1242.46 | Lietaus nuotekos - L1 13
1109717 | 0 a | 583.36 | -1257.14 | Lietaus nuotekos - L1 13
1109729 | 0 a | 7691.77 | -1595.31 | Lietaus nuotekos - L1 13
1110457 | 2 a | 14503.5 | -4690.72 | Lietaus nuotekos - L1 5
1110571 | 2 a | 14340.6 | -4527.83 | Lietaus nuotekos - L1 5
1110587 | 2 a | 14148.6 | -4335.83 | Lietaus nuotekos - L1 5
1110607 | 2 a | 13897.2 | -4084.43 | Lietaus nuotekos - L1 5
1110786 | 2 a | 14296 | -4483.18 | Lietaus nuotekos - L1 20
1110788 | 2 a | 14133.1 | -4320.29 | Lietaus nuotekos - L1 20
1110790 | 2 a | 13941.1 | -4128.29 | Lietaus nuotekos - L1 20
1110792 | 2 a | 1728.1 | 8084.68 | Lietaus nuotekos - L1 20
1110934 | 0 a | 8111 | -4326.75 | Lietaus nuotekos - L1 20
1110942 | 0 a | 483.34 | -4339.43 | Lietaus nuotekos - L1 20
1111152 | 0 a | 28628.9 | -5285.6 | Lietaus nuotekos - L1 20
1111244 | 2 a | 19.047 | -4706.62 | Lietaus nuotekos - L1 20
1111247 | 0 a | 7838.34 | -4706.98 | Lietaus nuotekos - L1 20
1111298 | 2 a | 19.047 | -4543.72 | Lietaus nuotekos - L1 20
1111301 | 0 a | 9293.92 | -4544.08 | Lietaus nuotekos - L1 20
1111330 | 2 a | 19.047 | -4351.72 | Lietaus nuotekos - L1 20
1111333 | 0 a | 481.929 | -4352.08 | Lietaus nuotekos - L1 20
1111367 | 2 a | 7649.64 | -4528.72 | Lietaus nuotekos - L1 5
1111432 | 0 a | 483.471 | -4541.4 | Lietaus nuotekos - L1 5
1111450 | 0 a | 28427.2 | -5492.77 | Lietaus nuotekos - L1 5
1111604 | 2 a | 19.503 | -4560.76 | Lietaus nuotekos - L1 5
1111607 | 0 a | 943.385 | -4563.28 | Lietaus nuotekos - L1 5
1111636 | 2 a | 19.503 | -4752.76 | Lietaus nuotekos - L1 5
1111639 | 0 a | 9293.92 | -4755.28 | Lietaus nuotekos - L1 5
1111668 | 2 a | 19.503 | -4915.65 | Lietaus nuotekos - L1 5
1111671 | 0 a | 7838.34 | -4918.18 | Lietaus nuotekos - L1 5
1112151 | 4 a V1 | 4.4993 | 12453.8 | Ūkio-buities nuotekos - F1 1
1112382 | 4 a V1 | 905.984 | 12435.1 | Ūkio-buities nuotekos - F1 1
1112417 | 4 a V1 | 754.906 | 12433 | Ūkio-buities nuotekos - F1 1
1112551 | 4 a V1 | 561.109 | 12324.4 | Ūkio-buities nuotekos - F1 1
1112559 | 4 a V1 | 7.52337 | 12294.8 | Ūkio-buities nuotekos - F1 1
1112594 | 4 a V1 | 3157.94 | -4069.69 | Ūkio-buities nuotekos - F1 1
1112838 | 4 a V1 | 32.1276 | 12566 | Ūkio-buities nuotekos - F1 1
1112925 | 4 a V1 | 4535.72 | 3353.73 | Ūkio-buities nuotekos - F1 1
1113160 | 4 a V1 | 535.931 | 3122.83 | Ūkio-buities nuotekos - F1 1
1113226 | 4 a V1 | 16.3728 | 2946.04 | Ūkio-buities nuotekos - F1 1
1113313 | 4 a V1 | 36.7433 | -242.251 | Ūkio-buities nuotekos - F1 2
1113383 | 4 a V1 | 4180 | -5161.27 | K1 2
1113482 | 4 a V1 | 4364.21 | -5299.97 | Ūkio-buities nuotekos - F1 5
1113596 | 4 a V1 | 17519.8 | -5299.97 | Ūkio-buities nuotekos - F1 7
1113624 | 4 a V1 | 13584.7 | -5299.97 | Ūkio-buities nuotekos - F1 9
1113800 | 4 a V1 | 8091.33 | -5116.78 | Ūkio-buities nuotekos - F1 12
1113880 | 4 a V1 | 163.627 | 17068.2 | Ūkio-buities nuotekos - F1 13
1114110 | 4 a V1 | 4931.81 | -1289.51 | Ūkio-buities nuotekos - F1 17
1114120 | 4 a V1 | 8663.3 | -5299.97 | Ūkio-buities nuotekos - F1 18
1114150 | 4 a V1 | 17850.6 | -5299.97 | Ūkio-buities nuotekos - F1 20
1118453 | 0 a | 35.9366 | 16942.6 | Lietaus nuotekos - L1 8
1118519 | 5 a V1 | 2235.94 | 16942.6 | Lietaus nuotekos - L1 8
1118584 | 5 a V1 | 5628.72 | 17166 | Lietaus nuotekos - L1 8
1118753 | 0 a | 238.157 | 17245.6 | Lietaus nuotekos - L1 6
1118775 | 0 a | 1032.02 | 17477 | Lietaus nuotekos - L1 6
1118912 | 4 a V1 | 5966.94 | 17133.1 | K1 2
1119185 | 4 a V1 | 1809.25 | 17096.1 | K1 2
1119216 | 5 a V1 | 149 | 17153 | K1 2
1119339 | 4 a V1 | 587.706 | 17291.8 | Ūkio-buities nuotekos - F1 5
1119348 | 4 a V1 | 5732.76 | 17267.3 | Ūkio-buities nuotekos - F1 5
1119553 | 5 a V1 | 298.983 | 17379.3 | Ūkio-buities nuotekos - F1 5
1119570 | 4 a V1 | 224.778 | 17284.5 | Ūkio-buities nuotekos - F1 5
1119900 | 5 a V1 | 206.995 | 17387.8 | Ūkio-buities nuotekos - F1 5
1121136 | 4 a V1 | 4197.2 | 12566.6 | Ūkio-buities nuotekos - F1 8
1121180 | 5 a V1 | 186.699 | 17025 | Ūkio-buities nuotekos - F1 8
1121190 | 5 a V1 | 504.146 | 17066.4 | Ūkio-buities nuotekos - F1 8
1121244 | 5 a V1 | 324.042 | 17134.9 | Ūkio-buities nuotekos - F1 8
1121259 | 5 a V1 | 280.508 | 17082.2 | Ūkio-buities nuotekos - F1 8
1121316 | 5 a V1 | 279.757 | 17076.4 | Ūkio-buities nuotekos - F1 8
1121325 | 5 a V1 | 943.567 | 17034.5 | Ūkio-buities nuotekos - F1 8
1121480 | 4 a V1 | 116.823 | 17474.2 | Ūkio-buities nuotekos - F1 12
1121502 | 4 a V1 | 6255.11 | 17644.9 | Ūkio-buities nuotekos - F1 12
1121566 | 4 a V1 | 1291.84 | 17352.6 | Ūkio-buities nuotekos - F1 13
1121582 | 4 a V1 | 6353.21 | 17546.8 | Ūkio-buities nuotekos - F1 13
1121655 | 4 a V1 | 4434.11 | 13077.7 | Ūkio-buities nuotekos - F1 13
1121663 | 4 a V1 | 1497.05 | 17632.6 | Ūkio-buities nuotekos - F1 13
1121677 | 4 a V1 | 5869.11 | 17830.9 | Ūkio-buities nuotekos - F1 13
1122055 | 5 a V1 | 235.1 | 17066.4 | Lietaus nuotekos - L1 10
1122507 | 5 a V1 | 1160.8 | 17414.7 | Lietaus nuotekos - L1 10
1122616 | 4 a V1 | 1517.56 | 17432.6 | Ūkio-buities nuotekos - F1 14
1122632 | 4 a V1 | 6068.71 | 17631.3 | Ūkio-buities nuotekos - F1 14
1122905 | 5 a V1 | 268.6 | 16910.6 | Lietaus nuotekos - L1 10
1123229 | 5 a V1 | 1280.8 | 17291.3 | Lietaus nuotekos - L1 10
1123293 | 4 a V1 | 4695.45 | 17155.7 | Ūkio-buities nuotekos - F1 15
1123309 | 4 a V1 | 6230.21 | 17469.8 | Ūkio-buities nuotekos - F1 15
1124047 | 4 a V1 | 4689.77 | 3642.07 | Ūkio-buities nuotekos - F1 19
1124055 | 4 a V1 | 806.824 | 8452.65 | Ūkio-buities nuotekos - F1 19
1124069 | 4 a V1 | 11203.5 | 12896.5 | Ūkio-buities nuotekos - F1 19
1125110 | 5 a V1 | 1166.82 | 17201 | Lietaus nuotekos - L1 10
1125208 | 5 a V1 | 4037.73 | 16944 | Lietaus nuotekos - L1 10
1125449 | 5 a V1 | 20838 | -3971.96 | Lietaus nuotekos - L1 10
1125912 | 4 a V1 | 5931.01 | 17872.4 | Ūkio-buities nuotekos - F1 16
1125920 | 4 a V1 | 1386.68 | 17624.5 | Ūkio-buities nuotekos - F1 16
1126255 | 5 a V1 | 988.411 | 17599 | Ūkio-buities nuotekos - F1 16
1126291 | 5 a V1 | 4025.32 | 13504.8 | Ūkio-buities nuotekos - F1 16
1127277 | 4 a V1 | 1171.16 | 13112 | Ūkio-buities nuotekos - F1 16
1127480 | 4 a V1 | 989.682 | 12944.5 | Ūkio-buities nuotekos - F1 16
1127491 | 4 a V1 | 113.767 | 12929.3 | Ūkio-buities nuotekos - F1 16
1127606 | 4 a V1 | 1411.55 | 12968.1 | Ūkio-buities nuotekos - F1 16
1127622 | 4 a V1 | 636.253 | 13043.9 | Ūkio-buities nuotekos - F1 16
1127997 | 5 a V1 | 682.259 | 13280.2 | Ūkio-buities nuotekos - F1 16
1128091 | 4 a V1 | 349.433 | 13302.8 | Ūkio-buities nuotekos - F1 16
1128100 | 5 a V1 | 248.781 | 13270.8 | Ūkio-buities nuotekos - F1 16
1128131 | 4 a V1 | 367.999 | 13052.6 | Ūkio-buities nuotekos - F1 14
1128142 | 4 a V1 | 4330.82 | 12981 | Ūkio-buities nuotekos - F1 14
1128221 | 4 a V1 | 217.287 | 12638.2 | Ūkio-buities nuotekos - F1 13
1128274 | 4 a V1 | 1358.26 | 13078.7 | Ūkio-buities nuotekos - F1 13
1128282 | 4 a V1 | 1505.36 | 13126.6 | Ūkio-buities nuotekos - F1 13
1128421 | 4 a V1 | 1316.85 | 16821.7 | Ūkio-buities nuotekos - F1 13
1128437 | 4 a V1 | 15.3471 | 12644.3 | Ūkio-buities nuotekos - F1 13
1128612 | 4 a V1 | 1316.85 | 12397.9 | Ūkio-buities nuotekos - F1 13
1128794 | 4 a V1 | 742.214 | 12852.3 | Ūkio-buities nuotekos - F1 13
1128803 | 4 a V1 | 3870.79 | 12882 | Ūkio-buities nuotekos - F1 13
1128844 | 4 a V1 | 365.532 | 12948.6 | Ūkio-buities nuotekos - F1 13
1128874 | 4 a V1 | 2948.6 | 12921.1 | Ūkio-buities nuotekos - F1 13
1128883 | 4 a V1 | 407.008 | 12879 | Ūkio-buities nuotekos - F1 13
1129204 | 5 a V1 | 283.228 | 17264.1 | Lietaus nuotekos - L1 7
1129234 | 5 a V1 | 194.253 | 17252.9 | Lietaus nuotekos - L1 7
1129342 | 5 a V1 | 137.108 | 17242.9 | Lietaus nuotekos - L1 7
1129408 | 5 a V1 | 9184.97 | -1003.79 | Lietaus nuotekos - L1 7
1129447 | 4 a V1 | 185.235 | 12540.3 | Ūkio-buities nuotekos - F1 12
1129456 | 4 a V1 | 4802.66 | 12550.8 | Ūkio-buities nuotekos - F1 12
1129665 | 4 a V1 | 1080 | 12421.1 | Ūkio-buities nuotekos - F1 12
1129674 | 4 a V1 | 390.58 | 12521.1 | Ūkio-buities nuotekos - F1 12
1129741 | 4 a V1 | 4118.92 | 8636.92 | Ūkio-buities nuotekos - F1 19
1129777 | 4 a V1 | 1769.09 | 12937.4 | Ūkio-buities nuotekos - F1 19
1129787 | 4 a V1 | 3490.22 | 12991.7 | Ūkio-buities nuotekos - F1 19
1129822 | 4 a V1 | 2848.64 | 12706.5 | Ūkio-buities nuotekos - F1 20
1129831 | 4 a V1 | 5808.71 | 12691.3 | Ūkio-buities nuotekos - F1 20
1129900 | 4 a V1 | 1073.83 | 12767.3 | Ūkio-buities nuotekos - F1 20
1129964 | 4 a V1 | 198.228 | 12468.6 | Ūkio-buities nuotekos - F1 18
1129973 | 4 a V1 | 11349.6 | 12450.4 | Ūkio-buities nuotekos - F1 18
1130055 | 4 a V1 | 854.165 | 12476.4 | Ūkio-buities nuotekos - F1 18
1130071 | 4 a V1 | 2269.21 | 12497.2 | Ūkio-buities nuotekos - F1 18
1130085 | 4 a V1 | 354.011 | 12546.4 | Ūkio-buities nuotekos - F1 18
1130178 | 4 a V1 | 659.717 | 12471.2 | Ūkio-buities nuotekos - F1 18
1130187 | 4 a V1 | 27.0997 | 12465.6 | Ūkio-buities nuotekos - F1 18
1130229 | 4 a V1 | 2754.42 | 12487.4 | Ūkio-buities nuotekos - F1 18
1130276 | 4 a V1 | 3294.17 | 12617.1 | Ūkio-buities nuotekos - F1 18
1130290 | 4 a V1 | 860.051 | 12692.3 | Ūkio-buities nuotekos - F1 18
1130330 | 4 a V1 | 1088.9 | 12760.3 | Ūkio-buities nuotekos - F1 18
1130348 | 4 a V1 | 131.231 | 12785.8 | Ūkio-buities nuotekos - F1 18
1130562 | 4 a V1 | 250.006 | 12542 | Ūkio-buities nuotekos - F1 1
1130620 | 4 a V1 | 596.182 | 12549.3 | Ūkio-buities nuotekos - F1 1
1130646 | 4 a V1 | 689.775 | 12621.1 | Ūkio-buities nuotekos - F1 1
1130761 | 4 a V1 | 520.384 | 12621.6 | Ūkio-buities nuotekos - F1 1
1130772 | 4 a V1 | 369.828 | 12605.6 | Ūkio-buities nuotekos - F1 1
1130814 | 4 a V1 | 35.9782 | 12800.3 | Ūkio-buities nuotekos - F1 1
1130848 | 4 a V1 | 86.664 | 12957.1 | Ūkio-buities nuotekos - F1 1
1131060 | 4 a V1 | 5657.31 | 13127.2 | Ūkio-buities nuotekos - F1 1
1131235 | 4 a V1 | 637.662 | 12451.3 | Ūkio-buities nuotekos - F1 1
1131259 | 4 a V1 | 18.2326 | 12510.9 | Ūkio-buities nuotekos - F1 1
1131304 | 4 a V1 | 600.933 | 12479.5 | Ūkio-buities nuotekos - F1 1
1131313 | 4 a V1 | 19.3367 | 12469.8 | Ūkio-buities nuotekos - F1 1
1131354 | 4 a V1 | 6031.05 | 12649.4 | Ūkio-buities nuotekos - F1 1
1131501 | 5 a V1 | 305.641 | 17111 | K1 2
1131581 | 4 a V1 | 227.449 | 17089 | K1 2
1131588 | 5 a V1 | 8246.92 | 17077 | K1 2
1131639 | 5 a V1 | 2269.13 | 17245.7 | K1 2
1131653 | 5 a V1 | 1614.18 | 17294.8 | K1 2
1131841 | 5 a V1 | 107.461 | 18729.5 | K1 2
1131923 | 5 a V1 | 1202.88 | 17432 | K1 2
1132281 | 5 a V1 | 969.503 | 17147.7 | K1 2
1132338 | 5 a V1 | 1370.28 | 17171.5 | K1 2
1132473 | 5 a V1 | 867.052 | 17320.5 | K1 2
1139352 | 5 a V1 | 2506.4 | 17154.9 | K1 2
1139417 | 5 a V1 | 130.168 | 17134.9 | K1 2
1139432 | 5 a V1 | 171.936 | 18729.5 | K1 2
1139519 | 5 a V1 | 1333.26 | 17301.6 | K1 2
1139644 | 5 a V1 | 19.6522 | 17153.9 | K1 2
1139651 | 5 a V1 | 161.51 | 17147.3 | K1 2
1139664 | 5 a V1 | 171.811 | 17152.4 | K1 2
1139711 | 5 a V1 | 67.4769 | 18729.5 | K1 2
1139792 | 5 a V1 | 1382.16 | 17252.7 | K1 2
1140002 | 5 a V1 | 187.479 | 17274.6 | Ūkio-buities nuotekos - F1 5
1140045 | 4 a V1 | 152.859 | 17237.6 | Ūkio-buities nuotekos - F1 5
1140054 | 5 a V1 | 3702.72 | 17282.2 | Ūkio-buities nuotekos - F1 5
1140068 | 5 a V1 | 799.552 | 17360 | Ūkio-buities nuotekos - F1 5
1140082 | 5 a V1 | 175.789 | 17379.7 | Ūkio-buities nuotekos - F1 5
1140096 | 5 a V1 | 70.7843 | 18729.5 | Ūkio-buities nuotekos - F1 5
1140169 | 5 a V1 | 1154.76 | 17480.1 | Ūkio-buities nuotekos - F1 5
1140662 | 4 a V1 | 12.6111 | 17525.1 | Ūkio-buities nuotekos - F1 5
1140671 | 4 a V1 | 1826.84 | 17243.5 | Ūkio-buities nuotekos - F1 5
1141262 | 4 a V1 | 349.844 | 17682.7 | Ūkio-buities nuotekos - F1 5
1141362 | 5 a V1 | 174.717 | 17329.1 | Ūkio-buities nuotekos - F1 5
1141371 | 5 a V1 | 59.4175 | 17322.9 | Ūkio-buities nuotekos - F1 5
1141405 | 5 a V1 | 75.0107 | 18679.5 | Ūkio-buities nuotekos - F1 5
1141422 | 5 a V1 | 1155.36 | 17429.5 | Ūkio-buities nuotekos - F1 5
1141637 | 5 a V1 | 40.2311 | 17281.4 | Ūkio-buities nuotekos - F1 5
1141854 | 5 a V1 | 781.954 | 17403.8 | Ūkio-buities nuotekos - F1 5
1142807 | 5 a V1 | 5709.89 | 17267 | Ūkio-buities nuotekos - F1 8
1142816 | 5 a V1 | 3211.51 | 16956.3 | Ūkio-buities nuotekos - F1 8
1143117 | 5 a V1 | 3437.77 | 21657.4 | Lietaus nuotekos - L1 11
1143147 | 5 a V1 | 4238.04 | 17341.5 | Lietaus nuotekos - L1 11
1143167 | 5 a V1 | 2896.13 | 16992.3 | Lietaus nuotekos - L1 11
1143187 | 0 a | 65.0108 | 16982.3 | Lietaus nuotekos - L1 11
1143188 | 5 a V1 | 217.755 | 16986.4 | Lietaus nuotekos - L1 11
1143192 | 0 a | 17133.6 | -404.544 | Lietaus nuotekos - L1 11
1143429 | 5 a V1 | 320.017 | 17087.8 | Ūkio-buities nuotekos - F1 8
1143497 | 5 a V1 | 442.688 | 17062 | Ūkio-buities nuotekos - F1 8
1143759 | 5 a V1 | 970.014 | 17215.8 | Ūkio-buities nuotekos - F1 8
1143891 | 5 a V1 | 520.666 | 17080.4 | Ūkio-buities nuotekos - F1 8
1143902 | 5 a V1 | 482.036 | 17068.7 | Ūkio-buities nuotekos - F1 8
1143917 | 5 a V1 | 126.869 | 18552.6 | Ūkio-buities nuotekos - F1 8
1143979 | 5 a V1 | 1180.04 | 17251.8 | Ūkio-buities nuotekos - F1 8
1144028 | 5 a V1 | 1005.07 | 17246.6 | Ūkio-buities nuotekos - F1 8
1144117 | 5 a V1 | 168.673 | 17097.1 | Ūkio-buities nuotekos - F1 8
1144128 | 5 a V1 | 287.543 | 17057.8 | Ūkio-buities nuotekos - F1 8
1144143 | 5 a V1 | 231.83 | 17097.1 | Ūkio-buities nuotekos - F1 8
1144190 | 5 a V1 | 107.485 | 18729.5 | Ūkio-buities nuotekos - F1 8
1144230 | 5 a V1 | 1436.3 | 17198.5 | Ūkio-buities nuotekos - F1 8
1144300 | 5 a V1 | 972.344 | 17364.5 | Ūkio-buities nuotekos - F1 8
1144391 | 5 a V1 | 81.1922 | 17106 | Ūkio-buities nuotekos - F1 8
1144400 | 5 a V1 | 9.61798 | 17097.2 | Ūkio-buities nuotekos - F1 8
1144407 | 5 a V1 | 135.192 | 18602.6 | Ūkio-buities nuotekos - F1 8
1144450 | 5 a V1 | 1205.81 | 17276 | Ūkio-buities nuotekos - F1 8
1144518 | 5 a V1 | 289.282 | 17146.5 | Ūkio-buities nuotekos - F1 8
1144533 | 5 a V1 | 534.294 | 17101.8 | Ūkio-buities nuotekos - F1 8
1144542 | 5 a V1 | 67.4769 | 18679.5 | Ūkio-buities nuotekos - F1 8
1144569 | 5 a V1 | 1335.73 | 17249.1 | Ūkio-buities nuotekos - F1 8
1144652 | 5 a V1 | 838.145 | 17115.3 | Ūkio-buities nuotekos - F1 8
1145032 | 5 a V1 | 55.2742 | 17166 | Ūkio-buities nuotekos - F1 8
1145167 | 5 a V1 | 203.014 | 17193.8 | Ūkio-buities nuotekos - F1 8
1145175 | 5 a V1 | 1218.55 | 17416.3 | Ūkio-buities nuotekos - F1 8
1145232 | 5 a V1 | 124.538 | 18729.5 | Ūkio-buities nuotekos - F1 8
1145297 | 5 a V1 | 817.435 | 17127.9 | Ūkio-buities nuotekos - F1 8
1145397 | 5 a V1 | 1112.35 | 17369.5 | Ūkio-buities nuotekos - F1 8
1145400 | 5 a V1 | 394.087 | 17115.6 | Ūkio-buities nuotekos - F1 8
1145447 | 5 a V1 | 996.842 | 17092.2 | Ūkio-buities nuotekos - F1 8
1145470 | 5 a V1 | 584.542 | 17156.8 | Ūkio-buities nuotekos - F1 8
1145608 | 5 a V1 | 431.888 | 17186 | Ūkio-buities nuotekos - F1 8
1145644 | 5 a V1 | 107.485 | 18729.5 | Ūkio-buities nuotekos - F1 8
1145702 | 5 a V1 | 1343.38 | 17291.5 | Ūkio-buities nuotekos - F1 8
1145821 | 5 a V1 | 932.05 | 17134.8 | Ūkio-buities nuotekos - F1 8
1145852 | 5 a V1 | 847.621 | 17160 | Ūkio-buities nuotekos - F1 8
1145940 | 5 a V1 | 965.77 | 17298.5 | Ūkio-buities nuotekos - F1 8
1151744 | 4 a V1 | 94.6543 | 12447 | Ūkio-buities nuotekos - F1 1
1151881 | 4 a V1 | 694.454 | 12639.2 | Ūkio-buities nuotekos - F1 1
1151890 | 4 a V1 | 425.982 | 12635 | Ūkio-buities nuotekos - F1 1
1151936 | 4 a V1 | 5826.33 | 12852.5 | Ūkio-buities nuotekos - F1 1
1151994 | 4 a V1 | 621.754 | 12576.8 | Ūkio-buities nuotekos - F1 1
1152003 | 4 a V1 | 212.994 | 12570.7 | Ūkio-buities nuotekos - F1 1
1152072 | 4 a V1 | 5872.79 | 12757.6 | Ūkio-buities nuotekos - F1 1
1152265 | 4 a V1 | 550.91 | 12676.1 | Ūkio-buities nuotekos - F1 1
1152369 | 4 a V1 | 910.245 | 12855.4 | Ūkio-buities nuotekos - F1 1
1152432 | 4 a V1 | 890.454 | 12679.7 | Ūkio-buities nuotekos - F1 1
1152441 | 4 a V1 | 424.862 | 12659.9 | Ūkio-buities nuotekos - F1 1
1152689 | 4 a V1 | 988.959 | 12825.6 | Ūkio-buities nuotekos - F1 1
1152808 | 4 a V1 | 262.556 | 12651.1 | Ūkio-buities nuotekos - F1 1
1152817 | 4 a V1 | 538.391 | 12646.9 | Ūkio-buities nuotekos - F1 1
1152830 | 4 a V1 | 164.769 | 14052.6 | Ūkio-buities nuotekos - F1 1
1152942 | 4 a V1 | 27.603 | 13904.2 | Ūkio-buities nuotekos - F1 1
1153039 | 4 a V1 | 1709.03 | 12656.7 | Ūkio-buities nuotekos - F1 1
1153048 | 4 a V1 | 290.502 | 12625.6 | Ūkio-buities nuotekos - F1 1
1153071 | 4 a V1 | 373.555 | 12705.5 | Ūkio-buities nuotekos - F1 1
1153085 | 4 a V1 | 231.315 | 12716.7 | Ūkio-buities nuotekos - F1 1
1153099 | 4 a V1 | 189.725 | 12725.1 | Ūkio-buities nuotekos - F1 1
1153113 | 4 a V1 | 107.485 | 14229.5 | Ūkio-buities nuotekos - F1 1
1153163 | 4 a V1 | 1309.09 | 12825.8 | Ūkio-buities nuotekos - F1 1
1153193 | 4 a V1 | 120.145 | 12708.9 | Ūkio-buities nuotekos - F1 1
1153202 | 4 a V1 | 232.469 | 12698.4 | Ūkio-buities nuotekos - F1 1
1153209 | 4 a V1 | 67.4769 | 14229.5 | Ūkio-buities nuotekos - F1 1
1153292 | 4 a V1 | 1326.73 | 12808.1 | Ūkio-buities nuotekos - F1 1
1153323 | 4 a V1 | 66.052 | 12560.2 | Ūkio-buities nuotekos - F1 1
1153331 | 4 a V1 | 241.731 | 12625.5 | Ūkio-buities nuotekos - F1 1
1153521 | 4 a V1 | 220.256 | 12646.1 | Ūkio-buities nuotekos - F1 1
1153532 | 4 a V1 | 2510.3 | 12577.2 | Ūkio-buities nuotekos - F1 1
1153541 | 4 a V1 | 309.726 | 12654.2 | Ūkio-buities nuotekos - F1 1
