Properties of the parts of a building model (IFC2X3), part 51 of 57

# IfcFlowSegment: Pipe Types:Wavin AS+ (socket end) OD (3301)
Name (Pipe Types:Wavin AS+ (socket end) OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1319613 | 1 a +-152.84 | 101.02 | -604.487 | Ūkio-buities nuotekos - F1 69
1319621 | 1 a +-152.84 | 444.817 | 252.615 | Ūkio-buities nuotekos - F1 69
1319746 | 1 a +-152.84 | 565.94 | -434.13 | Ūkio-buities nuotekos - F1 69
1319796 | 1 a +-152.84 | 61.0124 | -626.115 | Ūkio-buities nuotekos - F1 69
1319805 | 2 a | 449.893 | -643.755 | Ūkio-buities nuotekos - F1 69
1319812 | 1 a +-152.84 | 404.817 | 252.615 | Ūkio-buities nuotekos - F1 69
1319903 | 1 a +-152.84 | 588.369 | -456.558 | Ūkio-buities nuotekos - F1 69
1319933 | 1 a +-152.84 | 109.246 | -780.056 | Ūkio-buities nuotekos - F1 69
1319944 | 2 a | 169.109 | -810.474 | Ūkio-buities nuotekos - F1 69
1319967 | 1 a +-152.84 | 247.449 | 379.455 | Ūkio-buities nuotekos - F1 69
1320043 | 1 a +-152.84 | 965.871 | -681.023 | Ūkio-buities nuotekos - F1 69
1320207 | 1 a +-152.84 | 668.838 | -573.795 | Ūkio-buities nuotekos - F1 69
1320220 | 2 a | 189.37 | -630.316 | Ūkio-buities nuotekos - F1 69
1320227 | 1 a +-152.84 | 1863.14 | -554.721 | Ūkio-buities nuotekos - F1 69
1320241 | 1 a +-152.84 | 203.487 | 252.615 | Ūkio-buities nuotekos - F1 69
1320270 | 1 a +-152.84 | 480.939 | -349.129 | Ūkio-buities nuotekos - F1 69
1320337 | 1 a +-152.84 | 2109.57 | -567.848 | Ūkio-buities nuotekos - F1 69
1320348 | 1 a +-152.84 | 924.175 | -617.886 | Ūkio-buities nuotekos - F1 69
1320357 | 1 a +-152.84 | 167.497 | 429.455 | Ūkio-buities nuotekos - F1 69
1320407 | 1 a +-152.84 | 763.664 | -428.816 | Ūkio-buities nuotekos - F1 69
1320437 | 1 a +-152.84 | 251.261 | -545.05 | Ūkio-buities nuotekos - F1 69
1320450 | 1 a +-152.84 | 835.362 | -593.313 | Ūkio-buities nuotekos - F1 69
1320459 | 1 a +-152.84 | 492.753 | -520.679 | Ūkio-buities nuotekos - F1 69
1320473 | 1 a +-152.84 | 129.092 | -507.052 | Ūkio-buities nuotekos - F1 69
1320524 | 1 a +-152.84 | 742.47 | -407.621 | Ūkio-buities nuotekos - F1 69
1320559 | 1 a +-152.84 | 120.166 | -520.496 | Ūkio-buities nuotekos - F1 69
1320570 | 1 a +-152.84 | 655.47 | -536.252 | Ūkio-buities nuotekos - F1 69
1320608 | 1 a +-152.84 | 756.093 | -421.245 | Ūkio-buities nuotekos - F1 69
1320643 | 1 a +-152.84 | 6450.51 | -562.169 | Ūkio-buities nuotekos - F1 69
1320658 | 1 a +-152.84 | 23.3273 | -596.592 | Ūkio-buities nuotekos - F1 69
1320667 | 1 a +-152.84 | 375.755 | 429.455 | Ūkio-buities nuotekos - F1 69
1320719 | 1 a +-152.84 | 671.184 | -336.335 | Ūkio-buities nuotekos - F1 69
1411610 | 0 a | 13333.7 | -5591.2 | Ūkio-buities nuotekos - F1 2
1411619 | 4 a V1 | 4622.25 | -5318.88 | Ūkio-buities nuotekos - F1 2
1411743 | 2 a | 86.245 | -5037.02 | Ūkio-buities nuotekos - F1 75
1411780 | 0 a | 1595.16 | -4970.58 | Ūkio-buities nuotekos - F1 75
1411788 | 0 a | 402.969 | -4932.99 | Ūkio-buities nuotekos - F1 75
1411802 | 0 a | 162.762 | -3547.42 | Ūkio-buities nuotekos - F1 75
1411851 | 0 a | 1088.4 | -4756.59 | Ūkio-buities nuotekos - F1 75
1412036 | 0 a | 1599.28 | -5005.38 | Ūkio-buities nuotekos - F1 75
1412206 | 0 a | 1427.86 | -4843.01 | Ūkio-buities nuotekos - F1 75
1412453 | 2 a | 13.3423 | -4758.22 | Ūkio-buities nuotekos - F1 75
1412462 | 2 a | 7938.78 | -4728.56 | Ūkio-buities nuotekos - F1 75
1412548 | 0 a | 82.1249 | -4752.25 | Ūkio-buities nuotekos - F1 75
1412662 | 0 a | 96.195 | -4717.99 | Ūkio-buities nuotekos - F1 75
1412676 | 0 a | 161.063 | -4707.42 | Ūkio-buities nuotekos - F1 75
1412837 | 0 a | 464.317 | -4974.23 | Ūkio-buities nuotekos - F1 75
1412846 | 0 a | 826.562 | -5024.72 | Ūkio-buities nuotekos - F1 75
1412869 | 0 a | 1108.35 | -4868.1 | Ūkio-buities nuotekos - F1 75
1413214 | 0 a | 244.496 | -3646.98 | Ūkio-buities nuotekos - F1 75
1413239 | 0 a | 769.101 | -4536.88 | Ūkio-buities nuotekos - F1 75
1413367 | 0 a | 1140.08 | -5016.78 | Ūkio-buities nuotekos - F1 75
1413411 | 0 a | 1087.45 | -4897.13 | Ūkio-buities nuotekos - F1 75
1413424 | 0 a | 434.153 | -5059.41 | Ūkio-buities nuotekos - F1 75
1413622 | 0 a | 730.685 | -4498.45 | Ūkio-buities nuotekos - F1 75
1413625 | 0 a | 156.831 | -4744.91 | Ūkio-buities nuotekos - F1 75
1413686 | 0 a | 280.202 | -3320 | Ūkio-buities nuotekos - F1 75
1413707 | 0 a | 1118.95 | -4533.21 | Ūkio-buities nuotekos - F1 75
1413710 | 0 a | 449.071 | -4729.78 | Ūkio-buities nuotekos - F1 75
1414030 | 0 a | 528.685 | -4683.2 | Ūkio-buities nuotekos - F1 75
1414069 | 0 a | 127.489 | -3320.54 | Ūkio-buities nuotekos - F1 75
1414160 | 0 a | 1160.63 | -4575.78 | Ūkio-buities nuotekos - F1 75
1414250 | 0 a | 1503.64 | -4688.48 | Ūkio-buities nuotekos - F1 75
1414271 | 0 a | 236.945 | -4737.33 | Ūkio-buities nuotekos - F1 75
1414294 | 0 a | 809.372 | -4654.64 | Ūkio-buities nuotekos - F1 75
1414308 | 0 a | 87.4809 | -3320.54 | Ūkio-buities nuotekos - F1 75
1414354 | 0 a | 1126.45 | -4541.6 | Ūkio-buities nuotekos - F1 75
1414403 | 0 a | 820.353 | -4685.9 | Ūkio-buities nuotekos - F1 75
1414440 | 0 a | 384.758 | -4698.64 | Ūkio-buities nuotekos - F1 75
1414447 | 0 a | 54.7347 | -3320.54 | Ūkio-buities nuotekos - F1 75
1414520 | 0 a | 1157.49 | -4572.64 | Ūkio-buities nuotekos - F1 75
1414563 | 0 a | 377.672 | -4975.65 | Ūkio-buities nuotekos - F1 75
1414576 | 0 a | 221.998 | -5066.67 | Ūkio-buities nuotekos - F1 75
1414585 | 0 a | 811.964 | -4964.32 | Ūkio-buities nuotekos - F1 75
1414599 | 0 a | 156.291 | -3320.54 | Ūkio-buities nuotekos - F1 75
1414676 | 0 a | 1436.09 | -4851.24 | Ūkio-buities nuotekos - F1 75
1414789 | 0 a | 1137.21 | -4973.07 | Ūkio-buities nuotekos - F1 75
1414815 | 0 a | 967.449 | -4788.46 | Ūkio-buities nuotekos - F1 75
1414876 | 0 a | 2508.32 | -5028.27 | Ūkio-buities nuotekos - F1 75
1414952 | 0 a | 1011.03 | -4820.71 | Ūkio-buities nuotekos - F1 75
1414961 | 0 a | 3128.14 | -4947.86 | Ūkio-buities nuotekos - F1 75
1415019 | 2 a | 8592.45 | -5731.01 | Ūkio-buities nuotekos - F1 75
1415097 | 2 a | 8984.71 | -5937.16 | nuotekos ūkio-buities - F1 1
1415248 | 2 a | 454.633 | -4871.32 | nuotekos ūkio-buities - F1 1
1415257 | 2 a | 8181.94 | -4890.45 | nuotekos ūkio-buities - F1 1
1415329 | 0 a | 574.355 | -4858.67 | nuotekos ūkio-buities - F1 1
1415369 | 0 a | 566.797 | -4843.62 | nuotekos ūkio-buities - F1 1
1415383 | 0 a | 578.899 | -4803.87 | nuotekos ūkio-buities - F1 1
1415513 | 0 a | 4.14324 | -4788.52 | nuotekos ūkio-buities - F1 1
1415596 | 0 a | 249.687 | -3320.54 | nuotekos ūkio-buities - F1 1
1415611 | 0 a | 1276.44 | -4691.59 | nuotekos ūkio-buities - F1 1
1415778 | 0 a | 3247.3 | -4840.18 | nuotekos ūkio-buities - F1 1
1415789 | 2 a | 1512.29 | -4904.38 | nuotekos ūkio-buities - F1 1
1415804 | 0 a | 334.641 | -4820.99 | nuotekos ūkio-buities - F1 1
1415853 | 0 a | 654.245 | -4644.3 | nuotekos ūkio-buities - F1 1
1415926 | 2 a | 646.413 | -4920.11 | nuotekos ūkio-buities - F1 1
1415979 | 0 a | 1362.45 | -4777.6 | nuotekos ūkio-buities - F1 1
1416111 | 1 a +-152.84 | 468.761 | -5563.64 | nuotekos ūkio-buities - F1 4
1416141 | 0 a | 7838.09 | -5741.96 | nuotekos ūkio-buities - F1 4
1416273 | 1 a +-152.84 | 8075.44 | -4583.05 | nuotekos ūkio-buities - F1 4
1416296 | 0 a | 1610.35 | -4529.07 | nuotekos ūkio-buities - F1 4
1416308 | 0 a | 191.84 | -4493.09 | nuotekos ūkio-buities - F1 4
1416322 | 0 a | 147.493 | -3320.54 | nuotekos ūkio-buities - F1 4
1416429 | 0 a | 977.254 | -4392.4 | nuotekos ūkio-buities - F1 4
1416531 | 0 a | 180.226 | -4526.48 | nuotekos ūkio-buities - F1 4
1416542 | 0 a | 1815.75 | -4567.84 | nuotekos ūkio-buities - F1 4
1416549 | 0 a | 136.752 | -3320.54 | nuotekos ūkio-buities - F1 4
1416661 | 0 a | 1010.88 | -4426.03 | nuotekos ūkio-buities - F1 4
1416723 | 0 a | 488.383 | -5552.82 | nuotekos ūkio-buities - F1 4
1416738 | 0 a | 572.478 | -5580.79 | nuotekos ūkio-buities - F1 4
1416743 | 0 a | 2775.62 | -5537.35 | nuotekos ūkio-buities - F1 4
1416794 | 0 a | 1305.52 | -5295.57 | nuotekos ūkio-buities - F1 4
1416862 | 0 a | 519.576 | -5496.89 | nuotekos ūkio-buities - F1 4
1416875 | 0 a | 966.701 | -5576.59 | nuotekos ūkio-buities - F1 4
1416888 | 0 a | 355.844 | -5484.67 | nuotekos ūkio-buities - F1 4
1417005 | 0 a | 301.292 | -5529.29 | nuotekos ūkio-buities - F1 4
1417014 | 0 a | 838.442 | -5548.62 | nuotekos ūkio-buities - F1 4
1417052 | 0 a | 1584.71 | -5354.92 | nuotekos ūkio-buities - F1 4
1417086 | 0 a | 1564.71 | -5309.21 | nuotekos ūkio-buities - F1 4
1417230 | 2 a | 539.323 | -5484.72 | Ūkio-buities nuotekos - F1 16
1417251 | 2 a | 911.681 | -4744.28 | Ūkio-buities nuotekos - F1 16
1417260 | 2 a | 8174.92 | -4723.2 | Ūkio-buities nuotekos - F1 16
1417278 | 0 a | 1052.44 | -4720.55 | Ūkio-buities nuotekos - F1 16
1417294 | 0 a | 426.866 | -4616.9 | Ūkio-buities nuotekos - F1 16
1417438 | 0 a | 1453.04 | -4603.96 | Ūkio-buities nuotekos - F1 16
1417454 | 0 a | 414.937 | -4404.99 | Ūkio-buities nuotekos - F1 16
1417693 | 0 a | 921.832 | -4637.91 | Ūkio-buities nuotekos - F1 16
1417704 | 0 a | 1872.05 | -4681.84 | Ūkio-buities nuotekos - F1 16
1417805 | 0 a | 3489.14 | -4613.7 | Ūkio-buities nuotekos - F1 16
1417814 | 0 a | 1045.5 | -4641.11 | Ūkio-buities nuotekos - F1 16
1417821 | 0 a | 2565.69 | -4539.53 | Ūkio-buities nuotekos - F1 16
1417849 | 0 a | 1219.48 | -4725.06 | Ūkio-buities nuotekos - F1 16
1417866 | 2 a | 254.841 | -4752.86 | Ūkio-buities nuotekos - F1 16
1417875 | 0 a | 1763.46 | -4696.27 | Ūkio-buities nuotekos - F1 16
1417891 | 0 a | 458.335 | -4448.39 | Ūkio-buities nuotekos - F1 16
1417918 | 2 a | 6415.69 | -5833.19 | Ūkio-buities nuotekos - F1 16
1418037 | 0 a | 1487.1 | -4769.27 | Ūkio-buities nuotekos - F1 16
1418046 | 0 a | 1337.95 | -4657.7 | Ūkio-buities nuotekos - F1 16
1418082 | 0 a | 745.807 | -4741.76 | Ūkio-buities nuotekos - F1 16
1418119 | 0 a | 177.96 | -4736.93 | Ūkio-buities nuotekos - F1 16
1418152 | 0 a | 206.971 | -4749.67 | Ūkio-buities nuotekos - F1 16
1418396 | 0 a | 568.363 | -4732.05 | Ūkio-buities nuotekos - F1 16
1418407 | 0 a | 3537.08 | -4730.76 | Ūkio-buities nuotekos - F1 16
1418416 | 0 a | 344.407 | -4742.71 | Ūkio-buities nuotekos - F1 16
1418794 | 0 a | 1476.41 | -4659.5 | Ūkio-buities nuotekos - F1 16
1418805 | 0 a | 467.457 | -4627.65 | Ūkio-buities nuotekos - F1 16
1418810 | 0 a | 5366.25 | -4771.21 | Ūkio-buities nuotekos - F1 16
1418837 | 0 a | 8092.9 | -5160.82 | Ūkio-buities nuotekos - F1 75
1418846 | 0 a | 1019.57 | -5047.92 | Ūkio-buities nuotekos - F1 75
1418869 | 0 a | 1631.59 | -5197.22 | Ūkio-buities nuotekos - F1 75
1418989 | 0 a | 244.387 | -5205.89 | Ūkio-buities nuotekos - F1 75
1419044 | 4 a V1 | 1374.38 | -5323.06 | Ūkio-buities nuotekos - F1 1
1419218 | 2 a | 17368.7 | -5579.42 | Ūkio-buities nuotekos - F1 87
1419328 | 4 a V1 | 10786.9 | -5511.66 | Ūkio-buities nuotekos - F1 6
1419468 | 2 a | 18556.4 | -5249.39 | Ūkio-buities nuotekos - F1 69
1419560 | 4 a V1 | 1785.75 | -5710.96 | Ūkio-buities nuotekos - F1 12
1497543 | 1 a +-152.84 | 16900 | -5501.38 | Ūkio-buities nuotekos - F1 84
1497712 | 5 a V1 | 10045.3 | -520.864 | L1 1
1498250 | 5 a V1 | 558.548 | 3294.22 | L1 2
1498266 | 5 a V1 | 939.374 | 3585.22 | L1 2
1498307 | 5 a V1 | 7616.92 | -4493.35 | L1 2
1498315 | 5 a V1 | 4308.28 | -4938.12 | L1 2
1498474 | 5 a V1 | 558.548 | 3294.22 | L1 3
1498482 | 5 a V1 | 939.374 | 3585.22 | L1 3
1498490 | 5 a V1 | 7616.92 | -4493.35 | L1 3
1498492 | 5 a V1 | 4308.28 | -4938.12 | L1 3
1498701 | 5 a V1 | 537.188 | -4827.01 | Lietaus nuotekos - L1 10
1498737 | 0 a | 462.131 | -4843.53 | Lietaus nuotekos - L1 10
1498759 | 0 a | 2315.38 | -5390.51 | Lietaus nuotekos - L1 10
1498853 | 5 a V1 | 4756.95 | -4358.4 | Lietaus nuotekos - L1 10
1498989 | 5 a V1 | 566.207 | -5002.48 | Lietaus nuotekos - L1 10
1499004 | 0 a | 6822.84 | -5338.05 | Lietaus nuotekos - L1 10
1499044 | 5 a V1 | 284.168 | -5008.78 | Lietaus nuotekos - L1 10
1499047 | 0 a | 7918.3 | -5009.15 | Lietaus nuotekos - L1 10
1499086 | 5 a V1 | 284.168 | -5195.1 | Lietaus nuotekos - L1 10
1499089 | 0 a | 9009.9 | -5195.47 | Lietaus nuotekos - L1 10
1499191 | 0 a | 3263.12 | -895.011 | Lietaus nuotekos - L1 11
1499300 | 1 a +-152.84 | 648.51 | -909.553 | Lietaus nuotekos - L1 11
1500675 | 0 a | 14962.2 | -1214.39 | Lietaus nuotekos - L1 11
1500748 | 0 a | 744.266 | -909.05 | Lietaus nuotekos - L1 11
1501773 | 0 a | 236.588 | -4974.67 | Ūkio-buities nuotekos - F1 84
1501834 | 0 a | 22826.4 | -4966.35 | Ūkio-buities nuotekos - F1 84
1502245 | 2 a | 397.466 | -5227.67 | Ūkio-buities nuotekos - F1 87
1502250 | 0 a | 33.4903 | -5223.47 | Ūkio-buities nuotekos - F1 87
1502313 | 0 a | 14106.7 | -5217.1 | Ūkio-buities nuotekos - F1 87
1502474 | 0 a | 151.166 | -4927.53 | Ūkio-buities nuotekos - F1 87
1502858 | 0 a | 667.56 | -933.827 | Lietaus nuotekos - L1 13
1502898 | 0 a | 23.3959 | -1099.78 | Lietaus nuotekos - L1 13
1502901 | 0 a | 8761.19 | -1435.35 | Lietaus nuotekos - L1 13
1503283 | 4 a V1 | 3799.21 | -1585.66 | Ūkio-buities nuotekos - F1 17
1503331 | 0 a | 354.884 | -1595.12 | Ūkio-buities nuotekos - F1 17
1503349 | 0 a | 3555.23 | -1668.57 | Ūkio-buities nuotekos - F1 17
1503530 | 5 a V1 | 12084.2 | -2559.84 | L1 4
1503538 | 5 a V1 | 3420.09 | -2986.85 | L1 4
1503653 | 0 a | 3429.3 | -5492.8 | nuotekos ūkio-buities - F1 4
1503662 | 0 a | 2318.36 | -5533.38 | nuotekos ūkio-buities - F1 4
1503675 | 0 a | 831.199 | -5455.28 | nuotekos ūkio-buities - F1 4
1504068 | 0 a | 8215.13 | -5834.25 | Ūkio-buities nuotekos - F1 16
1504098 | 0 a | 2231.49 | -5664.28 | Ūkio-buities nuotekos - F1 16
1504138 | 2 a | 16285.5 | -5147.66 | Ūkio-buities nuotekos - F1 81
1506125 | 0 a | 277.369 | -5348.46 | Ūkio-buities nuotekos - F1 12
1506134 | 4 a V1 | 578.219 | -5348.53 | Ūkio-buities nuotekos - F1 12
1506163 | 0 a | 14201.1 | -5326.3 | Ūkio-buities nuotekos - F1 12
1506187 | 0 a | 1495.61 | -5036.63 | Ūkio-buities nuotekos - F1 12
1506201 | 0 a | 84.2105 | -5001.02 | Ūkio-buities nuotekos - F1 12
1506578 | 2 a | 391.361 | 3912.62 | Ūkio-buities nuotekos - F1 17
1506603 | 2 a | 529.228 | 3868.09 | Ūkio-buities nuotekos - F1 17
1506612 | 2 a | 5869.85 | 3924.23 | Ūkio-buities nuotekos - F1 17
1506626 | 2 a | 1127.16 | 4045.37 | Ūkio-buities nuotekos - F1 17
1506640 | 2 a | 400.08 | 4067.91 | F1 1
1855995 | 5 a V1 | 1353.53 | 17528.3 | Ūkio-buities nuotekos - F1 10
1856006 | 4 a V1 | 23.7824 | 17558.7 | Ūkio-buities nuotekos - F1 10
1856013 | 5 a V1 | 224.979 | 17518.1 | Ūkio-buities nuotekos - F1 10
1856027 | 5 a V1 | 1251.01 | 17487.3 | Ūkio-buities nuotekos - F1 10
1856409 | 5 a V1 | 89.615 | 17552.9 | Ūkio-buities nuotekos - F1 10
1856582 | 5 a V1 | 213.184 | 17593.2 | F1 4
1856598 | 5 a V1 | 1414.14 | 17601.2 | F1 4
1856651 | 5 a V1 | 4685.28 | 17633.3 | F1 4
1856841 | 5 a V1 | 3233.43 | 17410.6 | Ūkio-buities nuotekos - F1 5
1856850 | 5 a V1 | 2514.78 | 17326.6 | Ūkio-buities nuotekos - F1 5
1856857 | 5 a V1 | 1884.72 | 17479 | Ūkio-buities nuotekos - F1 5
1856902 | 5 a V1 | 1661.85 | 17413.2 | Ūkio-buities nuotekos - F1 5
1856915 | 5 a V1 | 1311.36 | 17381.9 | Ūkio-buities nuotekos - F1 5
1857382 | 5 a V1 | 46.8099 | 17337.1 | K1 4
1857383 | 5 a V1 | 52.1476 | 17296.6 | K1 4
1857457 | 5 a V1 | 46.8099 | 17366.1 | K1 4
1857458 | 5 a V1 | 83.6239 | 17303.5 | K1 4
1857558 | 5 a V1 | 27.5442 | 17474.2 | K1 4
1857571 | 5 a V1 | 2384.81 | 17592.5 | K1 4
1857660 | 5 a V1 | 224.383 | 17686.2 | K1 1
1858412 | 4 a V1 | 152.032 | -4699.07 | Ūkio-buities nuotekos - F1 1
1858413 | 4 a V1 | 389.951 | -4473.63 | Ūkio-buities nuotekos - F1 1
1858417 | 4 a V1 | 4942.11 | -4942.19 | Ūkio-buities nuotekos - F1 1
1859539 | 4 a V1 | 145.673 | -5670.82 | Ūkio-buities nuotekos - F1 12
1859544 | 4 a V1 | 15880.1 | -5670.81 | Ūkio-buities nuotekos - F1 12
1859644 | 4 a V1 | 17228.6 | -5291.14 | Ūkio-buities nuotekos - F1 1
1862249 | 2 a | 93.43 | -4869.69 | Ūkio-buities nuotekos - F1 69
1862254 | 2 a | 8911.31 | -4873.89 | Ūkio-buities nuotekos - F1 69
1868036 | 4 a V1 | 1057.22 | -745.445 | Ūkio-buities nuotekos - F1 5

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipes
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Wavin Tigris Single Pipe (OD) - Standard; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00254 mm
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1102731 | 0 a | 6121.11 | -970 | vanduo šaltas - V1 2
1114239 | 0 a | 4318 | -889 | vanduo šaltas - V1 2
1114372 | 1 a +-152.84 | 4559.04 | 12522 | vanduo šaltas - V1 2
1114402 | 0 a | 4638 | -889 | vanduo šaltas - V1 2
1118351 | 0 a | 1644.74 | -970 | vanduo šaltas - V1 2
1328765 | 2 a | 198 | 3531 | vanduo šaltas - V1 2
1328778 | 0 a | 5893.53 | 3450 | vanduo šaltas - V1 2
1328900 | 0 a | 3678 | -889 | vanduo šaltas - V1 2
1328911 | 0 a | 1049 | -970 | vanduo šaltas - V1 2
1328942 | 0 a | 3514.77 | -970 | vanduo šaltas - V1 2
1329590 | 0 a | 218 | 2810 | vanduo šaltas - V1 2
1329600 | 0 a | 838.001 | 2890.96 | vanduo šaltas - V1 2
1329948 | 1 a +-152.84 | 5130.93 | 3750 | vanduo šaltas - V1 2
1330137 | 1 a +-152.84 | 415.853 | 3750 | vanduo šaltas - V1 2
1330185 | 1 a +-152.84 | 236.648 | 8064.35 | vanduo šaltas - V1 2
1330229 | 1 a +-152.84 | 180.618 | 3750 | vanduo šaltas - V1 2
1330304 | 1 a +-152.84 | 3672 | 8319.5 | vanduo šaltas - V1 2
1330444 | 3 a | 1580.98 | 8319.5 | vanduo šaltas - V1 2
1330513 | 3 a | 4679.99 | 12809 | vanduo šaltas - V1 2
1330732 | 4 a V1 | 238 | 17532.3 | vanduo šaltas - V1 2
1330821 | 4 a V1 | 139.029 | 17532.3 | vanduo šaltas - V1 2
1331000 | 4 a V1 | 145 | 17532.3 | vanduo šaltas - V1 2
1331051 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1331101 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1331123 | 4 a V1 | 170 | 17532.3 | vanduo šaltas - V1 2
1331175 | 3 a | 236.309 | 17524 | vanduo šaltas - V1 2
1331205 | 3 a | 227.818 | 17524 | vanduo šaltas - V1 2
1331209 | 4 a V1 | 160 | 17532.3 | vanduo šaltas - V1 2
1331219 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1331276 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1331324 | 4 a V1 | 100.971 | 17532.3 | vanduo šaltas - V1 2
1331327 | 4 a V1 | 180 | 17532.3 | vanduo šaltas - V1 2
1331333 | 4 a V1 | 159.029 | 14442.3 | vanduo šaltas - V1 2
1331367 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1331427 | 4 a V1 | 635.14 | 17530 | vanduo šaltas - V1 2
1331500 | 3 a | 4928.69 | 17524 | vanduo šaltas - V1 2
1331503 | 4 a V1 | 209.726 | 17532.3 | vanduo šaltas - V1 2
1331562 | 4 a V1 | 200 | 14442.3 | vanduo šaltas - V1 2
1331592 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1331614 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1331623 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1331626 | 4 a V1 | 307.857 | 17532.3 | vanduo šaltas - V1 2
1331655 | 4 a V1 | 115 | 14442.3 | vanduo šaltas - V1 2
1331670 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1331673 | 4 a V1 | 361.417 | 17532.3 | vanduo šaltas - V1 2
1331694 | 4 a V1 | 1138 | 17532.3 | vanduo šaltas - V1 2
1331730 | 4 a V1 | 1701.71 | 17530 | vanduo šaltas - V1 2
1331733 | 4 a V1 | 178.686 | 14642.3 | vanduo šaltas - V1 2
1331760 | 4 a V1 | 2850 | 14670 | vanduo šaltas - V1 2
1331794 | 4 a V1 | 1078 | 17532.3 | vanduo šaltas - V1 2
1331803 | 4 a V1 | 499.508 | 17530 | vanduo šaltas - V1 2
1331806 | 4 a V1 | 100 | 14142.3 | vanduo šaltas - V1 2
1331861 | 4 a V1 | 3350 | 14170 | vanduo šaltas - V1 2
1331949 | 4 a V1 | 1121.76 | 17532.3 | vanduo šaltas - V1 2
1331962 | 3 a | 367.689 | 17524 | vanduo šaltas - V1 2
1331965 | 4 a V1 | 200 | 14442.3 | vanduo šaltas - V1 2
1332060 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1332083 | 4 a V1 | 93.2627 | 17532.3 | vanduo šaltas - V1 2
1332092 | 4 a V1 | 888.245 | 17532.3 | vanduo šaltas - V1 2
1332104 | 4 a V1 | 80 | 14242.3 | vanduo šaltas - V1 2
1332113 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1332152 | 4 a V1 | 40 | 17532.3 | vanduo šaltas - V1 2
1332159 | 4 a V1 | 966.737 | 17532.3 | vanduo šaltas - V1 2
1332162 | 4 a V1 | 120 | 17532.3 | vanduo šaltas - V1 2
1332172 | 4 a V1 | 80 | 14242.3 | vanduo šaltas - V1 2
1332231 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1332255 | 4 a V1 | 231 | 17532.3 | vanduo šaltas - V1 2
1332279 | 3 a | 909.701 | 17524 | vanduo šaltas - V1 2
1332303 | 4 a V1 | 90 | 14242.3 | vanduo šaltas - V1 2
1332312 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1332339 | 4 a V1 | 20 | 14242.3 | vanduo šaltas - V1 2
1332346 | 4 a V1 | 90 | 14242.3 | vanduo šaltas - V1 2
1332349 | 4 a V1 | 340 | 14242.3 | vanduo šaltas - V1 2
1332377 | 4 a V1 | 2050 | 17532.3 | vanduo šaltas - V1 2
1332390 | 3 a | 101.174 | 17524 | vanduo šaltas - V1 2
1332393 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1332423 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1332476 | 4 a V1 | 128.379 | 17532.3 | vanduo šaltas - V1 2
1332487 | 3 a | 699.906 | 17524 | vanduo šaltas - V1 2
1332490 | 4 a V1 | 120 | 14242.3 | vanduo šaltas - V1 2
1332517 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1332543 | 4 a V1 | 100 | 17532.3 | vanduo šaltas - V1 2
1332552 | 4 a V1 | 1261.62 | 17532.3 | vanduo šaltas - V1 2
1332555 | 4 a V1 | 909.033 | 17532.3 | vanduo šaltas - V1 2
1332581 | 4 a V1 | 260 | 14242.3 | vanduo šaltas - V1 2
1332615 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1332635 | 4 a V1 | 2770 | 17532.3 | vanduo šaltas - V1 2
1332654 | 3 a | 339.71 | 17524 | vanduo šaltas - V1 2
1332657 | 4 a V1 | 160 | 14442.3 | vanduo šaltas - V1 2
1332693 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1332781 | 2 a | 612.765 | 3759.5 | vanduo šaltas - V1 2
1332850 | 2 a | 417.953 | 12431 | vanduo šaltas - V1 2
1333396 | 2 a | 5810.43 | 12884 | vanduo šaltas - V1 2
1333486 | 2 a | 4582 | 12929 | vanduo šaltas - V1 2
1333508 | 2 a | 164.138 | 17524 | vanduo šaltas - V1 2
1333596 | 4 a V1 | 2733.97 | 12887 | vanduo šaltas - V1 2
1333666 | 2 a | 457.565 | 12884 | vanduo šaltas - V1 2
1333719 | 4 a V1 | 2494 | 12892.3 | vanduo šaltas - V1 2
1333755 | 4 a V1 | 5297.03 | 12887 | vanduo šaltas - V1 2
1333758 | 4 a V1 | 154.672 | 14442.3 | vanduo šaltas - V1 2
1333787 | 4 a V1 | 1509.99 | 12920 | vanduo šaltas - V1 2
1333838 | 4 a V1 | 120 | 12892.3 | vanduo šaltas - V1 2
1333849 | 4 a V1 | 1112.71 | 12892.3 | vanduo šaltas - V1 2
1333852 | 4 a V1 | 173.132 | 14242.3 | vanduo šaltas - V1 2
1333888 | 4 a V1 | 1309.99 | 12920 | vanduo šaltas - V1 2
1333933 | 4 a V1 | 85 | 12892.3 | vanduo šaltas - V1 2
1333942 | 4 a V1 | 738.566 | 12892.3 | vanduo šaltas - V1 2
1333945 | 4 a V1 | 148.132 | 14242.3 | vanduo šaltas - V1 2
1333971 | 4 a V1 | 1309.99 | 12920 | vanduo šaltas - V1 2
1334036 | 4 a V1 | 999.872 | 17527 | vanduo šaltas - V1 2
1334082 | 4 a V1 | 1522.26 | 17532.3 | vanduo šaltas - V1 2
1334126 | 4 a V1 | 70 | 14242.3 | vanduo šaltas - V1 2
1334165 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1334208 | 4 a V1 | 660 | 17532.3 | vanduo šaltas - V1 2
1334219 | 4 a V1 | 250.58 | 17532.3 | vanduo šaltas - V1 2
1334516 | 4 a V1 | 100 | 14242.3 | vanduo šaltas - V1 2
1334525 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1334548 | 4 a V1 | 154.285 | 17532.3 | vanduo šaltas - V1 2
1334557 | 4 a V1 | 77.1584 | 17532.3 | vanduo šaltas - V1 2
1334560 | 4 a V1 | 80 | 14242.3 | vanduo šaltas - V1 2
1334601 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1334623 | 4 a V1 | 502.178 | 17532.3 | vanduo šaltas - V1 2
1334632 | 4 a V1 | 1560.14 | 17527 | vanduo šaltas - V1 2
1334635 | 4 a V1 | 460 | 17532.3 | vanduo šaltas - V1 2
1334643 | 4 a V1 | 140 | 14642.3 | vanduo šaltas - V1 2
1334685 | 4 a V1 | 2850 | 14670 | vanduo šaltas - V1 2
1334726 | 4 a V1 | 700 | 17532.3 | vanduo šaltas - V1 2
1334735 | 4 a V1 | 1411.82 | 17532.3 | vanduo šaltas - V1 2
1334738 | 4 a V1 | 200 | 17532.3 | vanduo šaltas - V1 2
1334751 | 4 a V1 | 80 | 14642.3 | vanduo šaltas - V1 2
1334787 | 4 a V1 | 2850 | 14670 | vanduo šaltas - V1 2
1334809 | 4 a V1 | 1590.77 | 17532.3 | vanduo šaltas - V1 2
1334818 | 4 a V1 | 377.731 | 17527 | vanduo šaltas - V1 2
1334821 | 4 a V1 | 140 | 14242.3 | vanduo šaltas - V1 2
1334851 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1334885 | 4 a V1 | 360 | 17532.3 | vanduo šaltas - V1 2
1334894 | 4 a V1 | 155.791 | 17532.3 | vanduo šaltas - V1 2
1334897 | 4 a V1 | 80 | 14242.3 | vanduo šaltas - V1 2
1334936 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335183 | 4 a V1 | 420 | 17532.3 | vanduo šaltas - V1 2
1335190 | 4 a V1 | 167.434 | 17532.3 | vanduo šaltas - V1 2
1335193 | 4 a V1 | 60 | 14242.3 | vanduo šaltas - V1 2
1335230 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335256 | 4 a V1 | 164 | 17532.3 | vanduo šaltas - V1 2
1335265 | 4 a V1 | 4031.3 | 17527 | vanduo šaltas - V1 2
1335268 | 4 a V1 | 90 | 14242.3 | vanduo šaltas - V1 2
1335313 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335334 | 4 a V1 | 1608.41 | 17532.3 | vanduo šaltas - V1 2
1335345 | 4 a V1 | 1215.24 | 17527 | vanduo šaltas - V1 2
1335348 | 4 a V1 | 180 | 14242.3 | vanduo šaltas - V1 2
1335389 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335417 | 4 a V1 | 700 | 17532.3 | vanduo šaltas - V1 2
1335426 | 4 a V1 | 202.065 | 17532.3 | vanduo šaltas - V1 2
1335429 | 4 a V1 | 120 | 14242.3 | vanduo šaltas - V1 2
1335467 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335488 | 4 a V1 | 760 | 17532.3 | vanduo šaltas - V1 2
1335497 | 4 a V1 | 123.527 | 17532.3 | vanduo šaltas - V1 2
1335500 | 4 a V1 | 80 | 14242.3 | vanduo šaltas - V1 2
1335539 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335563 | 4 a V1 | 174 | 17532.3 | vanduo šaltas - V1 2
1335572 | 4 a V1 | 469.71 | 17527 | vanduo šaltas - V1 2
1335575 | 4 a V1 | 89.0536 | 14242.3 | vanduo šaltas - V1 2
1335623 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335646 | 4 a V1 | 80 | 17532.3 | vanduo šaltas - V1 2
1335655 | 4 a V1 | 1356.69 | 17527 | vanduo šaltas - V1 2
1335658 | 4 a V1 | 680 | 17532.3 | vanduo šaltas - V1 2
1335669 | 4 a V1 | 100 | 14642.3 | vanduo šaltas - V1 2
1335704 | 4 a V1 | 2850 | 14670 | vanduo šaltas - V1 2
1335738 | 4 a V1 | 61.8618 | 17532.3 | vanduo šaltas - V1 2
1335749 | 4 a V1 | 1834 | 17532.3 | vanduo šaltas - V1 2
1335752 | 4 a V1 | 80 | 17532.3 | vanduo šaltas - V1 2
1335765 | 4 a V1 | 130 | 14642.3 | vanduo šaltas - V1 2
1335835 | 4 a V1 | 2850 | 14670 | vanduo šaltas - V1 2
1335857 | 4 a V1 | 370 | 17532.3 | vanduo šaltas - V1 2
1335868 | 2 a | 181.223 | 17524 | vanduo šaltas - V1 2
1335871 | 4 a V1 | 180 | 17532.3 | vanduo šaltas - V1 2
1335881 | 4 a V1 | 100 | 14242.3 | vanduo šaltas - V1 2
1335912 | 4 a V1 | 3250 | 14270 | vanduo šaltas - V1 2
1335934 | 4 a V1 | 150 | 17532.3 | vanduo šaltas - V1 2
1335943 | 2 a | 162.688 | 17524 | vanduo šaltas - V1 2
1335946 | 4 a V1 | 65 | 14442.3 | vanduo šaltas - V1 2
1335995 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1336020 | 4 a V1 | 190 | 17532.3 | vanduo šaltas - V1 2
1336031 | 2 a | 1310.95 | 17524 | vanduo šaltas - V1 2
1336043 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1336052 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1336081 | 4 a V1 | 74 | 17532.3 | vanduo šaltas - V1 2
1336090 | 4 a V1 | 104.318 | 17527 | vanduo šaltas - V1 2
1336093 | 4 a V1 | 280 | 17532.3 | vanduo šaltas - V1 2
1336101 | 4 a V1 | 50 | 17532.3 | vanduo šaltas - V1 2
1336120 | 4 a V1 | 85 | 14442.3 | vanduo šaltas - V1 2
1336137 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1336179 | 2 a | 281.072 | 3750 | vanduo šaltas - V1 2
1336187 | 2 a | 286 | 3750 | vanduo šaltas - V1 2
1336223 | 2 a | 4834.37 | 12698.6 | vanduo šaltas - V1 2
1336403 | 4 a V1 | 2873.34 | 17570 | vanduo šaltas - V1 2
1336436 | 4 a V1 | 1727.67 | 17567 | vanduo šaltas - V1 2
1336460 | 4 a V1 | 10107.9 | 17567 | vanduo šaltas - V1 2
1336542 | 4 a V1 | 479 | 17572.3 | vanduo šaltas - V1 2
1336556 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1336592 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1336613 | 4 a V1 | 998 | 17572.3 | vanduo šaltas - V1 2
1336624 | 4 a V1 | 3633.23 | 17570 | vanduo šaltas - V1 2
1336627 | 4 a V1 | 120 | 17572.3 | vanduo šaltas - V1 2
1336638 | 4 a V1 | 180 | 14442.3 | vanduo šaltas - V1 2
1336681 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1336705 | 4 a V1 | 978 | 17572.3 | vanduo šaltas - V1 2
1336714 | 4 a V1 | 3439.05 | 17570 | vanduo šaltas - V1 2
1336717 | 4 a V1 | 240 | 17572.3 | vanduo šaltas - V1 2
1336725 | 4 a V1 | 160 | 14442.3 | vanduo šaltas - V1 2
1336756 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1336780 | 4 a V1 | 998 | 17572.3 | vanduo šaltas - V1 2
1336789 | 4 a V1 | 3441.23 | 17570 | vanduo šaltas - V1 2
1336792 | 4 a V1 | 180 | 17572.3 | vanduo šaltas - V1 2
1336806 | 4 a V1 | 120 | 13792.3 | vanduo šaltas - V1 2
1336862 | 4 a V1 | 3740 | 13820 | vanduo šaltas - V1 2
1336885 | 4 a V1 | 558 | 17572.3 | vanduo šaltas - V1 2
1336894 | 4 a V1 | 459.158 | 17570 | vanduo šaltas - V1 2
1336897 | 4 a V1 | 3511.94 | 17572.3 | vanduo šaltas - V1 2
1336905 | 4 a V1 | 36.6591 | 17572.3 | vanduo šaltas - V1 2
1336923 | 4 a V1 | 95 | 13792.3 | vanduo šaltas - V1 2
1336973 | 4 a V1 | 3740 | 13820 | vanduo šaltas - V1 2
1337174 | 4 a V1 | 5 | 17572.3 | vanduo šaltas - V1 2
1337181 | 4 a V1 | 68.3409 | 17572.3 | vanduo šaltas - V1 2
1337184 | 4 a V1 | 255 | 17572.3 | vanduo šaltas - V1 2
1337197 | 4 a V1 | 65.4859 | 14442.3 | vanduo šaltas - V1 2
1337236 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337259 | 4 a V1 | 79 | 17572.3 | vanduo šaltas - V1 2
1337270 | 4 a V1 | 85.1264 | 17567 | vanduo šaltas - V1 2
1337273 | 4 a V1 | 200 | 14442.3 | vanduo šaltas - V1 2
1337312 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337338 | 4 a V1 | 1736.46 | 17570 | vanduo šaltas - V1 2
1337395 | 4 a V1 | 5855.53 | 17567 | vanduo šaltas - V1 2
1337398 | 4 a V1 | 1899 | 17572.3 | vanduo šaltas - V1 2
1337429 | 4 a V1 | 2800 | 17572.3 | vanduo šaltas - V1 2
1337437 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1337466 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337487 | 4 a V1 | 538 | 17572.3 | vanduo šaltas - V1 2
1337496 | 4 a V1 | 1498.68 | 17570 | vanduo šaltas - V1 2
1337499 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1337536 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337564 | 4 a V1 | 538 | 17572.3 | vanduo šaltas - V1 2
1337573 | 4 a V1 | 756.856 | 17570 | vanduo šaltas - V1 2
1337576 | 4 a V1 | 87.0636 | 14242.3 | vanduo šaltas - V1 2
1337615 | 4 a V1 | 3290 | 14270 | vanduo šaltas - V1 2
1337663 | 4 a V1 | 96.9591 | 17572.3 | vanduo šaltas - V1 2
1337676 | 4 a V1 | 80 | 17572.3 | vanduo šaltas - V1 2
1337686 | 4 a V1 | 80.6436 | 14442.3 | vanduo šaltas - V1 2
1337725 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337754 | 4 a V1 | 110 | 17572.3 | vanduo šaltas - V1 2
1337765 | 4 a V1 | 91.8067 | 17572.3 | vanduo šaltas - V1 2
1337784 | 4 a V1 | 30 | 17572.3 | vanduo šaltas - V1 2
1337794 | 4 a V1 | 75 | 14442.3 | vanduo šaltas - V1 2
1337835 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337864 | 4 a V1 | 420 | 17572.3 | vanduo šaltas - V1 2
1337873 | 4 a V1 | 481.234 | 17572.3 | vanduo šaltas - V1 2
1337876 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1337928 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1337949 | 4 a V1 | 74 | 17572.3 | vanduo šaltas - V1 2
1337960 | 4 a V1 | 72.6361 | 17567 | vanduo šaltas - V1 2
1337963 | 4 a V1 | 140 | 14242.3 | vanduo šaltas - V1 2
1338005 | 4 a V1 | 3290 | 14270 | vanduo šaltas - V1 2
1338034 | 4 a V1 | 334 | 17572.3 | vanduo šaltas - V1 2
1338049 | 4 a V1 | 172.248 | 17567 | vanduo šaltas - V1 2
1338052 | 4 a V1 | 252.636 | 14642.3 | vanduo šaltas - V1 2
1338086 | 4 a V1 | 2890 | 14670 | vanduo šaltas - V1 2
1338111 | 4 a V1 | 165.072 | 17572.3 | vanduo šaltas - V1 2
1338124 | 4 a V1 | 3530.55 | 17567 | vanduo šaltas - V1 2
1338127 | 4 a V1 | 160 | 14442.3 | vanduo šaltas - V1 2
1338185 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1338223 | 1 a +-152.84 | 8144.66 | 3750 | vanduo šaltas - V1 2
1338227 | 2 a | 198 | 3531 | vanduo šaltas - V1 2
1338230 | 0 a | 3650.58 | 3450 | vanduo šaltas - V1 2
1338238 | 1 a +-152.84 | 524.232 | 3750 | vanduo šaltas - V1 2
1338319 | 2 a | 2273.25 | 3750 | vanduo šaltas - V1 2
1338705 | 2 a | 2378.78 | 3750 | vanduo šaltas - V1 2
1338717 | 2 a | 3990.18 | 17670.8 | vanduo šaltas - V1 2
1338779 | 2 a | 722 | 21679.5 | vanduo šaltas - V1 2
1338854 | 5 a V1 | 220.536 | 21684 | vanduo šaltas - V1 2
1338870 | 5 a V1 | 3560 | 21692.3 | vanduo šaltas - V1 2
1338908 | 5 a V1 | 140 | 18942.3 | vanduo šaltas - V1 2
1338962 | 5 a V1 | 2710 | 18970 | vanduo šaltas - V1 2
1338983 | 5 a V1 | 5880.9 | 21690 | vanduo šaltas - V1 2
1339045 | 5 a V1 | 5477.47 | 21684 | vanduo šaltas - V1 2
1339050 | 5 a V1 | 159 | 21692.3 | vanduo šaltas - V1 2
1339079 | 5 a V1 | 100 | 18942.3 | vanduo šaltas - V1 2
1339113 | 5 a V1 | 2710 | 18970 | vanduo šaltas - V1 2
1339140 | 5 a V1 | 275 | 21690 | vanduo šaltas - V1 2
1339164 | 5 a V1 | 8841.1 | 21690 | vanduo šaltas - V1 2
1339167 | 5 a V1 | 19 | 21692.3 | vanduo šaltas - V1 2
1339208 | 5 a V1 | 160 | 18942.3 | vanduo šaltas - V1 2
1339245 | 5 a V1 | 2710 | 18970 | vanduo šaltas - V1 2
1339289 | 5 a V1 | 6299.34 | 21690 | vanduo šaltas - V1 2
1339300 | 5 a V1 | 6965 | 21684 | vanduo šaltas - V1 2
1339305 | 5 a V1 | 1038.03 | 21690 | vanduo šaltas - V1 2
1339315 | 5 a V1 | 119 | 21692.3 | vanduo šaltas - V1 2
1339339 | 5 a V1 | 180 | 18942.3 | vanduo šaltas - V1 2
1339431 | 5 a V1 | 2710 | 18970 | vanduo šaltas - V1 2
1339453 | 5 a V1 | 138 | 21692.3 | vanduo šaltas - V1 2
1339462 | 5 a V1 | 810.255 | 21690 | vanduo šaltas - V1 2
1339465 | 5 a V1 | 170.863 | 18942.3 | vanduo šaltas - V1 2
1339543 | 5 a V1 | 2710 | 18970 | vanduo šaltas - V1 2
1339565 | 5 a V1 | 260 | 18742.3 | vanduo šaltas - V1 2
1339574 | 5 a V1 | 2908 | 18770 | vanduo šaltas - V1 2
1339577 | 5 a V1 | 627.714 | 21690 | vanduo šaltas - V1 2
1339596 | 5 a V1 | 2818 | 21692.3 | vanduo šaltas - V1 2
1339609 | 5 a V1 | 3368.66 | 21690 | vanduo šaltas - V1 2
1339612 | 5 a V1 | 240 | 21692.3 | vanduo šaltas - V1 2
1339622 | 5 a V1 | 160 | 18942.3 | vanduo šaltas - V1 2
1339661 | 5 a V1 | 2710 | 18970 | vanduo šaltas - V1 2
1339747 | 2 a | 1509.06 | 17623.8 | vanduo šaltas - V1 2
1339796 | 2 a | 4845.34 | 12757.5 | vanduo šaltas - V1 2
1339818 | 4 a V1 | 1000 | 17629.1 | vanduo šaltas - V1 2
1339832 | 4 a V1 | 1080 | 17629.1 | vanduo šaltas - V1 2
1339840 | 4 a V1 | 192.472 | 14442.3 | vanduo šaltas - V1 2
1339866 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1339896 | 4 a V1 | 131.5 | 17629.1 | vanduo šaltas - V1 2
1339905 | 2 a | 535.369 | 17623.8 | vanduo šaltas - V1 2
1339908 | 4 a V1 | 32.5 | 14242.3 | vanduo šaltas - V1 2
1339954 | 4 a V1 | 3346.82 | 14270 | vanduo šaltas - V1 2
1340281 | 4 a V1 | 459 | 17629.1 | vanduo šaltas - V1 2
1340292 | 2 a | 162.193 | 17623.8 | vanduo šaltas - V1 2
1340295 | 4 a V1 | 80 | 14242.3 | vanduo šaltas - V1 2
1340342 | 4 a V1 | 3346.82 | 14270 | vanduo šaltas - V1 2
1340363 | 4 a V1 | 254 | 17629.1 | vanduo šaltas - V1 2
1340372 | 2 a | 690.87 | 17623.8 | vanduo šaltas - V1 2
1340375 | 4 a V1 | 60 | 14242.3 | vanduo šaltas - V1 2
1340410 | 4 a V1 | 3346.82 | 14270 | vanduo šaltas - V1 2
1340432 | 4 a V1 | 234 | 17629.1 | vanduo šaltas - V1 2
1340441 | 2 a | 766.263 | 17623.8 | vanduo šaltas - V1 2
1340444 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1340480 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1340501 | 4 a V1 | 322.638 | 17626.8 | vanduo šaltas - V1 2
1340510 | 2 a | 7422.09 | 17623.8 | vanduo šaltas - V1 2
1340513 | 4 a V1 | 220.097 | 17626.8 | vanduo šaltas - V1 2
1340525 | 4 a V1 | 119 | 17629.1 | vanduo šaltas - V1 2
1340545 | 4 a V1 | 120 | 17629.1 | vanduo šaltas - V1 2
1340653 | 4 a V1 | 240 | 17629.1 | vanduo šaltas - V1 2
1340663 | 4 a V1 | 101.151 | 14442.3 | vanduo šaltas - V1 2
1340703 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1340722 | 4 a V1 | 249.935 | 17629.1 | vanduo šaltas - V1 2
1340731 | 4 a V1 | 199.145 | 17626.8 | vanduo šaltas - V1 2
1340734 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1340770 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1340793 | 4 a V1 | 249.935 | 17629.1 | vanduo šaltas - V1 2
1340802 | 4 a V1 | 1876.76 | 17626.8 | vanduo šaltas - V1 2
1340805 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1340845 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1340872 | 4 a V1 | 83 | 17629.1 | vanduo šaltas - V1 2
1340881 | 4 a V1 | 618.645 | 17626.8 | vanduo šaltas - V1 2
1340884 | 4 a V1 | 110 | 14242.3 | vanduo šaltas - V1 2
1340918 | 4 a V1 | 3346.82 | 14270 | vanduo šaltas - V1 2
1340944 | 4 a V1 | 78 | 17629.1 | vanduo šaltas - V1 2
1340955 | 4 a V1 | 2470.72 | 17626.8 | vanduo šaltas - V1 2
1340958 | 4 a V1 | 60 | 14642.3 | vanduo šaltas - V1 2
1340991 | 4 a V1 | 2946.82 | 14670 | vanduo šaltas - V1 2
1341012 | 4 a V1 | 426.248 | 17626.8 | vanduo šaltas - V1 2
1341021 | 2 a | 123.23 | 17623.8 | vanduo šaltas - V1 2
1341024 | 4 a V1 | 3516 | 17626.8 | vanduo šaltas - V1 2
1341034 | 4 a V1 | 365.514 | 17626.8 | vanduo šaltas - V1 2
1341044 | 4 a V1 | 1419 | 17629.1 | vanduo šaltas - V1 2
1341064 | 4 a V1 | 180 | 17629.1 | vanduo šaltas - V1 2
1341074 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1341136 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1341173 | 4 a V1 | 378 | 17629.1 | vanduo šaltas - V1 2
1341188 | 4 a V1 | 541.462 | 17626.8 | vanduo šaltas - V1 2
1341191 | 4 a V1 | 60 | 14242.3 | vanduo šaltas - V1 2
1341226 | 4 a V1 | 3346.82 | 14270 | vanduo šaltas - V1 2
1341248 | 4 a V1 | 358 | 17629.1 | vanduo šaltas - V1 2
1341259 | 4 a V1 | 269.025 | 17626.8 | vanduo šaltas - V1 2
1341262 | 4 a V1 | 60 | 14642.3 | vanduo šaltas - V1 2
1341299 | 4 a V1 | 2946.82 | 14670 | vanduo šaltas - V1 2
1341325 | 4 a V1 | 488.123 | 17629.1 | vanduo šaltas - V1 2
1341334 | 2 a | 1887.93 | 17623.8 | vanduo šaltas - V1 2
1341337 | 4 a V1 | 1760 | 17629.1 | vanduo šaltas - V1 2
1341345 | 4 a V1 | 296.422 | 17629.1 | vanduo šaltas - V1 2
1341360 | 4 a V1 | 220 | 17629.1 | vanduo šaltas - V1 2
1341368 | 4 a V1 | 60 | 17629.1 | vanduo šaltas - V1 2
1341378 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1341417 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1341448 | 4 a V1 | 40 | 17629.1 | vanduo šaltas - V1 2
1341455 | 4 a V1 | 548.752 | 17629.1 | vanduo šaltas - V1 2
1341458 | 4 a V1 | 118.533 | 14442.3 | vanduo šaltas - V1 2
1341505 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1341528 | 4 a V1 | 370 | 17629.1 | vanduo šaltas - V1 2
1341541 | 4 a V1 | 3634.83 | 17629.1 | vanduo šaltas - V1 2
1341544 | 4 a V1 | 85 | 17629.1 | vanduo šaltas - V1 2
1341554 | 4 a V1 | 95 | 14442.3 | vanduo šaltas - V1 2
1341585 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1341658 | 2 a | 3989.59 | 17717.4 | vanduo šaltas - V1 2
1341720 | 2 a | 62 | 21839 | vanduo šaltas - V1 2
1341782 | 2 a | 98 | 17670.4 | vanduo šaltas - V1 2
1341828 | 2 a | 9599.79 | 8049.62 | vanduo šaltas - V1 2
1341873 | 4 a V1 | 1694.89 | 17670.4 | vanduo šaltas - V1 2
1341897 | 4 a V1 | 1051.9 | 17670.4 | vanduo šaltas - V1 2
1341907 | 4 a V1 | 200.06 | 17670.4 | vanduo šaltas - V1 2
1341933 | 4 a V1 | 645.68 | 17670.4 | vanduo šaltas - V1 2
1341942 | 4 a V1 | 530.24 | 17670.4 | vanduo šaltas - V1 2
1341969 | 4 a V1 | 376.009 | 17675.7 | vanduo šaltas - V1 2
1341978 | 4 a V1 | 3620.49 | 17670.4 | vanduo šaltas - V1 2
1341981 | 4 a V1 | 152.592 | 14442.3 | vanduo šaltas - V1 2
1342018 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342261 | 4 a V1 | 255 | 17675.7 | vanduo šaltas - V1 2
1342288 | 4 a V1 | 891.83 | 17675.7 | vanduo šaltas - V1 2
1342291 | 4 a V1 | 60 | 14442.3 | vanduo šaltas - V1 2
1342326 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342362 | 4 a V1 | 170 | 17675.7 | vanduo šaltas - V1 2
1342369 | 4 a V1 | 1951.16 | 17675.7 | vanduo šaltas - V1 2
1342372 | 4 a V1 | 185 | 17675.7 | vanduo šaltas - V1 2
1342385 | 4 a V1 | 90 | 14442.3 | vanduo šaltas - V1 2
1342424 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342455 | 4 a V1 | 94 | 17675.7 | vanduo šaltas - V1 2
1342466 | 4 a V1 | 632.616 | 17670.4 | vanduo šaltas - V1 2
1342469 | 4 a V1 | 220 | 14442.3 | vanduo šaltas - V1 2
1342492 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342522 | 4 a V1 | 154 | 17675.7 | vanduo šaltas - V1 2
1342537 | 4 a V1 | 517.693 | 17670.4 | vanduo šaltas - V1 2
1342540 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1342586 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342608 | 4 a V1 | 114 | 17675.7 | vanduo šaltas - V1 2
1342619 | 4 a V1 | 498.409 | 17670.4 | vanduo šaltas - V1 2
1342622 | 4 a V1 | 60 | 14442.3 | vanduo šaltas - V1 2
1342657 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342691 | 4 a V1 | 141.069 | 17675.7 | vanduo šaltas - V1 2
1342728 | 4 a V1 | 1480 | 17675.7 | vanduo šaltas - V1 2
1342775 | 4 a V1 | 180 | 17675.7 | vanduo šaltas - V1 2
1342787 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1342822 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1342871 | 4 a V1 | 160 | 17675.7 | vanduo šaltas - V1 2
1342880 | 4 a V1 | 833.539 | 17675.7 | vanduo šaltas - V1 2
1342883 | 4 a V1 | 100 | 14242.3 | vanduo šaltas - V1 2
1342921 | 4 a V1 | 3393.41 | 14270 | vanduo šaltas - V1 2
1342945 | 4 a V1 | 220 | 17675.7 | vanduo šaltas - V1 2
1342956 | 4 a V1 | 214.392 | 17675.7 | vanduo šaltas - V1 2
1342959 | 4 a V1 | 160 | 14442.3 | vanduo šaltas - V1 2
1342992 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343018 | 4 a V1 | 230 | 17675.7 | vanduo šaltas - V1 2
1343034 | 4 a V1 | 115 | 17675.7 | vanduo šaltas - V1 2
1343042 | 4 a V1 | 110 | 14442.3 | vanduo šaltas - V1 2
1343119 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343143 | 4 a V1 | 81.9324 | 17675.7 | vanduo šaltas - V1 2
1343152 | 4 a V1 | 1238.95 | 17670.4 | vanduo šaltas - V1 2
1343155 | 4 a V1 | 153.291 | 14442.3 | vanduo šaltas - V1 2
1343177 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343199 | 4 a V1 | 81.9324 | 17675.7 | vanduo šaltas - V1 2
1343208 | 4 a V1 | 200.06 | 17670.4 | vanduo šaltas - V1 2
1343245 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343255 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1343278 | 4 a V1 | 177.733 | 17673.4 | vanduo šaltas - V1 2
1343290 | 4 a V1 | 450.775 | 17675.7 | vanduo šaltas - V1 2
1343404 | 4 a V1 | 140 | 17675.7 | vanduo šaltas - V1 2
1343414 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1343461 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343480 | 4 a V1 | 245 | 17675.7 | vanduo šaltas - V1 2
1343489 | 4 a V1 | 1238.91 | 17675.7 | vanduo šaltas - V1 2
1343492 | 4 a V1 | 97.5902 | 14442.3 | vanduo šaltas - V1 2
1343551 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343573 | 4 a V1 | 200 | 17675.7 | vanduo šaltas - V1 2
1343582 | 4 a V1 | 89.3156 | 17675.7 | vanduo šaltas - V1 2
1343585 | 4 a V1 | 90 | 14442.3 | vanduo šaltas - V1 2
1343624 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1343699 | 4 a V1 | 518 | 17675.7 | vanduo šaltas - V1 2
1343710 | 4 a V1 | 587.519 | 17673.4 | vanduo šaltas - V1 2
1343713 | 4 a V1 | 85 | 14242.3 | vanduo šaltas - V1 2
1343745 | 4 a V1 | 3393.41 | 14270 | vanduo šaltas - V1 2
1343767 | 4 a V1 | 498 | 17675.7 | vanduo šaltas - V1 2
1343778 | 4 a V1 | 1393.38 | 17673.4 | vanduo šaltas - V1 2
1343781 | 4 a V1 | 100 | 14642.3 | vanduo šaltas - V1 2
1343808 | 4 a V1 | 2993.41 | 14670 | vanduo šaltas - V1 2
1343829 | 4 a V1 | 478 | 17675.7 | vanduo šaltas - V1 2
1343840 | 4 a V1 | 815.226 | 17673.4 | vanduo šaltas - V1 2
1343843 | 4 a V1 | 80 | 14642.3 | vanduo šaltas - V1 2
1343869 | 4 a V1 | 2993.41 | 14670 | vanduo šaltas - V1 2
1343890 | 4 a V1 | 498 | 17675.7 | vanduo šaltas - V1 2
1343903 | 4 a V1 | 238.142 | 17673.4 | vanduo šaltas - V1 2
1343906 | 4 a V1 | 100 | 14242.3 | vanduo šaltas - V1 2
1343935 | 4 a V1 | 3393.41 | 14270 | vanduo šaltas - V1 2
1343998 | 2 a | 4264.67 | 17268.3 | vanduo šaltas - V1 2
1344071 | 2 a | 11328.5 | 3750 | vanduo šaltas - V1 2
1344088 | 2 a | 3648.62 | 21567 | vanduo šaltas - V1 2
1344191 | 5 a V1 | 4433 | 21570 | vanduo šaltas - V1 2
1344565 | 5 a V1 | 964.929 | 21570 | vanduo šaltas - V1 2
1344575 | 5 a V1 | 2479 | 21572.3 | vanduo šaltas - V1 2
1344601 | 5 a V1 | 7260 | 21572.3 | vanduo šaltas - V1 2
1344613 | 5 a V1 | 2560 | 21572.3 | vanduo šaltas - V1 2
1344621 | 5 a V1 | 80 | 21572.3 | vanduo šaltas - V1 2
1344643 | 5 a V1 | 140 | 18942.3 | vanduo šaltas - V1 2
1344697 | 5 a V1 | 2590 | 18970 | vanduo šaltas - V1 2
1344727 | 5 a V1 | 2283 | 21572.3 | vanduo šaltas - V1 2
1344738 | 5 a V1 | 1347.69 | 21570 | vanduo šaltas - V1 2
1344741 | 5 a V1 | 95 | 18742.3 | vanduo šaltas - V1 2
1344781 | 5 a V1 | 2790 | 18770 | vanduo šaltas - V1 2
1344807 | 5 a V1 | 137.011 | 21572.3 | vanduo šaltas - V1 2
1344822 | 5 a V1 | 605.899 | 21570 | vanduo šaltas - V1 2
1344825 | 5 a V1 | 74.4583 | 18942.3 | vanduo šaltas - V1 2
1344863 | 5 a V1 | 2590 | 18970 | vanduo šaltas - V1 2
1344910 | 5 a V1 | 140 | 18942.3 | vanduo šaltas - V1 2
1344919 | 5 a V1 | 2590 | 18970 | vanduo šaltas - V1 2
1344922 | 5 a V1 | 173.564 | 21572.3 | vanduo šaltas - V1 2
1344957 | 5 a V1 | 913.893 | 21572.3 | vanduo šaltas - V1 2
1344970 | 5 a V1 | 1117.49 | 21570 | vanduo šaltas - V1 2
1344973 | 5 a V1 | 440 | 21572.3 | vanduo šaltas - V1 2
1344986 | 5 a V1 | 120 | 18742.3 | vanduo šaltas - V1 2
1345025 | 5 a V1 | 2790 | 18770 | vanduo šaltas - V1 2
1345056 | 5 a V1 | 620 | 21572.3 | vanduo šaltas - V1 2
1345065 | 5 a V1 | 1124.11 | 21572.3 | vanduo šaltas - V1 2
1345068 | 5 a V1 | 88.559 | 18742.3 | vanduo šaltas - V1 2
1345131 | 5 a V1 | 2790 | 18770 | vanduo šaltas - V1 2
1345208 | 2 a | 898 | 17221.3 | vanduo šaltas - V1 2
1345219 | 2 a | 4674.48 | 12525.8 | vanduo šaltas - V1 2
1345256 | 4 a V1 | 2101.91 | 17221.3 | vanduo šaltas - V1 2
1345292 | 4 a V1 | 470.765 | 17224.3 | vanduo šaltas - V1 2
1345301 | 4 a V1 | 98.7995 | 17221.3 | vanduo šaltas - V1 2
1345831 | 4 a V1 | 936.907 | 17224.3 | vanduo šaltas - V1 2
1345840 | 4 a V1 | 258.791 | 17221.3 | vanduo šaltas - V1 2
1345843 | 4 a V1 | 1710.08 | 17226.6 | vanduo šaltas - V1 2
1345866 | 4 a V1 | 140 | 14242.3 | vanduo šaltas - V1 2
1345906 | 4 a V1 | 2944.33 | 14270 | vanduo šaltas - V1 2
1345979 | 4 a V1 | 350 | 17226.6 | vanduo šaltas - V1 2
1345988 | 4 a V1 | 308.916 | 17226.6 | vanduo šaltas - V1 2
1345991 | 4 a V1 | 70 | 14442.3 | vanduo šaltas - V1 2
1346023 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1346117 | 4 a V1 | 3649.7 | 17670.4 | vanduo šaltas - V1 2
1346121 | 4 a V1 | 200 | 14642.3 | vanduo šaltas - V1 2
1346132 | 4 a V1 | 2993.41 | 14670 | vanduo šaltas - V1 2
1346352 | 4 a V1 | 120 | 14242.3 | vanduo šaltas - V1 2
1346367 | 4 a V1 | 3387.41 | 14270 | vanduo šaltas - V1 2
1346370 | 4 a V1 | 591.719 | 17670.4 | vanduo šaltas - V1 2
1346417 | 4 a V1 | 190.261 | 17675.7 | vanduo šaltas - V1 2
1346432 | 4 a V1 | 3683.48 | 17670.4 | vanduo šaltas - V1 2
1346435 | 4 a V1 | 320 | 17675.7 | vanduo šaltas - V1 2
1346445 | 4 a V1 | 120 | 17675.7 | vanduo šaltas - V1 2
1346453 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1346516 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1346540 | 4 a V1 | 180 | 17675.7 | vanduo šaltas - V1 2
1346549 | 4 a V1 | 198.116 | 17675.7 | vanduo šaltas - V1 2
1346552 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1346582 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1346603 | 4 a V1 | 130 | 17675.7 | vanduo šaltas - V1 2
1346612 | 4 a V1 | 1825.62 | 17675.7 | vanduo šaltas - V1 2
1346615 | 4 a V1 | 55 | 14442.3 | vanduo šaltas - V1 2
1346642 | 4 a V1 | 3193.41 | 14470 | vanduo šaltas - V1 2
1346665 | 4 a V1 | 419.755 | 17226.6 | vanduo šaltas - V1 2
1346683 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1346718 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1346742 | 4 a V1 | 100 | 17226.6 | vanduo šaltas - V1 2
1346751 | 4 a V1 | 1629.15 | 17226.6 | vanduo šaltas - V1 2
1346754 | 4 a V1 | 90 | 14442.3 | vanduo šaltas - V1 2
1346802 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1346844 | 4 a V1 | 65 | 17226.6 | vanduo šaltas - V1 2
1346853 | 4 a V1 | 150.092 | 17226.6 | vanduo šaltas - V1 2
1346856 | 4 a V1 | 135 | 14442.3 | vanduo šaltas - V1 2
1346882 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1346904 | 4 a V1 | 93 | 17226.6 | vanduo šaltas - V1 2
1346915 | 4 a V1 | 469.895 | 17224.3 | vanduo šaltas - V1 2
1346918 | 4 a V1 | 163.325 | 14242.3 | vanduo šaltas - V1 2
1346952 | 4 a V1 | 2944.33 | 14270 | vanduo šaltas - V1 2
1346979 | 4 a V1 | 83 | 17226.6 | vanduo šaltas - V1 2
1346988 | 4 a V1 | 3063.19 | 17224.3 | vanduo šaltas - V1 2
1346991 | 4 a V1 | 153.325 | 14642.3 | vanduo šaltas - V1 2
1347018 | 4 a V1 | 2544.33 | 14670 | vanduo šaltas - V1 2
1347044 | 4 a V1 | 169.456 | 17226.6 | vanduo šaltas - V1 2
1347058 | 4 a V1 | 100 | 17226.6 | vanduo šaltas - V1 2
1347066 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1347097 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1347121 | 4 a V1 | 190 | 17226.6 | vanduo šaltas - V1 2
1347130 | 4 a V1 | 310.544 | 17226.6 | vanduo šaltas - V1 2
1347133 | 4 a V1 | 300 | 17226.6 | vanduo šaltas - V1 2
1347143 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1347172 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1347196 | 4 a V1 | 279.826 | 17226.6 | vanduo šaltas - V1 2
1347205 | 4 a V1 | 190 | 17226.6 | vanduo šaltas - V1 2
1347208 | 4 a V1 | 90.3704 | 14442.3 | vanduo šaltas - V1 2
1347249 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1347271 | 4 a V1 | 118 | 17226.6 | vanduo šaltas - V1 2
1347282 | 4 a V1 | 188.152 | 17224.3 | vanduo šaltas - V1 2
1347345 | 4 a V1 | 85 | 14242.3 | vanduo šaltas - V1 2
1347354 | 4 a V1 | 2944.33 | 14270 | vanduo šaltas - V1 2
1347408 | 4 a V1 | 419 | 17226.6 | vanduo šaltas - V1 2
1347417 | 4 a V1 | 104.812 | 17221.3 | vanduo šaltas - V1 2
1347420 | 4 a V1 | 100 | 14642.3 | vanduo šaltas - V1 2
1347453 | 4 a V1 | 2544.33 | 14670 | vanduo šaltas - V1 2
1347476 | 4 a V1 | 533.555 | 17224.3 | vanduo šaltas - V1 2
1347485 | 4 a V1 | 5446.74 | 17221.3 | vanduo šaltas - V1 2
1347488 | 4 a V1 | 476 | 17224.3 | vanduo šaltas - V1 2
1347496 | 4 a V1 | 80.2544 | 17224.3 | vanduo šaltas - V1 2
1347506 | 4 a V1 | 319.844 | 17226.6 | vanduo šaltas - V1 2
1347518 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1347561 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1347605 | 4 a V1 | 260 | 17226.6 | vanduo šaltas - V1 2
1347616 | 4 a V1 | 239.128 | 17226.6 | vanduo šaltas - V1 2
1347619 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1347669 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1347691 | 4 a V1 | 260 | 17226.6 | vanduo šaltas - V1 2
1347700 | 4 a V1 | 1400.03 | 17226.6 | vanduo šaltas - V1 2
1347703 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1347730 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1347752 | 4 a V1 | 331.188 | 17226.6 | vanduo šaltas - V1 2
1347763 | 4 a V1 | 808.218 | 17224.3 | vanduo šaltas - V1 2
1347766 | 4 a V1 | 120 | 14242.3 | vanduo šaltas - V1 2
1347794 | 4 a V1 | 2944.33 | 14270 | vanduo šaltas - V1 2
1347818 | 4 a V1 | 458 | 17226.6 | vanduo šaltas - V1 2
1347837 | 4 a V1 | 1207.53 | 17224.3 | vanduo šaltas - V1 2
1347840 | 4 a V1 | 219 | 14642.3 | vanduo šaltas - V1 2
1347876 | 4 a V1 | 2544.33 | 14670 | vanduo šaltas - V1 2
1347897 | 4 a V1 | 2018 | 17226.6 | vanduo šaltas - V1 2
1347908 | 4 a V1 | 1436.75 | 17224.3 | vanduo šaltas - V1 2
1347911 | 4 a V1 | 100 | 14642.3 | vanduo šaltas - V1 2
1347957 | 4 a V1 | 2544.33 | 14670 | vanduo šaltas - V1 2
1347979 | 4 a V1 | 2018 | 17226.6 | vanduo šaltas - V1 2
1347990 | 4 a V1 | 637.565 | 17224.3 | vanduo šaltas - V1 2
1347993 | 4 a V1 | 120 | 14642.3 | vanduo šaltas - V1 2
1348028 | 4 a V1 | 2544.33 | 14670 | vanduo šaltas - V1 2
1348054 | 4 a V1 | 2018 | 17226.6 | vanduo šaltas - V1 2
1348065 | 4 a V1 | 525.541 | 17224.3 | vanduo šaltas - V1 2
1348068 | 4 a V1 | 100 | 14197.5 | vanduo šaltas - V1 2
1348107 | 4 a V1 | 2989.13 | 14225.2 | vanduo šaltas - V1 2
1348131 | 4 a V1 | 178 | 17226.6 | vanduo šaltas - V1 2
1348142 | 4 a V1 | 375.238 | 17224.3 | vanduo šaltas - V1 2
1348145 | 4 a V1 | 100 | 17226.6 | vanduo šaltas - V1 2
1348157 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1348196 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1348230 | 4 a V1 | 423.299 | 17226.6 | vanduo šaltas - V1 2
1348241 | 4 a V1 | 3831.95 | 17221.3 | vanduo šaltas - V1 2
1348244 | 4 a V1 | 140 | 17226.6 | vanduo šaltas - V1 2
1348252 | 4 a V1 | 103.709 | 14442.3 | vanduo šaltas - V1 2
1348285 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1348305 | 4 a V1 | 75 | 17226.6 | vanduo šaltas - V1 2
1348312 | 4 a V1 | 668.492 | 17226.6 | vanduo šaltas - V1 2
1348315 | 4 a V1 | 145 | 14442.3 | vanduo šaltas - V1 2
1348350 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1348374 | 4 a V1 | 340 | 17226.6 | vanduo šaltas - V1 2
1348385 | 4 a V1 | 1502.21 | 17226.6 | vanduo šaltas - V1 2
1348388 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1348420 | 4 a V1 | 2744.33 | 14470 | vanduo šaltas - V1 2
1348465 | 2 a | 364.218 | 12716.8 | vanduo šaltas - V1 2
1348476 | 2 a | 6005.65 | 3750 | vanduo šaltas - V1 2
1348678 | 2 a | 3245.28 | 3750 | vanduo šaltas - V1 2
1348682 | 2 a | 408.451 | 13099.5 | vanduo šaltas - V1 2
1349046 | 4 a V1 | 322 | 13099.5 | vanduo šaltas - V1 2
1349096 | 4 a V1 | 3822 | 13159 | vanduo šaltas - V1 2
1349192 | 4 a V1 | 2233.41 | 16999.5 | vanduo šaltas - V1 2
1349202 | 4 a V1 | 4052.25 | 16999.5 | vanduo šaltas - V1 2
1349210 | 4 a V1 | 143.029 | 17007 | vanduo šaltas - V1 2
1349278 | 4 a V1 | 533.561 | 17010 | vanduo šaltas - V1 2
1349342 | 4 a V1 | 2401 | 17010 | vanduo šaltas - V1 2
1349361 | 4 a V1 | 620.589 | 16999.5 | vanduo šaltas - V1 2
1349396 | 4 a V1 | 138.976 | 17010 | vanduo šaltas - V1 2
1349406 | 4 a V1 | 259 | 17012.3 | vanduo šaltas - V1 2
1349426 | 4 a V1 | 180 | 17012.3 | vanduo šaltas - V1 2
1349436 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1349473 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1349501 | 4 a V1 | 1338 | 17010 | vanduo šaltas - V1 2
1349508 | 4 a V1 | 2330.52 | 17010 | vanduo šaltas - V1 2
1349511 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1349554 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1349642 | 4 a V1 | 79.3334 | 17010 | vanduo šaltas - V1 2
1349655 | 4 a V1 | 2113.51 | 17010 | vanduo šaltas - V1 2
1349658 | 4 a V1 | 99 | 17012.3 | vanduo šaltas - V1 2
1349674 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1349712 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1349742 | 4 a V1 | 258 | 17012.3 | vanduo šaltas - V1 2
1349751 | 4 a V1 | 654.698 | 17010 | vanduo šaltas - V1 2
1349754 | 4 a V1 | 195 | 17012.3 | vanduo šaltas - V1 2
1349762 | 4 a V1 | 40 | 14142.3 | vanduo šaltas - V1 2
1349791 | 4 a V1 | 2829.99 | 14170 | vanduo šaltas - V1 2
1349909 | 4 a V1 | 118 | 17012.3 | vanduo šaltas - V1 2
1349918 | 4 a V1 | 1076.95 | 17010 | vanduo šaltas - V1 2
1349921 | 4 a V1 | 80 | 14142.3 | vanduo šaltas - V1 2
1349963 | 4 a V1 | 2829.99 | 14170 | vanduo šaltas - V1 2
1349994 | 4 a V1 | 78 | 17012.3 | vanduo šaltas - V1 2
1350003 | 4 a V1 | 524.019 | 17010 | vanduo šaltas - V1 2
1350006 | 4 a V1 | 160 | 14442.3 | vanduo šaltas - V1 2
1350040 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1350091 | 4 a V1 | 552.324 | 17012.3 | vanduo šaltas - V1 2
1350130 | 4 a V1 | 2020 | 17012.3 | vanduo šaltas - V1 2
1350140 | 4 a V1 | 360 | 17012.3 | vanduo šaltas - V1 2
1350154 | 4 a V1 | 180 | 17012.3 | vanduo šaltas - V1 2
1350164 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1350192 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1350214 | 4 a V1 | 880 | 17012.3 | vanduo šaltas - V1 2
1350223 | 4 a V1 | 1448.68 | 17012.3 | vanduo šaltas - V1 2
1350226 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1350250 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1350280 | 4 a V1 | 228.241 | 17012.3 | vanduo šaltas - V1 2
1350312 | 4 a V1 | 80 | 17012.3 | vanduo šaltas - V1 2
1350322 | 4 a V1 | 100 | 17012.3 | vanduo šaltas - V1 2
1350330 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1350369 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1350411 | 4 a V1 | 376.681 | 17012.3 | vanduo šaltas - V1 2
1350420 | 4 a V1 | 157.372 | 17012.3 | vanduo šaltas - V1 2
1350423 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1350466 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1350489 | 4 a V1 | 360 | 17012.3 | vanduo šaltas - V1 2
1350498 | 4 a V1 | 1534.39 | 17012.3 | vanduo šaltas - V1 2
1350501 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1350539 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1350633 | 4 a V1 | 209 | 17012.3 | vanduo šaltas - V1 2
1350642 | 4 a V1 | 633.875 | 17007 | vanduo šaltas - V1 2
1350645 | 4 a V1 | 55 | 14142.3 | vanduo šaltas - V1 2
1350672 | 4 a V1 | 2829.99 | 14170 | vanduo šaltas - V1 2
1350746 | 4 a V1 | 204 | 17012.3 | vanduo šaltas - V1 2
1350759 | 4 a V1 | 1322.53 | 17007 | vanduo šaltas - V1 2
1350762 | 4 a V1 | 50 | 14642.3 | vanduo šaltas - V1 2
1350835 | 4 a V1 | 2329.99 | 14670 | vanduo šaltas - V1 2
1350924 | 4 a V1 | 204 | 17012.3 | vanduo šaltas - V1 2
1350933 | 4 a V1 | 649.654 | 17007 | vanduo šaltas - V1 2
1350936 | 4 a V1 | 40 | 14642.3 | vanduo šaltas - V1 2
1350967 | 4 a V1 | 2329.99 | 14670 | vanduo šaltas - V1 2
1350997 | 4 a V1 | 219 | 17012.3 | vanduo šaltas - V1 2
1351006 | 4 a V1 | 745.697 | 17007 | vanduo šaltas - V1 2
1351009 | 4 a V1 | 65 | 14142.3 | vanduo šaltas - V1 2
1351036 | 4 a V1 | 2829.99 | 14170 | vanduo šaltas - V1 2
1351078 | 4 a V1 | 226.109 | 17010 | vanduo šaltas - V1 2
1351089 | 4 a V1 | 1516.21 | 17007 | vanduo šaltas - V1 2
1351092 | 4 a V1 | 259 | 17012.3 | vanduo šaltas - V1 2
1351118 | 4 a V1 | 120 | 17012.3 | vanduo šaltas - V1 2
1351126 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1351161 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1351183 | 4 a V1 | 318 | 17012.3 | vanduo šaltas - V1 2
1351192 | 4 a V1 | 147.834 | 17010 | vanduo šaltas - V1 2
1351195 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1351224 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1351257 | 4 a V1 | 278 | 17012.3 | vanduo šaltas - V1 2
1351266 | 4 a V1 | 1518.06 | 17010 | vanduo šaltas - V1 2
1351269 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1351301 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1351345 | 4 a V1 | 256.5 | 17012.3 | vanduo šaltas - V1 2
1351361 | 4 a V1 | 245 | 17012.3 | vanduo šaltas - V1 2
1351372 | 4 a V1 | 70 | 14642.3 | vanduo šaltas - V1 2
1351402 | 4 a V1 | 2329.99 | 14670 | vanduo šaltas - V1 2
1351437 | 4 a V1 | 64.1994 | 17010 | vanduo šaltas - V1 2
1351448 | 4 a V1 | 1411.38 | 17007 | vanduo šaltas - V1 2
1351451 | 4 a V1 | 76 | 17010 | vanduo šaltas - V1 2
1351461 | 4 a V1 | 178 | 14440 | vanduo šaltas - V1 2
1351496 | 4 a V1 | 2525.99 | 14472 | vanduo šaltas - V1 2
1351527 | 4 a V1 | 318 | 17012.3 | vanduo šaltas - V1 2
1351538 | 4 a V1 | 62.8116 | 17010 | vanduo šaltas - V1 2
1351541 | 4 a V1 | 460 | 17012.3 | vanduo šaltas - V1 2
1351549 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1351585 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1351609 | 4 a V1 | 93 | 17010 | vanduo šaltas - V1 2
1351618 | 4 a V1 | 1538.99 | 17010 | vanduo šaltas - V1 2
1351621 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1351660 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1351716 | 4 a V1 | 238 | 17012.3 | vanduo šaltas - V1 2
1351727 | 4 a V1 | 533.561 | 17010 | vanduo šaltas - V1 2
1351730 | 4 a V1 | 80 | 14142.3 | vanduo šaltas - V1 2
1351754 | 4 a V1 | 2829.99 | 14170 | vanduo šaltas - V1 2
1351778 | 4 a V1 | 290.188 | 17010 | vanduo šaltas - V1 2
1351787 | 4 a V1 | 2276.51 | 16999.5 | vanduo šaltas - V1 2
1351792 | 4 a V1 | 239 | 17012.3 | vanduo šaltas - V1 2
1351837 | 4 a V1 | 109.5 | 14142.3 | vanduo šaltas - V1 2
1351865 | 4 a V1 | 2829.99 | 14170 | vanduo šaltas - V1 2
1351889 | 4 a V1 | 218 | 17012.3 | vanduo šaltas - V1 2
1351902 | 4 a V1 | 2256.73 | 17010 | vanduo šaltas - V1 2
1351905 | 4 a V1 | 80 | 14642.3 | vanduo šaltas - V1 2
1351940 | 4 a V1 | 2329.99 | 14670 | vanduo šaltas - V1 2
1352174 | 4 a V1 | 1338 | 17012.3 | vanduo šaltas - V1 2
1352185 | 4 a V1 | 615.086 | 17010 | vanduo šaltas - V1 2
1352188 | 4 a V1 | 700 | 17012.3 | vanduo šaltas - V1 2
1352198 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
