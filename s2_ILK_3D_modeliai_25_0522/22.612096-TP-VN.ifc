Properties of the parts of a building model (IFC2X3), part 15 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1342659_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342657_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342663_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342680_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342956_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342680_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346117_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342691_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342691_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342773_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342728_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342773_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342728_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342785_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342775_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342785_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342775_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342824_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342828_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342822_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342824_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342871_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342879_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342923_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342880_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342880_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342955_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342883_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342927_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342883_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342921_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342923_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342927_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342945_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342955_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342945_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342994_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342955_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342956_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342959_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342998_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342959_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342992_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342994_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342992_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1342998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343018_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343028_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343018_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343040_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343028_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343030_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343034_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343040_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343121_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343042_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343125_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343042_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343119_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343121_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343119_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343125_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343143_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343151_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343143_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343151_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343208_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343151_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343152_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343152_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343286_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343155_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343183_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343155_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343177_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343179_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343199_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343207_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343199_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343207_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343245_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343247_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343245_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343251_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343255_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343255_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343278_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343709_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343313_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343286_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343903_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343290_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343581_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343290_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343412_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343313_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343315_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343489_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343404_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343412_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343404_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343463_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343414_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343465_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343414_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343461_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343463_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343461_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343480_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343488_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343480_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343582_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343488_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343492_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343557_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343492_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343551_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343553_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343573_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343581_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343573_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343626_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343581_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343582_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343585_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343630_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343624_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343626_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343624_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343630_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343699_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343709_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343747_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343709_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343710_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343710_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343777_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343713_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343751_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343745_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343747_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343745_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343767_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343777_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343767_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343810_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343777_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343778_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343778_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343839_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343781_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343814_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343781_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343808_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343810_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343808_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343814_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343829_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343839_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343829_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343839_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343902_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343843_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343875_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343843_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343869_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343871_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343875_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343890_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343902_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343890_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343937_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343902_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343903_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343906_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343941_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343906_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343935_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343937_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343941_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343998_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345218_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1343998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344100_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344071_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344083_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344083_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344083_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392321_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344088_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344098_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344088_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344207_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344098_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344100_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344191_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344223_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344191_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344573_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344207_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344565_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344737_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344595_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344573_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344970_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344575_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344597_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344575_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344611_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344595_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344597_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344601_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344611_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344613_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344619_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344641_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344621_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344621_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344643_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344703_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344643_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344697_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344697_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344703_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344727_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344737_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344783_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344737_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344738_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344821_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344741_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344787_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344741_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344781_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344783_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344781_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344807_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344865_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344821_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344821_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344922_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344822_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344825_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344825_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344863_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344865_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344863_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344910_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344925_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344910_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344919_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344921_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344919_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344925_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344921_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344922_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345064_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344984_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344969_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344970_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344969_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345065_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344973_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344984_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344973_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345027_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344986_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345031_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1344986_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345025_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345027_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345025_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345031_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345056_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345064_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345056_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345133_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345064_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345065_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345068_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345137_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345068_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345131_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345133_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345131_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345137_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345208_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345218_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345254_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345219_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1361464_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348241_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345256_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345300_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345256_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345292_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346914_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346677_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345300_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345300_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347282_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345301_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347416_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345831_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345831_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345860_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345839_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347485_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345839_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345839_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348142_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348240_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345843_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345843_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345908_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345860_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345862_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345862_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345988_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345866_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345912_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345866_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345906_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345908_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345906_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345912_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345987_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346025_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345987_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345988_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345991_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346029_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1345991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346023_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346025_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346023_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346029_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346116_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346117_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346116_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346432_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346121_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346140_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346121_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346132_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346134_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346132_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346140_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346134_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346136_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346352_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346373_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346367_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346369_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346373_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346369_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346370_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346370_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346431_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346417_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346548_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346443_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346431_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346432_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346431_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346612_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346435_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346443_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346451_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346445_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346451_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346445_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346453_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346522_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346453_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346516_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346518_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346516_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346522_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346540_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346548_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346540_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346584_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346548_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346549_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346611_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346552_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346588_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346552_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346582_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346584_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346582_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346588_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346603_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346611_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346603_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346611_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346612_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346615_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346648_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346642_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346665_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346852_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346720_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346677_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346679_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346679_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346751_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346683_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346724_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346683_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346718_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346720_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346718_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346724_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346742_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346750_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346742_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346804_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346750_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346853_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346750_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346754_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346808_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346754_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346802_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346804_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346802_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346808_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346844_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346852_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346844_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346884_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346852_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346853_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346856_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346888_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346856_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346882_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346884_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346882_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346888_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346904_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346914_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346954_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346914_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346915_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346915_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346918_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346958_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346952_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346954_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346952_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346958_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346987_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346987_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346988_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346988_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347281_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346991_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347024_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1346991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347018_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347020_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347018_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347044_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347129_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347044_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347064_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347054_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347052_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347130_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347058_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347064_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347099_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347066_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347103_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347066_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347097_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347099_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347097_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347103_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347121_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347204_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347121_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347141_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347129_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347130_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347129_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347205_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347133_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347141_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347133_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347143_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347178_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347143_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347172_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347174_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347172_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347178_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347196_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347204_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347196_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347204_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347205_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347208_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347255_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347249_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347251_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347249_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347255_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347271_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347281_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347271_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347356_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347281_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347282_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347345_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347360_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347345_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347354_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347356_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347354_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347408_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347416_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347408_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347416_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347417_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347484_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347420_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347457_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347420_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347453_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347455_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347453_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347457_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347484_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347476_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347494_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347484_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347485_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347488_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347494_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347504_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347496_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347762_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347512_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347504_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347837_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347506_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347506_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347563_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347512_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347514_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347514_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347700_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347518_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347567_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347561_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347563_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347567_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347605_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347615_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347605_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347671_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347615_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347616_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347616_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347619_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347675_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347669_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347671_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347669_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347675_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347691_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347699_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347691_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347732_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347700_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347703_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347736_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347703_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347730_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347732_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347736_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347752_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347762_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347752_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347796_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347762_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347763_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347836_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347766_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347800_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347766_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347794_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347796_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347794_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347800_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347818_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347836_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347878_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347836_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347882_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347876_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347878_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347882_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347897_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347907_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347897_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347959_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347907_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347908_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347908_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347989_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347911_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347963_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347911_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347959_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347989_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348030_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347989_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347990_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347990_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348064_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347993_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348034_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1347993_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348028_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348030_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348028_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348054_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348064_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348064_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348065_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348065_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348141_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348068_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348113_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348068_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348107_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348109_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348107_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348113_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348131_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348141_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348131_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348155_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348141_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348142_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348145_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348155_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348145_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348157_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348202_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348157_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348196_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348198_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348196_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348311_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348250_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348240_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348241_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348240_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348385_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348244_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348250_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348244_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348287_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348252_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348289_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348252_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348285_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348287_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348285_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348289_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348305_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348311_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348305_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348311_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348312_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348384_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348315_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348356_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348350_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348352_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348350_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348356_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348374_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348384_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348384_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348385_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348388_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348424_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348388_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348420_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348422_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348420_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348465_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1360317_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348688_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348476_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1407563_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348677_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425558_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348677_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348677_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390788_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348682_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348688_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1348682_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349056_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349046_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349056_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349046_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349098_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349096_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349098_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349096_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349158_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349158_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349361_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349192_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349192_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349208_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349202_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349254_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349208_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1352267_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349210_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350641_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349210_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350587_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351089_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349254_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351448_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349278_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351726_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1351683_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349342_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349360_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349342_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350067_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349360_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349396_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349396_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349420_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349406_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349422_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349406_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349434_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349420_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349426_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349426_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349475_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349436_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349479_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349436_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349473_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349475_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349473_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349479_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349501_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349507_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349501_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349558_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349507_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349508_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349508_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349511_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349562_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349554_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349556_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349562_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349556_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349558_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349642_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349750_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349668_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349654_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349654_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350003_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349655_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350067_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349658_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349670_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349658_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349714_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349668_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349670_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349674_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349718_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349674_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349712_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349714_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349712_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349718_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349742_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349750_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349742_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349760_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349750_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349751_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349917_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349754_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349760_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349754_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349762_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349797_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349762_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349791_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349793_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349791_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349797_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349909_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349917_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349909_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349917_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349918_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350002_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349921_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349969_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349963_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349965_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349994_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350002_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1349994_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350042_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350002_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350003_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350006_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350046_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350040_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350042_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350040_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350046_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350067_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350223_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350091_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350138_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350130_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350138_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350130_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350152_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350140_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350152_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350140_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350162_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350154_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350162_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350154_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350194_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350164_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350198_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350164_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350192_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350194_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350192_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350214_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350222_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350214_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350252_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350222_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350226_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350256_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350226_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350250_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350252_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350250_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350256_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350280_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350419_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350280_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350320_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350288_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350288_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350498_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350312_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350320_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350328_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350322_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350328_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350322_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350330_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350375_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350330_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350369_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350371_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350375_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350411_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350419_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350468_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350419_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350420_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350420_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350497_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350423_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350472_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350423_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350468_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350472_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350489_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350497_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350497_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350498_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350501_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350545_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350501_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350539_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350541_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350539_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350545_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350633_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350641_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350633_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350674_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350641_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350642_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350758_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350645_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350678_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350645_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350672_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350674_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350746_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350758_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350758_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350759_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350759_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350932_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350762_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350841_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350762_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350835_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350837_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350835_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350841_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350924_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350932_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1350969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
