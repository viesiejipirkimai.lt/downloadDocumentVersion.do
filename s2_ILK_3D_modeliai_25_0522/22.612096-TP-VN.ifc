Properties of the parts of a building model (IFC2X3), part 55 of 57

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1447416 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1447457 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 1
1447487 | 2 a | 435 | 7866.3 | vanduo šaltas - V1 2
1447498 | 2 a | 135.862 | 7866.3 | vanduo šaltas - V1 2
1447501 | 2 a | 6740 | 7866.3 | vanduo šaltas - V1 2
1447512 | 2 a | 120 | 7866.3 | vanduo šaltas - V1 2
1447522 | 2 a | 220 | 5142.3 | vanduo šaltas - V1 2
1447566 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1447596 | 2 a | 2399 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1447616 | 2 a | 40.1919 | 7812.3 | vanduo karštas tiekiamasis - T3 9
1447627 | 2 a | 261.99 | 7812.3 | vanduo karštas tiekiamasis - T3 8
1447650 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 8
1447687 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 8
1447890 | 2 a | 2859.56 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1447905 | 2 a | 130.506 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1447920 | 2 a | 94.0929 | 7812.3 | vanduo karštas tiekiamasis - T3 10
1447928 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 10
1447967 | 2 a | 2630 | 5170 | vanduo karštas tiekiamasis - T3 10
1448001 | 2 a | 20 | 7812.3 | vanduo karštas tiekiamasis - T3 10
1448010 | 2 a | 238.407 | 7812.3 | vanduo karštas tiekiamasis - T3 10
1448150 | 2 a | 97.5 | 7810 | vanduo karštas tiekiamasis - T3 1
1448157 | 2 a | 1206.05 | 7810 | vanduo karštas tiekiamasis - T3 1
1448160 | 2 a | 759 | 7810 | vanduo karštas tiekiamasis - T3 1
1448170 | 2 a | 120 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1448228 | 2 a | 2480 | 5320 | vanduo karštas tiekiamasis - T3 1
1448267 | 2 a | 4940 | 3492.3 | vanduo karštas apytakinis - T4 1
1448278 | 1 a +-152.84 | 3649.36 | 3474.5 | vanduo karštas apytakinis - T4 1
1448285 | 2 a | 955 | 3492.3 | vanduo karštas apytakinis - T4 1
1448338 | 2 a | 4245 | 3520 | vanduo karštas apytakinis - T4 1
1448708 | 2 a | 4334.05 | 7777.3 | vanduo karštas apytakinis - T4 1
1448730 | 2 a | 7972.7 | 7777.3 | vanduo karštas apytakinis - T4 1
1448749 | 2 a | 6470.95 | 7777.3 | vanduo karštas apytakinis - T4 1
1448822 | 1 a +-152.84 | 31151 | 3947 | vanduo šaltas - V1 2
1448847 | 2 a | 118.632 | 3930 | vanduo šaltas - V1 2
1448907 | 2 a | 150.01 | 3547 | vanduo karštas tiekiamasis - T3 1
1448918 | 0 a | 11096.5 | 3530 | vanduo karštas tiekiamasis - T3 1
1448921 | 2 a | 610.5 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1448957 | 2 a | 2500 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1448965 | 2 a | 1465 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1448975 | 2 a | 135 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1448983 | 2 a | 72.3588 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1449023 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1449047 | 2 a | 2394 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1449066 | 2 a | 1755.79 | 3547 | vanduo karštas tiekiamasis - T3 1
1449069 | 2 a | 440 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1449082 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1449108 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1449158 | 2 a | 2674 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1449177 | 2 a | 150.01 | 3547 | vanduo karštas tiekiamasis - T3 1
1449180 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1449243 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1449267 | 2 a | 1854 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1449284 | 2 a | 6442.11 | 3547 | vanduo karštas tiekiamasis - T3 1
1449287 | 2 a | 355 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1449297 | 2 a | 60 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1449334 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1449360 | 2 a | 2272 | 3550 | vanduo karštas tiekiamasis - T3 1
1449371 | 2 a | 319.576 | 3547 | vanduo karštas tiekiamasis - T3 1
1449374 | 2 a | 379 | 3550 | vanduo karštas tiekiamasis - T3 1
1449388 | 2 a | 87.4211 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1449432 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1449478 | 0 a | 2133.02 | 3530 | vanduo karštas tiekiamasis - T3 1
1449481 | 2 a | 1190 | 3539.5 | vanduo karštas tiekiamasis - T3 1
1449487 | 2 a | 67 | 3539.5 | vanduo karštas tiekiamasis - T3 1
1449563 | 2 a | 4454.65 | 12625.4 | vanduo karštas tiekiamasis - T3 1
1449813 | 2 a | 1417 | 3484 | vanduo karštas apytakinis - T4 1
1449822 | 1 a +-152.84 | 7620.4 | 3474.5 | vanduo karštas apytakinis - T4 1
1449825 | 2 a | 102 | 3484 | vanduo karštas apytakinis - T4 1
1449858 | 2 a | 51 | 12484 | vanduo karštas apytakinis - T4 2
1450147 | 2 a | 4315.58 | 12680.4 | vanduo karštas apytakinis - T4 1
1450193 | 2 a | 39 | 7838.73 | vanduo karštas tiekiamasis - T3 1
1450200 | 2 a | 4221.23 | 3599 | vanduo karštas tiekiamasis - T3 1
1450218 | 2 a | 268 | 7846.23 | vanduo karštas tiekiamasis - T3 1
1450232 | 2 a | 1487.15 | 7846.23 | vanduo karštas tiekiamasis - T3 1
1450276 | 2 a | 62.4443 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450308 | 2 a | 90 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1450343 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1450368 | 2 a | 85 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1450379 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1450382 | 2 a | 510.212 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450421 | 2 a | 274 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450430 | 2 a | 1060.7 | 7846.23 | vanduo karštas tiekiamasis - T3 1
1450433 | 2 a | 106.602 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1450481 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1450503 | 2 a | 734 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450512 | 2 a | 114.156 | 7846.23 | vanduo karštas tiekiamasis - T3 1
1450515 | 2 a | 2560 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450523 | 2 a | 423.931 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450533 | 2 a | 95 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450541 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1450619 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1450643 | 2 a | 2390 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450656 | 2 a | 790.005 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450659 | 2 a | 465 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450669 | 2 a | 235 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450677 | 2 a | 60 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1450712 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1450742 | 2 a | 2675 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450755 | 2 a | 1028.74 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450758 | 2 a | 70 | 4792.3 | vanduo karštas tiekiamasis - T3 1
1450787 | 2 a | 3019.23 | 4820 | vanduo karštas tiekiamasis - T3 1
1450897 | 2 a | 1300 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450912 | 2 a | 3967.79 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450915 | 2 a | 180 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1450928 | 2 a | 120.118 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1450978 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1451000 | 2 a | 135 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1451009 | 2 a | 144.539 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1451012 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1451044 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1451068 | 2 a | 374 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1451077 | 2 a | 652.994 | 7846.23 | vanduo karštas tiekiamasis - T3 1
1451080 | 2 a | 1325 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1451088 | 2 a | 125 | 7851.53 | vanduo karštas tiekiamasis - T3 1
1451098 | 2 a | 128.398 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1451127 | 2 a | 2669.23 | 5170 | vanduo karštas tiekiamasis - T3 1
1451200 | 1 a +-152.84 | 4401.23 | 12636.8 | vanduo karštas tiekiamasis - T3 1
1451238 | 1 a +-152.84 | 174 | 17064 | vanduo karštas tiekiamasis - T3 1
1451304 | 1 a +-152.84 | 4306.21 | 12710.8 | vanduo karštas apytakinis - T4 1
1451415 | 2 a | 362 | 7618 | vanduo karštas tiekiamasis - T3 1
1451425 | 2 a | 462 | 7618 | vanduo karštas tiekiamasis - T3 1
1451433 | 2 a | 133.431 | 7618 | vanduo karštas tiekiamasis - T3 1
1451443 | 2 a | 119.087 | 7618 | vanduo karštas tiekiamasis - T3 1
1451469 | 2 a | 314.468 | 7618 | vanduo karštas tiekiamasis - T3 1
1451479 | 2 a | 282 | 7618 | vanduo karštas tiekiamasis - T3 1
1451589 | 1 a +-152.84 | 2296.53 | 3530 | vanduo karštas tiekiamasis - T3 1
1451614 | 2 a | 84 | 7618 | vanduo karštas tiekiamasis - T3 1
1451618 | 2 a | 51 | 3398 | vanduo karštas tiekiamasis - T3 1
1451728 | 1 a +-152.84 | 4793.11 | 3530 | vanduo karštas tiekiamasis - T3 1
1451772 | 2 a | 10466.3 | 3544 | vanduo karštas tiekiamasis - T3 1
1451782 | 2 a | 506.562 | 3544 | vanduo karštas tiekiamasis - T3 1
1451946 | 2 a | 88 | 3443 | vanduo karštas tiekiamasis - T3 1
1451958 | 2 a | 4016 | 3589 | vanduo karštas tiekiamasis - T3 1
1452121 | 2 a | 154 | 7621 | vanduo karštas tiekiamasis - T3 1
1452136 | 2 a | 84 | 7618 | vanduo karštas tiekiamasis - T3 1
1452139 | 2 a | 893 | 7621 | vanduo karštas tiekiamasis - T3 1
1452149 | 2 a | 58.173 | 7624 | vanduo karštas tiekiamasis - T3 1
1452163 | 2 a | 204.496 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452188 | 2 a | 95.4393 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1452243 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1452326 | 2 a | 83 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452347 | 2 a | 1553.46 | 7624 | vanduo karštas tiekiamasis - T3 1
1452350 | 2 a | 120 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452360 | 2 a | 300 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452370 | 2 a | 50 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1452404 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1452425 | 2 a | 208 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452434 | 2 a | 1635.06 | 7624 | vanduo karštas tiekiamasis - T3 1
1452437 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1452506 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1452528 | 2 a | 173 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452537 | 2 a | 94.2206 | 7624 | vanduo karštas tiekiamasis - T3 1
1452540 | 2 a | 65 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1452574 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1452599 | 2 a | 911.54 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452608 | 2 a | 63.8315 | 7624 | vanduo karštas tiekiamasis - T3 1
1452611 | 2 a | 105.962 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1452657 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1452677 | 2 a | 93.3598 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452686 | 2 a | 3116.26 | 7624 | vanduo karštas tiekiamasis - T3 1
1452689 | 2 a | 188.396 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1452719 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1452747 | 2 a | 388 | 7624 | vanduo karštas tiekiamasis - T3 1
1452756 | 2 a | 1260.64 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452759 | 2 a | 814 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1452775 | 2 a | 87.3539 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1452813 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1452915 | 2 a | 10388 | 3487 | vanduo karštas apytakinis - T4 1
1452934 | 1 a +-152.84 | 4326.72 | 3474.5 | vanduo karštas apytakinis - T4 1
1452966 | 2 a | 455.5 | 3487 | vanduo karštas apytakinis - T4 1
1452998 | 2 a | 4134 | 3526 | vanduo karštas apytakinis - T4 1
1453142 | 2 a | 69.3586 | 3487 | vanduo karštas apytakinis - T4 1
1453152 | 2 a | 283 | 3487 | vanduo karštas apytakinis - T4 1
1453160 | 2 a | 30848 | 3487 | vanduo karštas apytakinis - T4 1
1453178 | 2 a | 588 | 3487 | vanduo karštas apytakinis - T4 1
1453186 | 2 a | 1008 | 3487 | vanduo karštas apytakinis - T4 1
1453196 | 2 a | 468 | 3487 | vanduo karštas apytakinis - T4 1
1453204 | 2 a | 213 | 3487 | vanduo karštas apytakinis - T4 1
1453222 | 2 a | 239.105 | 3487 | vanduo karštas apytakinis - T4 1
1453297 | 2 a | 174 | 3487 | vanduo karštas apytakinis - T4 1
1453324 | 2 a | 144 | 3492.3 | vanduo karštas apytakinis - T4 1
1453337 | 2 a | 169.641 | 3487 | vanduo karštas apytakinis - T4 1
1453340 | 2 a | 795 | 3492.3 | vanduo karštas apytakinis - T4 1
1453350 | 2 a | 3183.9 | 3492.3 | vanduo karštas apytakinis - T4 1
1453365 | 2 a | 4094 | 3520 | vanduo karštas apytakinis - T4 1
1453368 | 2 a | 6.45966 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453386 | 2 a | 2640 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1453401 | 1 a +-152.84 | 28755.6 | 3530 | vanduo karštas tiekiamasis - T3 1
1453406 | 2 a | 112.801 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1453468 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1453555 | 2 a | 2740 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1453564 | 1 a +-152.84 | 1487.31 | 3530 | vanduo karštas tiekiamasis - T3 1
1453569 | 2 a | 64.1192 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1453616 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1453691 | 2 a | 1510 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453708 | 2 a | 679.028 | 7618 | vanduo karštas tiekiamasis - T3 1
1453711 | 2 a | 327.548 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453721 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1453763 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1453799 | 2 a | 405 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453806 | 2 a | 352.452 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453809 | 2 a | 139.522 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1453857 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1453881 | 2 a | 180 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453894 | 2 a | 1251.95 | 7618 | vanduo karštas tiekiamasis - T3 1
1453897 | 2 a | 54.5224 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1453935 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1453965 | 2 a | 125 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1453976 | 2 a | 804.938 | 7618 | vanduo karštas tiekiamasis - T3 1
1453979 | 2 a | 40 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1454022 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1454049 | 2 a | 135 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454062 | 2 a | 401.863 | 7618 | vanduo karštas tiekiamasis - T3 1
1454065 | 2 a | 45 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454101 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454125 | 2 a | 372.298 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454142 | 2 a | 3025.27 | 7618 | vanduo karštas tiekiamasis - T3 1
1454145 | 2 a | 280 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454158 | 2 a | 100 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454166 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454206 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454230 | 2 a | 200 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454239 | 2 a | 1081.37 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454242 | 2 a | 90 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454278 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454303 | 2 a | 220 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454312 | 2 a | 296.336 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454315 | 2 a | 77.2219 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454354 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454376 | 2 a | 135 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454389 | 2 a | 4797.92 | 7618 | vanduo karštas tiekiamasis - T3 1
1454392 | 2 a | 60 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1454428 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1454461 | 2 a | 1223.51 | 7618 | vanduo karštas tiekiamasis - T3 1
1454464 | 2 a | 182.212 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454521 | 2 a | 180 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454531 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454578 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454605 | 2 a | 140 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454614 | 2 a | 1505.58 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454617 | 2 a | 90 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454662 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454684 | 2 a | 1740 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454693 | 2 a | 182.212 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454696 | 2 a | 1596.02 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454707 | 2 a | 140 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454717 | 2 a | 160 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454758 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454795 | 2 a | 343.978 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454804 | 2 a | 303.117 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454827 | 2 a | 408.557 | 7621 | vanduo karštas tiekiamasis - T3 1
1454846 | 2 a | 997.518 | 7618 | vanduo karštas tiekiamasis - T3 1
1454849 | 2 a | 49.748 | 7624 | vanduo karštas tiekiamasis - T3 1
1454873 | 2 a | 1774.52 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454887 | 2 a | 235 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454900 | 2 a | 115 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1454964 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1454986 | 2 a | 220 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454995 | 2 a | 1124.48 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1454998 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455035 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455057 | 2 a | 172 | 7624 | vanduo karštas tiekiamasis - T3 1
1455066 | 2 a | 3776.44 | 7621 | vanduo karštas tiekiamasis - T3 1
1455069 | 2 a | 90.0348 | 4990 | vanduo karštas tiekiamasis - T3 1
1455096 | 2 a | 2590 | 5022 | vanduo karštas tiekiamasis - T3 1
1455116 | 2 a | 38 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455125 | 2 a | 646.252 | 7624 | vanduo karštas tiekiamasis - T3 1
1455128 | 2 a | 663.736 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455138 | 2 a | 180 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455191 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455213 | 2 a | 330 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455222 | 2 a | 1501.26 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455225 | 2 a | 65 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455255 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455279 | 2 a | 130 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455290 | 2 a | 1145.77 | 7618 | vanduo karštas tiekiamasis - T3 1
1455293 | 2 a | 60 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1455322 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1455346 | 2 a | 319.143 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455363 | 2 a | 3784.67 | 7618 | vanduo karštas tiekiamasis - T3 1
1455366 | 2 a | 160 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455376 | 2 a | 120 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455384 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455425 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455449 | 2 a | 190 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455458 | 2 a | 1430.86 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455461 | 2 a | 75 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455493 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455515 | 2 a | 540 | 7692.3 | vanduo šaltas - V1 2
1455524 | 2 a | 82.1522 | 7692.3 | vanduo šaltas - V1 2
1455527 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1455562 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1455584 | 2 a | 150 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455603 | 2 a | 840.935 | 7618 | vanduo karštas tiekiamasis - T3 1
1455606 | 2 a | 417.827 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455616 | 2 a | 72.7898 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455658 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455680 | 2 a | 408.354 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455689 | 2 a | 102.173 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455692 | 2 a | 30 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455705 | 2 a | 90 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455734 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455758 | 2 a | 360 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455767 | 2 a | 1341.65 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455770 | 2 a | 60 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1455802 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1455824 | 2 a | 125 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455837 | 2 a | 462.658 | 7618 | vanduo karštas tiekiamasis - T3 1
1455840 | 2 a | 74.5224 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1455882 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1455915 | 2 a | 454.496 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455926 | 2 a | 1957.33 | 7618 | vanduo karštas tiekiamasis - T3 1
1455929 | 2 a | 200 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455939 | 2 a | 100 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1455950 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456002 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456024 | 2 a | 240 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456033 | 2 a | 1515.5 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456036 | 2 a | 120.73 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456077 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456099 | 2 a | 135 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456112 | 2 a | 986.524 | 7618 | vanduo karštas tiekiamasis - T3 1
1456115 | 2 a | 57.5 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1456159 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1456183 | 2 a | 2299.98 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456194 | 2 a | 109.782 | 7618 | vanduo karštas tiekiamasis - T3 1
1456197 | 2 a | 280 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456207 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456243 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456265 | 2 a | 320 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456274 | 2 a | 2124.55 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456277 | 2 a | 60 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456285 | 2 a | 125 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1456321 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1456348 | 2 a | 115 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456357 | 2 a | 1605.47 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456360 | 2 a | 70.9529 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456400 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456431 | 2 a | 60 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456442 | 2 a | 2075.7 | 7618 | vanduo karštas tiekiamasis - T3 1
1456445 | 2 a | 111.64 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456491 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456511 | 2 a | 1558.89 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456526 | 2 a | 69.0455 | 7618 | vanduo karštas tiekiamasis - T3 1
1456529 | 2 a | 800 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456539 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456570 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456592 | 2 a | 320 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456601 | 2 a | 1671.11 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456604 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456638 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456660 | 2 a | 1061.45 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456671 | 2 a | 540.913 | 7618 | vanduo karštas tiekiamasis - T3 1
1456674 | 2 a | 320.538 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456682 | 2 a | 220 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456701 | 2 a | 160 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456709 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456739 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456772 | 2 a | 195 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456781 | 2 a | 1759.46 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456784 | 2 a | 85 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456818 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456845 | 2 a | 225 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456854 | 2 a | 388.554 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456857 | 2 a | 55 | 4792.3 | vanduo karštas tiekiamasis - T3 1
1456885 | 2 a | 2794 | 4820 | vanduo karštas tiekiamasis - T3 1
1456907 | 2 a | 1875 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456918 | 2 a | 447.255 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456921 | 2 a | 175 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1456931 | 2 a | 85 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1456970 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1456992 | 2 a | 35 | 4492.3 | vanduo karštas tiekiamasis - T3 1
1457001 | 2 a | 3094 | 4520 | vanduo karštas tiekiamasis - T3 1
1457004 | 2 a | 1472.74 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457075 | 2 a | 48 | 7624 | vanduo karštas tiekiamasis - T3 1
1457109 | 1 a +-152.84 | 243.501 | 7618 | vanduo karštas tiekiamasis - T3 1
1457112 | 2 a | 436 | 7624 | vanduo karštas tiekiamasis - T3 1
1457120 | 2 a | 966.468 | 7621 | vanduo karštas tiekiamasis - T3 1
1457146 | 2 a | 34 | 3492.3 | vanduo karštas apytakinis - T4 1
1457155 | 2 a | 73.8954 | 3487 | vanduo karštas apytakinis - T4 1
1457158 | 2 a | 535 | 3492.3 | vanduo karštas apytakinis - T4 1
1457166 | 2 a | 17495 | 3492.3 | vanduo karštas apytakinis - T4 1
1457201 | 2 a | 280 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457219 | 2 a | 80 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1457277 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1457301 | 2 a | 2264 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457310 | 2 a | 1286.52 | 7621 | vanduo karštas tiekiamasis - T3 1
1457313 | 2 a | 180 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457323 | 2 a | 57.5431 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1457370 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1457392 | 2 a | 45.7474 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457403 | 2 a | 168.547 | 7621 | vanduo karštas tiekiamasis - T3 1
1457406 | 2 a | 40 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457416 | 2 a | 6140 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457424 | 2 a | 15 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457437 | 2 a | 440 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457445 | 2 a | 60 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1457481 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1457505 | 2 a | 165 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457514 | 2 a | 2728.25 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457517 | 2 a | 260 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457525 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1457562 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1457586 | 2 a | 99 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457595 | 2 a | 133.297 | 7621 | vanduo karštas tiekiamasis - T3 1
1457598 | 2 a | 45 | 4792.3 | vanduo karštas tiekiamasis - T3 1
1457640 | 2 a | 2794 | 4820 | vanduo karštas tiekiamasis - T3 1
1457662 | 2 a | 145 | 7604.22 | vanduo šaltas - V1 2
1457671 | 2 a | 130.374 | 7604.22 | vanduo šaltas - V1 2
1457674 | 2 a | 65 | 4792.3 | vanduo šaltas - V1 2
1457704 | 2 a | 2753.22 | 4820 | vanduo šaltas - V1 2
1457730 | 2 a | 2209 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457749 | 2 a | 2321.61 | 7621 | vanduo karštas tiekiamasis - T3 1
1457752 | 2 a | 60 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457765 | 2 a | 150 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1457811 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1457848 | 2 a | 2279.77 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457865 | 2 a | 2619.39 | 7621 | vanduo karštas tiekiamasis - T3 1
1457868 | 2 a | 95 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1457896 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1457920 | 2 a | 220 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457929 | 2 a | 91.6898 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1457932 | 2 a | 125 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1457975 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1457997 | 2 a | 145 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458006 | 2 a | 1997.54 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458009 | 2 a | 50 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1458033 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1458097 | 2 a | 200 | 7606.52 | vanduo šaltas - V1 2
1458106 | 2 a | 1950.48 | 7606.52 | vanduo šaltas - V1 2
1458109 | 2 a | 4620 | 7606.52 | vanduo šaltas - V1 2
1458117 | 2 a | 120 | 7606.52 | vanduo šaltas - V1 2
1458127 | 2 a | 140 | 5142.3 | vanduo šaltas - V1 2
1458186 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1458224 | 2 a | 106.94 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458247 | 2 a | 2713.19 | 7621 | vanduo karštas tiekiamasis - T3 1
1458250 | 2 a | 220 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458260 | 2 a | 4840 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458274 | 2 a | 160 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458284 | 2 a | 160 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1458344 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1458375 | 2 a | 1707.06 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458378 | 2 a | 368.56 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458390 | 2 a | 200 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458398 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1458433 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1458453 | 2 a | 59 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458464 | 2 a | 333.575 | 7621 | vanduo karštas tiekiamasis - T3 1
1458467 | 2 a | 129.126 | 4792.3 | vanduo karštas tiekiamasis - T3 1
1458509 | 2 a | 2794 | 4820 | vanduo karštas tiekiamasis - T3 1
1458533 | 2 a | 72.8203 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458548 | 2 a | 1138.75 | 7621 | vanduo karštas tiekiamasis - T3 1
1458551 | 2 a | 70 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1458583 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1458608 | 2 a | 45 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458617 | 2 a | 2155.31 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458620 | 2 a | 55 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1458662 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1458687 | 2 a | 294 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458698 | 2 a | 3655.63 | 7621 | vanduo karštas tiekiamasis - T3 1
1458701 | 2 a | 54.1261 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1458782 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1458814 | 2 a | 5154 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458833 | 2 a | 78.9771 | 7621 | vanduo karštas tiekiamasis - T3 1
1458836 | 2 a | 425.308 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458852 | 2 a | 1860 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458866 | 2 a | 2620 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458876 | 2 a | 525 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458896 | 2 a | 310 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458912 | 2 a | 65 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1458953 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1458975 | 2 a | 107.037 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458984 | 2 a | 864.443 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1458987 | 2 a | 70 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459021 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1459074 | 2 a | 35 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459083 | 2 a | 1112.96 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459086 | 2 a | 201.163 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459094 | 2 a | 30 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459123 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1459197 | 2 a | 2680 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459210 | 2 a | 990.248 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459213 | 2 a | 205 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459223 | 2 a | 75 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459268 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1459292 | 2 a | 5330 | 7606.52 | vanduo šaltas - V1 2
1459307 | 2 a | 1384.82 | 7598.22 | vanduo šaltas - V1 2
1459310 | 2 a | 140 | 7606.52 | vanduo šaltas - V1 2
1459320 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1459357 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1459385 | 2 a | 5334 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459404 | 2 a | 1524.04 | 7621 | vanduo karštas tiekiamasis - T3 1
1459407 | 2 a | 215 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459417 | 2 a | 160 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459451 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1459473 | 2 a | 990.744 | 7624 | vanduo karštas tiekiamasis - T3 1
1459490 | 2 a | 662.569 | 7618 | vanduo karštas tiekiamasis - T3 1
1459493 | 2 a | 716 | 7624 | vanduo karštas tiekiamasis - T3 1
1459503 | 2 a | 138 | 4790 | vanduo karštas tiekiamasis - T3 1
1459557 | 2 a | 2790 | 4822 | vanduo karštas tiekiamasis - T3 1
1459579 | 2 a | 715 | 7624 | vanduo karštas tiekiamasis - T3 1
1459588 | 2 a | 393.395 | 7624 | vanduo karštas tiekiamasis - T3 1
1459591 | 2 a | 218 | 5140 | vanduo karštas tiekiamasis - T3 1
1459619 | 2 a | 2440 | 5172 | vanduo karštas tiekiamasis - T3 1
1459641 | 2 a | 131.209 | 7624 | vanduo karštas tiekiamasis - T3 1
1459650 | 2 a | 3051.86 | 7624 | vanduo karštas tiekiamasis - T3 1
1459653 | 2 a | 619 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459679 | 2 a | 65 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459727 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1459753 | 2 a | 395 | 7624 | vanduo karštas tiekiamasis - T3 1
1459762 | 2 a | 991.024 | 7624 | vanduo karštas tiekiamasis - T3 1
1459765 | 2 a | 696 | 7624 | vanduo karštas tiekiamasis - T3 1
1459775 | 2 a | 942.139 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459814 | 2 a | 80 | 4792.3 | vanduo karštas tiekiamasis - T3 1
1459842 | 2 a | 2794 | 4820 | vanduo karštas tiekiamasis - T3 1
1459862 | 2 a | 105 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459875 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1459878 | 2 a | 308.399 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459897 | 2 a | 3095 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459906 | 2 a | 328.462 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459909 | 2 a | 2355 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1459935 | 2 a | 130 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1459995 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460019 | 2 a | 1844.87 | 7624 | vanduo karštas tiekiamasis - T3 1
1460042 | 2 a | 4885.49 | 7618 | vanduo karštas tiekiamasis - T3 1
1460045 | 2 a | 119 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460065 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460116 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460138 | 2 a | 158 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460147 | 2 a | 1747.83 | 7624 | vanduo karštas tiekiamasis - T3 1
1460150 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460176 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460198 | 2 a | 1118 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460207 | 2 a | 3715.3 | 7624 | vanduo karštas tiekiamasis - T3 1
1460210 | 2 a | 140 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1460248 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1460270 | 2 a | 963 | 7624 | vanduo karštas tiekiamasis - T3 1
1460283 | 2 a | 329.628 | 7618 | vanduo karštas tiekiamasis - T3 1
1460286 | 2 a | 576 | 7624 | vanduo karštas tiekiamasis - T3 1
1460296 | 2 a | 3076 | 7624 | vanduo karštas tiekiamasis - T3 1
1460318 | 2 a | 316.28 | 7624 | vanduo karštas tiekiamasis - T3 1
1460340 | 2 a | 19 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460362 | 2 a | 300 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460372 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460408 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460432 | 2 a | 243 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460441 | 2 a | 810.397 | 7624 | vanduo karštas tiekiamasis - T3 1
1460444 | 2 a | 60 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1460492 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1460516 | 2 a | 48.3164 | 7624 | vanduo karštas tiekiamasis - T3 1
1460531 | 2 a | 1493.05 | 7624 | vanduo karštas tiekiamasis - T3 1
1460534 | 2 a | 279 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460551 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460583 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460605 | 2 a | 258 | 7626.3 | vanduo karštas tiekiamasis - T3 1
1460614 | 2 a | 1684.13 | 7624 | vanduo karštas tiekiamasis - T3 1
1460617 | 2 a | 80 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460664 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460686 | 2 a | 228 | 7624 | vanduo karštas tiekiamasis - T3 1
1460695 | 2 a | 1242.13 | 7624 | vanduo karštas tiekiamasis - T3 1
1460698 | 2 a | 70 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460733 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460757 | 2 a | 293 | 7624 | vanduo karštas tiekiamasis - T3 1
1460766 | 2 a | 68.431 | 7624 | vanduo karštas tiekiamasis - T3 1
1460769 | 2 a | 73.8424 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1460809 | 2 a | 2444 | 5170 | vanduo karštas tiekiamasis - T3 1
1460842 | 2 a | 233 | 7624 | vanduo karštas tiekiamasis - T3 1
1460851 | 2 a | 284.272 | 7624 | vanduo karštas tiekiamasis - T3 1
1460913 | 2 a | 65 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1460922 | 2 a | 2294 | 5320 | vanduo karštas tiekiamasis - T3 1
1461036 | 2 a | 4140.44 | 3550 | vanduo karštas tiekiamasis - T3 1
1461049 | 1 a +-152.84 | 443.409 | 3530 | vanduo karštas tiekiamasis - T3 1
1461064 | 2 a | 1325.14 | 3550 | vanduo karštas tiekiamasis - T3 1
1461074 | 2 a | 504 | 3550 | vanduo karštas tiekiamasis - T3 1
1461102 | 2 a | 65 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1461156 | 2 a | 1700 | 3580 | vanduo karštas tiekiamasis - T3 1
1461186 | 2 a | 51.1649 | 3550 | vanduo karštas tiekiamasis - T3 1
1461195 | 2 a | 5731.56 | 3550 | vanduo karštas tiekiamasis - T3 1
1461198 | 2 a | 2359 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461226 | 2 a | 820 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461236 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1461270 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1461295 | 2 a | 95 | 3550 | vanduo karštas tiekiamasis - T3 1
1461308 | 2 a | 506.177 | 3550 | vanduo karštas tiekiamasis - T3 1
1461311 | 2 a | 256 | 3550 | vanduo karštas tiekiamasis - T3 1
1461321 | 2 a | 919 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461340 | 2 a | 60 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1461380 | 2 a | 1700 | 3580 | vanduo karštas tiekiamasis - T3 1
1461404 | 2 a | 590.27 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461415 | 2 a | 543.858 | 3550 | vanduo karštas tiekiamasis - T3 1
1461418 | 2 a | 380 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461428 | 2 a | 113.088 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1461451 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1461473 | 2 a | 538 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461484 | 2 a | 507.8 | 3550 | vanduo karštas tiekiamasis - T3 1
1461487 | 2 a | 200 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461497 | 2 a | 78.1448 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1461534 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1461562 | 2 a | 1087.5 | 3550 | vanduo karštas tiekiamasis - T3 1
1461571 | 2 a | 504.857 | 3550 | vanduo karštas tiekiamasis - T3 1
1461584 | 2 a | 396 | 3550 | vanduo karštas tiekiamasis - T3 1
1461606 | 2 a | 459 | 3550 | vanduo karštas tiekiamasis - T3 1
1461614 | 2 a | 160.881 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1461641 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1461667 | 2 a | 38 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1461676 | 2 a | 1087.5 | 3550 | vanduo karštas tiekiamasis - T3 1
1461679 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1461710 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1461806 | 1 a +-152.84 | 463 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1461815 | 1 a +-152.84 | 4055.44 | 3599 | vanduo karštas tiekiamasis - T3 1
1461841 | 2 a | 216 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1461851 | 2 a | 476 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1461859 | 2 a | 31.819 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1461871 | 2 a | 5968.29 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1461881 | 2 a | 350.931 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1461902 | 2 a | 1120 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1461910 | 2 a | 200 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1461940 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1461968 | 2 a | 540 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1461979 | 2 a | 212.811 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1461982 | 2 a | 53.8188 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462025 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462049 | 2 a | 500 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462056 | 2 a | 295.258 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462059 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462089 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462157 | 2 a | 178 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462166 | 2 a | 487.709 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462169 | 2 a | 140.611 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462209 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462249 | 2 a | 298 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462256 | 2 a | 3537.12 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462259 | 2 a | 100 | 5292.3 | vanduo karštas tiekiamasis - T3 1
1462303 | 2 a | 2348.44 | 5320 | vanduo karštas tiekiamasis - T3 1
1462327 | 2 a | 78.865 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462346 | 2 a | 675.06 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462349 | 2 a | 4794 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462363 | 2 a | 4040 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462371 | 2 a | 5580 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462397 | 2 a | 840 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462410 | 2 a | 660 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462420 | 2 a | 140 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462460 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462482 | 2 a | 680 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462491 | 2 a | 758.963 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462494 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462532 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462554 | 2 a | 640 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462563 | 2 a | 41.0369 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462566 | 2 a | 82.1138 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462602 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462624 | 2 a | 1055 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462633 | 2 a | 208.379 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462636 | 2 a | 110.984 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462685 | 2 a | 2494.44 | 5172 | vanduo karštas tiekiamasis - T3 1
1462731 | 2 a | 978 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462742 | 2 a | 1236.23 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462745 | 2 a | 140 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462753 | 2 a | 200 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462772 | 2 a | 100 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462819 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1462841 | 2 a | 1178 | 7680.73 | vanduo karštas tiekiamasis - T3 1
1462850 | 2 a | 1185.52 | 7678.43 | vanduo karštas tiekiamasis - T3 1
1462853 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1462886 | 2 a | 2498.44 | 5170 | vanduo karštas tiekiamasis - T3 1
1463032 | 1 a +-152.84 | 5889.13 | 3530 | vanduo karštas tiekiamasis - T3 1
1463037 | 2 a | 3353 | 3550 | vanduo karštas tiekiamasis - T3 1
1463085 | 2 a | 3777.45 | 3550 | vanduo karštas tiekiamasis - T3 1
1463093 | 2 a | 101.851 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1463126 | 2 a | 1529 | 3601 | vanduo karštas tiekiamasis - T3 1
1463170 | 2 a | 178.425 | 4792.3 | vanduo karštas tiekiamasis - T3 1
1463181 | 2 a | 1198 | 3582 | vanduo karštas tiekiamasis - T3 1
1463184 | 2 a | 745.789 | 3550 | vanduo karštas tiekiamasis - T3 1
1463211 | 2 a | 53 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1463220 | 2 a | 1712.76 | 3550 | vanduo karštas tiekiamasis - T3 1
1463223 | 2 a | 103.425 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1463260 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1463282 | 2 a | 1992 | 3550 | vanduo karštas tiekiamasis - T3 1
1463293 | 1 a +-152.84 | 261.885 | 3539.5 | vanduo karštas tiekiamasis - T3 1
1463298 | 2 a | 171 | 3550 | vanduo karštas tiekiamasis - T3 1
1463308 | 2 a | 74.5 | 5140 | vanduo karštas tiekiamasis - T3 1
1463333 | 2 a | 1546 | 3582 | vanduo karštas tiekiamasis - T3 1
1463363 | 2 a | 900 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1463404 | 1 a +-152.84 | 87.1059 | 3539.5 | vanduo karštas tiekiamasis - T3 1
1463411 | 2 a | 120 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1463441 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1463484 | 2 a | 1622 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1463493 | 2 a | 131.841 | 7837.68 | vanduo karštas tiekiamasis - T3 1
1463524 | 2 a | 14040 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1463533 | 1 a +-152.84 | 1485.63 | 3530 | vanduo karštas tiekiamasis - T3 1
1463538 | 2 a | 1740 | 3552.3 | vanduo karštas tiekiamasis - T3 1
1463611 | 2 a | 160 | 5142.3 | vanduo karštas tiekiamasis - T3 1
1463640 | 2 a | 1550 | 3580 | vanduo karštas tiekiamasis - T3 1
1463696 | 2 a | 1069.3 | 7812.3 | vanduo karštas tiekiamasis - T3 1
1463788 | 1 a +-152.84 | 533.56 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1463828 | 3 a | 100.336 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1463856 | 3 a | 228 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1463864 | 3 a | 3348 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1463876 | 3 a | 2246.17 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1463888 | 3 a | 377.157 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1463900 | 3 a | 3680 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1463945 | 3 a | 80 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1463958 | 3 a | 180 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1463969 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464029 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1464051 | 3 a | 4894 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464066 | 3 a | 6204.33 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1464069 | 3 a | 280 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464079 | 3 a | 460 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464087 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464145 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1464184 | 3 a | 1185.49 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464197 | 3 a | 133.517 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1464200 | 3 a | 180 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464213 | 3 a | 460 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464221 | 3 a | 80 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464277 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1464301 | 3 a | 140 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464312 | 3 a | 1328.51 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464315 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464358 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1464382 | 3 a | 125.992 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464391 | 3 a | 6541.83 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1464394 | 3 a | 106.187 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464443 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1464463 | 3 a | 133.813 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464474 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1464477 | 3 a | 1608.01 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464632 | 1 a +-152.84 | 4828.69 | 7722.44 | vanduo karštas tiekiamasis - T3 1
1464666 | 1 a +-152.84 | 8978 | 3529 | vanduo karštas apytakinis - T4 1
1464738 | 3 a | 750 | 12499.3 | vanduo karštas apytakinis - T4 1
1464746 | 3 a | 400 | 12499.3 | vanduo karštas apytakinis - T4 1
1464759 | 3 a | 240 | 12499.3 | vanduo karštas apytakinis - T4 1
1464773 | 3 a | 3209.81 | 12499.3 | vanduo karštas apytakinis - T4 1
1464785 | 3 a | 8960 | 12499.3 | vanduo karštas apytakinis - T4 1
1464804 | 3 a | 6920 | 12499.3 | vanduo karštas apytakinis - T4 1
1464817 | 3 a | 120 | 12499.3 | vanduo karštas apytakinis - T4 1
1464870 | 3 a | 3456.04 | 12575.1 | vanduo karštas tiekiamasis - T3 1
1464892 | 3 a | 6818 | 12575.1 | vanduo karštas tiekiamasis - T3 1
1464902 | 3 a | 938 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1464932 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1464978 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1465017 | 3 a | 1040 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1465027 | 3 a | 115 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1465106 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1465130 | 3 a | 338 | 12575.1 | vanduo karštas tiekiamasis - T3 1
1465139 | 3 a | 1744.96 | 12575.1 | vanduo karštas tiekiamasis - T3 1
1465142 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1465183 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1465230 | 3 a | 5360 | 12499.3 | vanduo karštas apytakinis - T4 1
1465244 | 3 a | 6920 | 12499.3 | vanduo karštas apytakinis - T4 1
1465274 | 3 a | 1674 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1465289 | 3 a | 125.662 | 12572.1 | vanduo karštas tiekiamasis - T3 1
1465292 | 3 a | 80 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1465302 | 3 a | 1040 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1465313 | 3 a | 220 | 12577.4 | vanduo karštas tiekiamasis - T3 1
1465323 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1465367 | 3 a | 2595.13 | 9970 | vanduo karštas tiekiamasis - T3 1
1465409 | 1 a +-152.84 | 688 | 12350 | vanduo karštas tiekiamasis - T3 1
1465475 | 2 a | 3823 | 3487 | vanduo karštas apytakinis - T4 1
1465484 | 1 a +-152.84 | 8706.3 | 3474.5 | vanduo karštas apytakinis - T4 1
1465560 | 2 a | 47.6936 | 12243.3 | vanduo karštas apytakinis - T4 1
1465600 | 2 a | 710 | 12322.3 | vanduo karštas apytakinis - T4 1
1465631 | 3 a | 151.462 | 12350 | vanduo karštas tiekiamasis - T3 1
1465649 | 3 a | 4567.59 | 12350 | vanduo karštas tiekiamasis - T3 1
1465657 | 3 a | 2120 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465671 | 3 a | 134.069 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465679 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1465725 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1465749 | 3 a | 1614 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465758 | 3 a | 2374.35 | 12350 | vanduo karštas tiekiamasis - T3 1
1465761 | 3 a | 340 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465769 | 3 a | 98.7884 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1465820 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1465873 | 3 a | 1375.63 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465882 | 3 a | 571.113 | 12350 | vanduo karštas tiekiamasis - T3 1
1465885 | 3 a | 70 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465893 | 3 a | 130 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1465931 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1465958 | 3 a | 115 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465965 | 3 a | 713.373 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1465968 | 3 a | 160 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466021 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466043 | 3 a | 299 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466054 | 3 a | 65.1581 | 12350 | vanduo karštas tiekiamasis - T3 1
1466057 | 3 a | 145 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466109 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466134 | 3 a | 509 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466143 | 3 a | 1116.79 | 12350 | vanduo karštas tiekiamasis - T3 1
1466146 | 3 a | 35 | 10092.3 | vanduo karštas tiekiamasis - T3 1
1466194 | 3 a | 2223.05 | 10120 | vanduo karštas tiekiamasis - T3 1
1466244 | 3 a | 304.14 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466254 | 3 a | 80 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466265 | 3 a | 100.458 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466301 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466367 | 3 a | 2240 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466384 | 3 a | 4275.86 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466387 | 3 a | 460 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466397 | 3 a | 91.6205 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466460 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466482 | 3 a | 1814 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466495 | 3 a | 209.092 | 12350 | vanduo karštas tiekiamasis - T3 1
1466498 | 3 a | 280 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466510 | 3 a | 89.5522 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466559 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466581 | 3 a | 600 | 12322.3 | vanduo karštas apytakinis - T4 1
1466591 | 3 a | 4608.47 | 12322.3 | vanduo karštas apytakinis - T4 1
1466599 | 3 a | 2084 | 12322.3 | vanduo karštas apytakinis - T4 1
1466660 | 3 a | 6224 | 12322.3 | vanduo karštas apytakinis - T4 1
1466669 | 3 a | 4271.53 | 12322.3 | vanduo karštas apytakinis - T4 1
1466672 | 3 a | 20 | 12322.3 | vanduo karštas apytakinis - T4 1
1466720 | 3 a | 14 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466737 | 3 a | 87.4462 | 12350 | vanduo karštas tiekiamasis - T3 1
1466740 | 3 a | 140 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466750 | 3 a | 85 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466758 | 3 a | 3000 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466768 | 3 a | 4260 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466776 | 3 a | 255 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466786 | 3 a | 105 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466827 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466861 | 3 a | 2780 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466875 | 3 a | 260 | 12355.3 | vanduo karštas tiekiamasis - T3 1
1466885 | 3 a | 160 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1466925 | 3 a | 2373.05 | 9970 | vanduo karštas tiekiamasis - T3 1
1466961 | 1 a +-152.84 | 4197 | 3676 | vanduo karštas apytakinis - T4 1
1467004 | 1 a +-152.84 | 499.874 | 3474.5 | vanduo karštas apytakinis - T4 1
1467009 | 1 a +-152.84 | 676.729 | 7885 | vanduo karštas apytakinis - T4 1
1467077 | 2 a | 8018 | 7885 | vanduo karštas apytakinis - T4 1
1467192 | 3 a | 3873 | 7907 | vanduo karštas tiekiamasis - T3 1
1467205 | 2 a | 94.1634 | 7907 | vanduo karštas tiekiamasis - T3 1
1467208 | 3 a | 302.685 | 7907 | vanduo karštas tiekiamasis - T3 1
1467240 | 3 a | 2588 | 7907 | vanduo karštas tiekiamasis - T3 1
1467252 | 3 a | 92.3071 | 7907 | vanduo karštas tiekiamasis - T3 1
1467260 | 3 a | 331 | 7907 | vanduo karštas tiekiamasis - T3 1
1467270 | 3 a | 66.3799 | 7910 | vanduo karštas tiekiamasis - T3 1
1467340 | 3 a | 1936 | 7910 | vanduo karštas tiekiamasis - T3 1
1467350 | 3 a | 823.485 | 7910 | vanduo karštas tiekiamasis - T3 1
1467358 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1467403 | 3 a | 1969 | 7961 | vanduo karštas tiekiamasis - T3 1
1467520 | 3 a | 95 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1467531 | 3 a | 1988 | 7942 | vanduo karštas tiekiamasis - T3 1
1467534 | 3 a | 876.904 | 7910 | vanduo karštas tiekiamasis - T3 1
1467553 | 3 a | 155 | 7910 | vanduo karštas tiekiamasis - T3 1
1467562 | 3 a | 431.415 | 7910 | vanduo karštas tiekiamasis - T3 1
1467565 | 3 a | 713.583 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1467581 | 3 a | 160 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1467591 | 3 a | 85 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1467657 | 3 a | 1990 | 7940 | vanduo karštas tiekiamasis - T3 1
1467679 | 3 a | 545 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1467688 | 3 a | 1145.42 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1467691 | 3 a | 275 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1467699 | 3 a | 50 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1467743 | 3 a | 1990 | 7940 | vanduo karštas tiekiamasis - T3 1
1467767 | 3 a | 117.516 | 10090 | vanduo karštas tiekiamasis - T3 1
1467778 | 3 a | 2135 | 7943 | vanduo karštas tiekiamasis - T3 1
1467781 | 3 a | 1182.2 | 7910 | vanduo karštas tiekiamasis - T3 1
1467835 | 3 a | 52 | 7912.3 | vanduo karštas tiekiamasis - T3 1
1467937 | 3 a | 80 | 10092.3 | vanduo karštas tiekiamasis - T3 1
1467946 | 3 a | 2140 | 7940 | vanduo karštas tiekiamasis - T3 1
1468031 | 3 a | 4025 | 7885 | vanduo karštas apytakinis - T4 1
1468040 | 1 a +-152.84 | 233.271 | 7885 | vanduo karštas apytakinis - T4 1
1468043 | 3 a | 315 | 7885 | vanduo karštas apytakinis - T4 1
1468051 | 3 a | 2885 | 7885 | vanduo karštas apytakinis - T4 1
1468069 | 3 a | 1756 | 7885 | vanduo karštas apytakinis - T4 1
1468087 | 3 a | 1968 | 7885 | vanduo karštas apytakinis - T4 1
1468196 | 1 a +-152.84 | 18 | 12799.3 | vanduo karštas tiekiamasis - T3 1
1468209 | 1 a +-152.84 | 9167.29 | 3611 | vanduo karštas tiekiamasis - T3 1
1468345 | 3 a | 68 | 12799.3 | vanduo karštas tiekiamasis - T3 1
1468674 | 1 a +-152.84 | 288 | 12915.2 | vanduo karštas apytakinis - T4 1
1468718 | 1 a +-152.84 | 9368.16 | 3534 | vanduo karštas apytakinis - T4 1
1468724 | 3 a | 136 | 12915.2 | vanduo karštas apytakinis - T4 1
1468758 | 3 a | 3548 | 12799.3 | vanduo karštas tiekiamasis - T3 1
1468764 | 3 a | 596.306 | 12799.3 | vanduo karštas tiekiamasis - T3 1
1468774 | 3 a | 280 | 12804.6 | vanduo karštas tiekiamasis - T3 1
1468810 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1468852 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 1
1468874 | 3 a | 264 | 12804.6 | vanduo karštas tiekiamasis - T3 1
1468887 | 3 a | 1543.2 | 12799.3 | vanduo karštas tiekiamasis - T3 1
1468890 | 3 a | 90 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1468925 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 1
1468960 | 3 a | 4154 | 12804.6 | vanduo karštas tiekiamasis - T3 1
1468981 | 3 a | 195.495 | 12799.3 | vanduo karštas tiekiamasis - T3 1
1468984 | 3 a | 100 | 12804.6 | vanduo karštas tiekiamasis - T3 1
1469005 | 3 a | 160 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1469061 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 1
1469134 | 3 a | 1038 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469178 | 3 a | 91 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469188 | 3 a | 193.015 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469202 | 3 a | 702.564 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469210 | 3 a | 419 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469242 | 3 a | 80 | 9942.3 | vanduo karštas tiekiamasis - T3 11
1469282 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469318 | 3 a | 438 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469329 | 3 a | 275.144 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469332 | 3 a | 80 | 9942.3 | vanduo karštas tiekiamasis - T3 11
1469373 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469401 | 3 a | 638 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469410 | 3 a | 1378.29 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469413 | 3 a | 730.302 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469421 | 3 a | 120 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469431 | 3 a | 75.6318 | 9942.3 | vanduo karštas tiekiamasis - T3 11
1469486 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469510 | 3 a | 110 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469519 | 3 a | 413.7 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469522 | 3 a | 55 | 9942.3 | vanduo karštas tiekiamasis - T3 11
