Properties of the parts of a building model (IFC2X3), part 41 of 57

# IfcFlowFitting: PIF_Tigris_Elbow_M-K_Wavin:Standard (3281)
Name (PIF_Tigris_Elbow_M-K_Wavin:Standard:...) | In | Group
1334853 | 4 a V1 | vanduo šaltas - V1 2
1334857 | 4 a V1 | vanduo šaltas - V1 2
1334938 | 4 a V1 | vanduo šaltas - V1 2
1334942 | 4 a V1 | vanduo šaltas - V1 2
1335232 | 4 a V1 | vanduo šaltas - V1 2
1335236 | 4 a V1 | vanduo šaltas - V1 2
1335315 | 4 a V1 | vanduo šaltas - V1 2
1335319 | 4 a V1 | vanduo šaltas - V1 2
1335391 | 4 a V1 | vanduo šaltas - V1 2
1335395 | 4 a V1 | vanduo šaltas - V1 2
1335469 | 4 a V1 | vanduo šaltas - V1 2
1335473 | 4 a V1 | vanduo šaltas - V1 2
1335541 | 4 a V1 | vanduo šaltas - V1 2
1335545 | 4 a V1 | vanduo šaltas - V1 2
1335625 | 4 a V1 | vanduo šaltas - V1 2
1335629 | 4 a V1 | vanduo šaltas - V1 2
1335667 | 4 a V1 | vanduo šaltas - V1 2
1335706 | 4 a V1 | vanduo šaltas - V1 2
1335708 | 4 a V1 | vanduo šaltas - V1 2
1335763 | 4 a V1 | vanduo šaltas - V1 2
1335837 | 4 a V1 | vanduo šaltas - V1 2
1335841 | 4 a V1 | vanduo šaltas - V1 2
1335879 | 4 a V1 | vanduo šaltas - V1 2
1335914 | 4 a V1 | vanduo šaltas - V1 2
1335918 | 4 a V1 | vanduo šaltas - V1 2
1335997 | 4 a V1 | vanduo šaltas - V1 2
1336001 | 4 a V1 | vanduo šaltas - V1 2
1336054 | 4 a V1 | vanduo šaltas - V1 2
1336058 | 4 a V1 | vanduo šaltas - V1 2
1336099 | 4 a V1 | vanduo šaltas - V1 2
1336118 | 4 a V1 | vanduo šaltas - V1 2
1336139 | 4 a V1 | vanduo šaltas - V1 2
1336143 | 4 a V1 | vanduo šaltas - V1 2
1336382 | 2 a | vanduo šaltas - V1 2
1336550 | 4 a V1 | vanduo šaltas - V1 2
1336594 | 4 a V1 | vanduo šaltas - V1 2
1336598 | 4 a V1 | vanduo šaltas - V1 2
1336636 | 4 a V1 | vanduo šaltas - V1 2
1336683 | 4 a V1 | vanduo šaltas - V1 2
1336687 | 4 a V1 | vanduo šaltas - V1 2
1336723 | 4 a V1 | vanduo šaltas - V1 2
1336758 | 4 a V1 | vanduo šaltas - V1 2
1336762 | 4 a V1 | vanduo šaltas - V1 2
1336804 | 4 a V1 | vanduo šaltas - V1 2
1336864 | 4 a V1 | vanduo šaltas - V1 2
1336868 | 4 a V1 | vanduo šaltas - V1 2
1336903 | 4 a V1 | vanduo šaltas - V1 2
1336921 | 4 a V1 | vanduo šaltas - V1 2
1336975 | 4 a V1 | vanduo šaltas - V1 2
1336977 | 4 a V1 | vanduo šaltas - V1 2
1337195 | 4 a V1 | vanduo šaltas - V1 2
1337238 | 4 a V1 | vanduo šaltas - V1 2
1337240 | 4 a V1 | vanduo šaltas - V1 2
1337314 | 4 a V1 | vanduo šaltas - V1 2
1337316 | 4 a V1 | vanduo šaltas - V1 2
1337423 | 4 a V1 | vanduo šaltas - V1 2
1337435 | 4 a V1 | vanduo šaltas - V1 2
1337468 | 4 a V1 | vanduo šaltas - V1 2
1337472 | 4 a V1 | vanduo šaltas - V1 2
1337538 | 4 a V1 | vanduo šaltas - V1 2
1337542 | 4 a V1 | vanduo šaltas - V1 2
1337617 | 4 a V1 | vanduo šaltas - V1 2
1337621 | 4 a V1 | vanduo šaltas - V1 2
1337657 | 4 a V1 | vanduo šaltas - V1 2
1337684 | 4 a V1 | vanduo šaltas - V1 2
1337727 | 4 a V1 | vanduo šaltas - V1 2
1337729 | 4 a V1 | vanduo šaltas - V1 2
1337792 | 4 a V1 | vanduo šaltas - V1 2
1337837 | 4 a V1 | vanduo šaltas - V1 2
1337841 | 4 a V1 | vanduo šaltas - V1 2
1337930 | 4 a V1 | vanduo šaltas - V1 2
1337934 | 4 a V1 | vanduo šaltas - V1 2
1338007 | 4 a V1 | vanduo šaltas - V1 2
1338009 | 4 a V1 | vanduo šaltas - V1 2
1338088 | 4 a V1 | vanduo šaltas - V1 2
1338090 | 4 a V1 | vanduo šaltas - V1 2
1338187 | 4 a V1 | vanduo šaltas - V1 2
1338191 | 4 a V1 | vanduo šaltas - V1 2
1338900 | 5 a V1 | vanduo šaltas - V1 2
1338964 | 5 a V1 | vanduo šaltas - V1 2
1338968 | 5 a V1 | vanduo šaltas - V1 2
1339073 | 5 a V1 | vanduo šaltas - V1 2
1339115 | 5 a V1 | vanduo šaltas - V1 2
1339119 | 5 a V1 | vanduo šaltas - V1 2
1339202 | 5 a V1 | vanduo šaltas - V1 2
1339247 | 5 a V1 | vanduo šaltas - V1 2
1339251 | 5 a V1 | vanduo šaltas - V1 2
1339313 | 5 a V1 | vanduo šaltas - V1 2
1339333 | 5 a V1 | vanduo šaltas - V1 2
1339433 | 5 a V1 | vanduo šaltas - V1 2
1339437 | 5 a V1 | vanduo šaltas - V1 2
1339545 | 5 a V1 | vanduo šaltas - V1 2
1339549 | 5 a V1 | vanduo šaltas - V1 2
1339580 | 5 a V1 | vanduo šaltas - V1 2
1339620 | 5 a V1 | vanduo šaltas - V1 2
1339663 | 5 a V1 | vanduo šaltas - V1 2
1339667 | 5 a V1 | vanduo šaltas - V1 2
1339826 | 2 a | vanduo šaltas - V1 2
1339838 | 4 a V1 | vanduo šaltas - V1 2
1339868 | 4 a V1 | vanduo šaltas - V1 2
1339872 | 4 a V1 | vanduo šaltas - V1 2
1339956 | 4 a V1 | vanduo šaltas - V1 2
1339960 | 4 a V1 | vanduo šaltas - V1 2
1340344 | 4 a V1 | vanduo šaltas - V1 2
1340348 | 4 a V1 | vanduo šaltas - V1 2
1340412 | 4 a V1 | vanduo šaltas - V1 2
1340416 | 4 a V1 | vanduo šaltas - V1 2
1340482 | 4 a V1 | vanduo šaltas - V1 2
1340486 | 4 a V1 | vanduo šaltas - V1 2
1340523 | 4 a V1 | vanduo šaltas - V1 2
1340539 | 4 a V1 | vanduo šaltas - V1 2
1340554 | 4 a V1 | vanduo šaltas - V1 2
1340661 | 4 a V1 | vanduo šaltas - V1 2
1340705 | 4 a V1 | vanduo šaltas - V1 2
1340707 | 4 a V1 | vanduo šaltas - V1 2
1340772 | 4 a V1 | vanduo šaltas - V1 2
1340776 | 4 a V1 | vanduo šaltas - V1 2
1340847 | 4 a V1 | vanduo šaltas - V1 2
1340851 | 4 a V1 | vanduo šaltas - V1 2
1340920 | 4 a V1 | vanduo šaltas - V1 2
1340924 | 4 a V1 | vanduo šaltas - V1 2
1340993 | 4 a V1 | vanduo šaltas - V1 2
1340997 | 4 a V1 | vanduo šaltas - V1 2
1341032 | 4 a V1 | vanduo šaltas - V1 2
1341042 | 4 a V1 | vanduo šaltas - V1 2
1341058 | 4 a V1 | vanduo šaltas - V1 2
1341072 | 4 a V1 | vanduo šaltas - V1 2
1341138 | 4 a V1 | vanduo šaltas - V1 2
1341142 | 4 a V1 | vanduo šaltas - V1 2
1341228 | 4 a V1 | vanduo šaltas - V1 2
1341232 | 4 a V1 | vanduo šaltas - V1 2
1341301 | 4 a V1 | vanduo šaltas - V1 2
1341305 | 4 a V1 | vanduo šaltas - V1 2
1341343 | 4 a V1 | vanduo šaltas - V1 2
1341358 | 4 a V1 | vanduo šaltas - V1 2
1341366 | 4 a V1 | vanduo šaltas - V1 2
1341376 | 4 a V1 | vanduo šaltas - V1 2
1341419 | 4 a V1 | vanduo šaltas - V1 2
1341423 | 4 a V1 | vanduo šaltas - V1 2
1341507 | 4 a V1 | vanduo šaltas - V1 2
1341511 | 4 a V1 | vanduo šaltas - V1 2
1341552 | 4 a V1 | vanduo šaltas - V1 2
1341587 | 4 a V1 | vanduo šaltas - V1 2
1341591 | 4 a V1 | vanduo šaltas - V1 2
1341895 | 2 a | vanduo šaltas - V1 2
1341905 | 4 a V1 | vanduo šaltas - V1 2
1342020 | 4 a V1 | vanduo šaltas - V1 2
1342024 | 4 a V1 | vanduo šaltas - V1 2
1342328 | 4 a V1 | vanduo šaltas - V1 2
1342332 | 4 a V1 | vanduo šaltas - V1 2
1342383 | 4 a V1 | vanduo šaltas - V1 2
1342426 | 4 a V1 | vanduo šaltas - V1 2
1342430 | 4 a V1 | vanduo šaltas - V1 2
1342494 | 4 a V1 | vanduo šaltas - V1 2
1342498 | 4 a V1 | vanduo šaltas - V1 2
1342588 | 4 a V1 | vanduo šaltas - V1 2
1342592 | 4 a V1 | vanduo šaltas - V1 2
1342659 | 4 a V1 | vanduo šaltas - V1 2
1342663 | 4 a V1 | vanduo šaltas - V1 2
1342773 | 4 a V1 | vanduo šaltas - V1 2
1342785 | 4 a V1 | vanduo šaltas - V1 2
1342824 | 4 a V1 | vanduo šaltas - V1 2
1342828 | 4 a V1 | vanduo šaltas - V1 2
1342923 | 4 a V1 | vanduo šaltas - V1 2
1342927 | 4 a V1 | vanduo šaltas - V1 2
1342994 | 4 a V1 | vanduo šaltas - V1 2
1342998 | 4 a V1 | vanduo šaltas - V1 2
1343028 | 4 a V1 | vanduo šaltas - V1 2
1343040 | 4 a V1 | vanduo šaltas - V1 2
1343121 | 4 a V1 | vanduo šaltas - V1 2
1343125 | 4 a V1 | vanduo šaltas - V1 2
1343179 | 4 a V1 | vanduo šaltas - V1 2
1343183 | 4 a V1 | vanduo šaltas - V1 2
1343247 | 4 a V1 | vanduo šaltas - V1 2
1343251 | 4 a V1 | vanduo šaltas - V1 2
1343313 | 4 a V1 | vanduo šaltas - V1 2
1343412 | 4 a V1 | vanduo šaltas - V1 2
1343463 | 4 a V1 | vanduo šaltas - V1 2
1343465 | 4 a V1 | vanduo šaltas - V1 2
1343553 | 4 a V1 | vanduo šaltas - V1 2
1343557 | 4 a V1 | vanduo šaltas - V1 2
1343626 | 4 a V1 | vanduo šaltas - V1 2
1343630 | 4 a V1 | vanduo šaltas - V1 2
1343747 | 4 a V1 | vanduo šaltas - V1 2
1343751 | 4 a V1 | vanduo šaltas - V1 2
1343810 | 4 a V1 | vanduo šaltas - V1 2
1343814 | 4 a V1 | vanduo šaltas - V1 2
1343871 | 4 a V1 | vanduo šaltas - V1 2
1343875 | 4 a V1 | vanduo šaltas - V1 2
1343937 | 4 a V1 | vanduo šaltas - V1 2
1343941 | 4 a V1 | vanduo šaltas - V1 2
1344098 | 2 a | vanduo šaltas - V1 2
1344207 | 2 a | vanduo šaltas - V1 2
1344573 | 5 a V1 | vanduo šaltas - V1 2
1344595 | 5 a V1 | vanduo šaltas - V1 2
1344611 | 5 a V1 | vanduo šaltas - V1 2
1344619 | 5 a V1 | vanduo šaltas - V1 2
1344641 | 5 a V1 | vanduo šaltas - V1 2
1344699 | 5 a V1 | vanduo šaltas - V1 2
1344703 | 5 a V1 | vanduo šaltas - V1 2
1344783 | 5 a V1 | vanduo šaltas - V1 2
1344787 | 5 a V1 | vanduo šaltas - V1 2
1344865 | 5 a V1 | vanduo šaltas - V1 2
1344867 | 5 a V1 | vanduo šaltas - V1 2
1344925 | 5 a V1 | vanduo šaltas - V1 2
1344984 | 5 a V1 | vanduo šaltas - V1 2
1345027 | 5 a V1 | vanduo šaltas - V1 2
1345031 | 5 a V1 | vanduo šaltas - V1 2
1345133 | 5 a V1 | vanduo šaltas - V1 2
1345137 | 5 a V1 | vanduo šaltas - V1 2
1345254 | 2 a | vanduo šaltas - V1 2
1345860 | 4 a V1 | vanduo šaltas - V1 2
1345908 | 4 a V1 | vanduo šaltas - V1 2
1345912 | 4 a V1 | vanduo šaltas - V1 2
1346025 | 4 a V1 | vanduo šaltas - V1 2
1346029 | 4 a V1 | vanduo šaltas - V1 2
1346134 | 4 a V1 | vanduo šaltas - V1 2
1346140 | 4 a V1 | vanduo šaltas - V1 2
1346373 | 4 a V1 | vanduo šaltas - V1 2
1346443 | 4 a V1 | vanduo šaltas - V1 2
1346451 | 4 a V1 | vanduo šaltas - V1 2
1346518 | 4 a V1 | vanduo šaltas - V1 2
1346522 | 4 a V1 | vanduo šaltas - V1 2
1346584 | 4 a V1 | vanduo šaltas - V1 2
1346588 | 4 a V1 | vanduo šaltas - V1 2
1346644 | 4 a V1 | vanduo šaltas - V1 2
1346648 | 4 a V1 | vanduo šaltas - V1 2
1346677 | 4 a V1 | vanduo šaltas - V1 2
1346720 | 4 a V1 | vanduo šaltas - V1 2
1346724 | 4 a V1 | vanduo šaltas - V1 2
1346804 | 4 a V1 | vanduo šaltas - V1 2
1346808 | 4 a V1 | vanduo šaltas - V1 2
1346884 | 4 a V1 | vanduo šaltas - V1 2
1346888 | 4 a V1 | vanduo šaltas - V1 2
1346954 | 4 a V1 | vanduo šaltas - V1 2
1346958 | 4 a V1 | vanduo šaltas - V1 2
1347020 | 4 a V1 | vanduo šaltas - V1 2
1347024 | 4 a V1 | vanduo šaltas - V1 2
1347052 | 4 a V1 | vanduo šaltas - V1 2
1347064 | 4 a V1 | vanduo šaltas - V1 2
1347099 | 4 a V1 | vanduo šaltas - V1 2
1347103 | 4 a V1 | vanduo šaltas - V1 2
1347141 | 4 a V1 | vanduo šaltas - V1 2
1347174 | 4 a V1 | vanduo šaltas - V1 2
1347178 | 4 a V1 | vanduo šaltas - V1 2
1347251 | 4 a V1 | vanduo šaltas - V1 2
1347255 | 4 a V1 | vanduo šaltas - V1 2
1347356 | 4 a V1 | vanduo šaltas - V1 2
1347360 | 4 a V1 | vanduo šaltas - V1 2
1347455 | 4 a V1 | vanduo šaltas - V1 2
1347457 | 4 a V1 | vanduo šaltas - V1 2
1347494 | 4 a V1 | vanduo šaltas - V1 2
1347504 | 4 a V1 | vanduo šaltas - V1 2
1347512 | 4 a V1 | vanduo šaltas - V1 2
1347563 | 4 a V1 | vanduo šaltas - V1 2
1347567 | 4 a V1 | vanduo šaltas - V1 2
1347671 | 4 a V1 | vanduo šaltas - V1 2
1347675 | 4 a V1 | vanduo šaltas - V1 2
1347732 | 4 a V1 | vanduo šaltas - V1 2
1347736 | 4 a V1 | vanduo šaltas - V1 2
1347796 | 4 a V1 | vanduo šaltas - V1 2
1347800 | 4 a V1 | vanduo šaltas - V1 2
1347878 | 4 a V1 | vanduo šaltas - V1 2
1347882 | 4 a V1 | vanduo šaltas - V1 2
1347959 | 4 a V1 | vanduo šaltas - V1 2
1347963 | 4 a V1 | vanduo šaltas - V1 2
1348030 | 4 a V1 | vanduo šaltas - V1 2
1348034 | 4 a V1 | vanduo šaltas - V1 2
1348109 | 4 a V1 | vanduo šaltas - V1 2
1348113 | 4 a V1 | vanduo šaltas - V1 2
1348155 | 4 a V1 | vanduo šaltas - V1 2
1348198 | 4 a V1 | vanduo šaltas - V1 2
1348202 | 4 a V1 | vanduo šaltas - V1 2
1348250 | 4 a V1 | vanduo šaltas - V1 2
1348287 | 4 a V1 | vanduo šaltas - V1 2
1348289 | 4 a V1 | vanduo šaltas - V1 2
1348352 | 4 a V1 | vanduo šaltas - V1 2
1348356 | 4 a V1 | vanduo šaltas - V1 2
1348422 | 4 a V1 | vanduo šaltas - V1 2
1348424 | 4 a V1 | vanduo šaltas - V1 2
1349420 | 4 a V1 | vanduo šaltas - V1 2
1349434 | 4 a V1 | vanduo šaltas - V1 2
1349475 | 4 a V1 | vanduo šaltas - V1 2
1349479 | 4 a V1 | vanduo šaltas - V1 2
1349556 | 4 a V1 | vanduo šaltas - V1 2
1349562 | 4 a V1 | vanduo šaltas - V1 2
1349668 | 4 a V1 | vanduo šaltas - V1 2
1349714 | 4 a V1 | vanduo šaltas - V1 2
1349718 | 4 a V1 | vanduo šaltas - V1 2
1349760 | 4 a V1 | vanduo šaltas - V1 2
1349793 | 4 a V1 | vanduo šaltas - V1 2
1349797 | 4 a V1 | vanduo šaltas - V1 2
1349965 | 4 a V1 | vanduo šaltas - V1 2
1349969 | 4 a V1 | vanduo šaltas - V1 2
1350042 | 4 a V1 | vanduo šaltas - V1 2
1350046 | 4 a V1 | vanduo šaltas - V1 2
1350138 | 4 a V1 | vanduo šaltas - V1 2
1350152 | 4 a V1 | vanduo šaltas - V1 2
1350162 | 4 a V1 | vanduo šaltas - V1 2
1350194 | 4 a V1 | vanduo šaltas - V1 2
1350198 | 4 a V1 | vanduo šaltas - V1 2
1350252 | 4 a V1 | vanduo šaltas - V1 2
1350256 | 4 a V1 | vanduo šaltas - V1 2
1350288 | 4 a V1 | vanduo šaltas - V1 2
1350320 | 4 a V1 | vanduo šaltas - V1 2
1350328 | 4 a V1 | vanduo šaltas - V1 2
1350371 | 4 a V1 | vanduo šaltas - V1 2
1350375 | 4 a V1 | vanduo šaltas - V1 2
1350468 | 4 a V1 | vanduo šaltas - V1 2
1350472 | 4 a V1 | vanduo šaltas - V1 2
1350541 | 4 a V1 | vanduo šaltas - V1 2
1350545 | 4 a V1 | vanduo šaltas - V1 2
1350674 | 4 a V1 | vanduo šaltas - V1 2
1350678 | 4 a V1 | vanduo šaltas - V1 2
1350837 | 4 a V1 | vanduo šaltas - V1 2
1350841 | 4 a V1 | vanduo šaltas - V1 2
1350969 | 4 a V1 | vanduo šaltas - V1 2
1350973 | 4 a V1 | vanduo šaltas - V1 2
1351038 | 4 a V1 | vanduo šaltas - V1 2
1351042 | 4 a V1 | vanduo šaltas - V1 2
1351112 | 4 a V1 | vanduo šaltas - V1 2
1351124 | 4 a V1 | vanduo šaltas - V1 2
1351163 | 4 a V1 | vanduo šaltas - V1 2
1351167 | 4 a V1 | vanduo šaltas - V1 2
1351226 | 4 a V1 | vanduo šaltas - V1 2
1351230 | 4 a V1 | vanduo šaltas - V1 2
1351303 | 4 a V1 | vanduo šaltas - V1 2
1351307 | 4 a V1 | vanduo šaltas - V1 2
1351370 | 4 a V1 | vanduo šaltas - V1 2
1351404 | 4 a V1 | vanduo šaltas - V1 2
1351408 | 4 a V1 | vanduo šaltas - V1 2
1351459 | 4 a V1 | vanduo šaltas - V1 2
1351498 | 4 a V1 | vanduo šaltas - V1 2
1351502 | 4 a V1 | vanduo šaltas - V1 2
1351547 | 4 a V1 | vanduo šaltas - V1 2
1351587 | 4 a V1 | vanduo šaltas - V1 2
1351591 | 4 a V1 | vanduo šaltas - V1 2
1351662 | 4 a V1 | vanduo šaltas - V1 2
1351668 | 4 a V1 | vanduo šaltas - V1 2
1351756 | 4 a V1 | vanduo šaltas - V1 2
1351760 | 4 a V1 | vanduo šaltas - V1 2
1351831 | 4 a V1 | vanduo šaltas - V1 2
1351867 | 4 a V1 | vanduo šaltas - V1 2
1351871 | 4 a V1 | vanduo šaltas - V1 2
1351942 | 4 a V1 | vanduo šaltas - V1 2
1351946 | 4 a V1 | vanduo šaltas - V1 2
1352196 | 4 a V1 | vanduo šaltas - V1 2
1352235 | 4 a V1 | vanduo šaltas - V1 2
1352239 | 4 a V1 | vanduo šaltas - V1 2
1352316 | 4 a V1 | vanduo šaltas - V1 2
1352353 | 4 a V1 | vanduo šaltas - V1 2
1352357 | 4 a V1 | vanduo šaltas - V1 2
1352536 | 2 a | vanduo šaltas - V1 2
1352687 | 4 a V1 | vanduo šaltas - V1 2
1352699 | 4 a V1 | vanduo šaltas - V1 2
1352745 | 4 a V1 | vanduo šaltas - V1 2
1352749 | 4 a V1 | vanduo šaltas - V1 2
1352874 | 4 a V1 | vanduo šaltas - V1 2
1352886 | 4 a V1 | vanduo šaltas - V1 2
1352894 | 4 a V1 | vanduo šaltas - V1 2
1352912 | 4 a V1 | vanduo šaltas - V1 2
1352963 | 4 a V1 | vanduo šaltas - V1 2
1352967 | 4 a V1 | vanduo šaltas - V1 2
1353050 | 4 a V1 | vanduo šaltas - V1 2
1353054 | 4 a V1 | vanduo šaltas - V1 2
1353136 | 4 a V1 | vanduo šaltas - V1 2
1353140 | 4 a V1 | vanduo šaltas - V1 2
1353363 | 4 a V1 | vanduo šaltas - V1 2
1353401 | 4 a V1 | vanduo šaltas - V1 2
1353405 | 4 a V1 | vanduo šaltas - V1 2
1353507 | 4 a V1 | vanduo šaltas - V1 2
1353511 | 4 a V1 | vanduo šaltas - V1 2
1353682 | 4 a V1 | vanduo šaltas - V1 2
1353686 | 4 a V1 | vanduo šaltas - V1 2
1353744 | 4 a V1 | vanduo šaltas - V1 2
1353776 | 4 a V1 | vanduo šaltas - V1 2
1353778 | 4 a V1 | vanduo šaltas - V1 2
1353815 | 4 a V1 | vanduo šaltas - V1 2
1353858 | 4 a V1 | vanduo šaltas - V1 2
1353862 | 4 a V1 | vanduo šaltas - V1 2
1353913 | 4 a V1 | vanduo šaltas - V1 2
1353939 | 4 a V1 | vanduo šaltas - V1 2
1353971 | 4 a V1 | vanduo šaltas - V1 2
1354014 | 4 a V1 | vanduo šaltas - V1 2
1354024 | 4 a V1 | vanduo šaltas - V1 2
1354052 | 4 a V1 | vanduo šaltas - V1 2
1354054 | 4 a V1 | vanduo šaltas - V1 2
1354121 | 4 a V1 | vanduo šaltas - V1 2
1354176 | 4 a V1 | vanduo šaltas - V1 2
1354210 | 4 a V1 | vanduo šaltas - V1 2
1354214 | 4 a V1 | vanduo šaltas - V1 2
1354299 | 4 a V1 | vanduo šaltas - V1 2
1354301 | 4 a V1 | vanduo šaltas - V1 2
1354354 | 4 a V1 | vanduo šaltas - V1 2
1354356 | 4 a V1 | vanduo šaltas - V1 2
1354392 | 4 a V1 | vanduo šaltas - V1 2
1354434 | 4 a V1 | vanduo šaltas - V1 2
1354438 | 4 a V1 | vanduo šaltas - V1 2
1354517 | 4 a V1 | vanduo šaltas - V1 2
1354521 | 4 a V1 | vanduo šaltas - V1 2
1354589 | 4 a V1 | vanduo šaltas - V1 2
1354593 | 4 a V1 | vanduo šaltas - V1 2
1354859 | 1 a +-152.84 | vanduo šaltas - V1 2
1354877 | 4 a V1 | vanduo šaltas - V1 2
1354889 | 4 a V1 | vanduo šaltas - V1 2
1354928 | 4 a V1 | vanduo šaltas - V1 2
1354932 | 4 a V1 | vanduo šaltas - V1 2
1354996 | 4 a V1 | vanduo šaltas - V1 2
1355043 | 4 a V1 | vanduo šaltas - V1 2
1355047 | 4 a V1 | vanduo šaltas - V1 2
1355129 | 4 a V1 | vanduo šaltas - V1 2
1355173 | 4 a V1 | vanduo šaltas - V1 2
1355177 | 4 a V1 | vanduo šaltas - V1 2
1355228 | 4 a V1 | vanduo šaltas - V1 2
1355236 | 4 a V1 | vanduo šaltas - V1 2
1355274 | 4 a V1 | vanduo šaltas - V1 2
1355278 | 4 a V1 | vanduo šaltas - V1 2
1355361 | 4 a V1 | vanduo šaltas - V1 2
1355369 | 4 a V1 | vanduo šaltas - V1 2
1355397 | 4 a V1 | vanduo šaltas - V1 2
1355401 | 4 a V1 | vanduo šaltas - V1 2
1355435 | 4 a V1 | vanduo šaltas - V1 2
1355478 | 4 a V1 | vanduo šaltas - V1 2
1355482 | 4 a V1 | vanduo šaltas - V1 2
1355518 | 4 a V1 | vanduo šaltas - V1 2
1355560 | 4 a V1 | vanduo šaltas - V1 2
1355564 | 4 a V1 | vanduo šaltas - V1 2
1355598 | 4 a V1 | vanduo šaltas - V1 2
1355803 | 4 a V1 | vanduo šaltas - V1 2
1355807 | 4 a V1 | vanduo šaltas - V1 2
1355859 | 4 a V1 | vanduo šaltas - V1 2
1355901 | 4 a V1 | vanduo šaltas - V1 2
1355905 | 4 a V1 | vanduo šaltas - V1 2
1355967 | 4 a V1 | vanduo šaltas - V1 2
1356005 | 4 a V1 | vanduo šaltas - V1 2
1356009 | 4 a V1 | vanduo šaltas - V1 2
1356125 | 4 a V1 | vanduo šaltas - V1 2
1356129 | 4 a V1 | vanduo šaltas - V1 2
1356206 | 4 a V1 | vanduo šaltas - V1 2
1356210 | 4 a V1 | vanduo šaltas - V1 2
1356253 | 4 a V1 | vanduo šaltas - V1 2
1356294 | 4 a V1 | vanduo šaltas - V1 2
1356298 | 4 a V1 | vanduo šaltas - V1 2
1356372 | 4 a V1 | vanduo šaltas - V1 2
1356386 | 4 a V1 | vanduo šaltas - V1 2
1356400 | 4 a V1 | vanduo šaltas - V1 2
1356436 | 4 a V1 | vanduo šaltas - V1 2
1356470 | 4 a V1 | vanduo šaltas - V1 2
1356525 | 4 a V1 | vanduo šaltas - V1 2
1356529 | 4 a V1 | vanduo šaltas - V1 2
1356563 | 4 a V1 | vanduo šaltas - V1 2
1356595 | 4 a V1 | vanduo šaltas - V1 2
1356599 | 4 a V1 | vanduo šaltas - V1 2
1356665 | 4 a V1 | vanduo šaltas - V1 2
1356687 | 4 a V1 | vanduo šaltas - V1 2
1356699 | 4 a V1 | vanduo šaltas - V1 2
1356729 | 4 a V1 | vanduo šaltas - V1 2
1356733 | 4 a V1 | vanduo šaltas - V1 2
1356775 | 4 a V1 | vanduo šaltas - V1 2
1356788 | 4 a V1 | vanduo šaltas - V1 2
1356818 | 4 a V1 | vanduo šaltas - V1 2
1356822 | 4 a V1 | vanduo šaltas - V1 2
1356878 | 4 a V1 | vanduo šaltas - V1 2
1356882 | 4 a V1 | vanduo šaltas - V1 2
1356927 | 4 a V1 | vanduo šaltas - V1 2
1356965 | 4 a V1 | vanduo šaltas - V1 2
1356969 | 4 a V1 | vanduo šaltas - V1 2
1357008 | 4 a V1 | vanduo šaltas - V1 2
1357041 | 4 a V1 | vanduo šaltas - V1 2
1357045 | 4 a V1 | vanduo šaltas - V1 2
1357079 | 4 a V1 | vanduo šaltas - V1 2
1357115 | 4 a V1 | vanduo šaltas - V1 2
1357119 | 4 a V1 | vanduo šaltas - V1 2
1357439 | 3 a | vanduo šaltas - V1 2
1357460 | 3 a | vanduo šaltas - V1 2
1357474 | 3 a | vanduo šaltas - V1 2
1357516 | 3 a | vanduo šaltas - V1 2
1357520 | 3 a | vanduo šaltas - V1 2
1357568 | 3 a | vanduo šaltas - V1 2
1357580 | 3 a | vanduo šaltas - V1 2
1357619 | 3 a | vanduo šaltas - V1 2
1357623 | 3 a | vanduo šaltas - V1 2
1357683 | 3 a | vanduo šaltas - V1 2
1357687 | 3 a | vanduo šaltas - V1 2
1357727 | 3 a | vanduo šaltas - V1 2
1357735 | 3 a | vanduo šaltas - V1 2
1357772 | 3 a | vanduo šaltas - V1 2
1357776 | 3 a | vanduo šaltas - V1 2
1357863 | 3 a | vanduo šaltas - V1 2
1357875 | 3 a | vanduo šaltas - V1 2
1357915 | 3 a | vanduo šaltas - V1 2
1357919 | 3 a | vanduo šaltas - V1 2
1357963 | 3 a | vanduo šaltas - V1 2
1358013 | 3 a | vanduo šaltas - V1 2
1358017 | 3 a | vanduo šaltas - V1 2
1358080 | 3 a | vanduo šaltas - V1 2
1358084 | 3 a | vanduo šaltas - V1 2
1358213 | 3 a | vanduo šaltas - V1 2
1358243 | 3 a | vanduo šaltas - V1 2
1358245 | 3 a | vanduo šaltas - V1 2
1358285 | 3 a | vanduo šaltas - V1 2
1358359 | 3 a | vanduo šaltas - V1 2
1358367 | 3 a | vanduo šaltas - V1 2
1358413 | 3 a | vanduo šaltas - V1 2
1358417 | 3 a | vanduo šaltas - V1 2
1358642 | 3 a | vanduo šaltas - V1 2
1358681 | 3 a | vanduo šaltas - V1 2
1358685 | 3 a | vanduo šaltas - V1 2
1358828 | 3 a | vanduo šaltas - V1 2
1358879 | 3 a | vanduo šaltas - V1 2
1358887 | 3 a | vanduo šaltas - V1 2
1358937 | 3 a | vanduo šaltas - V1 2
1358941 | 3 a | vanduo šaltas - V1 2
1359019 | 3 a | vanduo šaltas - V1 2
1359023 | 3 a | vanduo šaltas - V1 2
1359111 | 3 a | vanduo šaltas - V1 2
1359115 | 3 a | vanduo šaltas - V1 2
1359183 | 3 a | vanduo šaltas - V1 2
1359237 | 3 a | vanduo šaltas - V1 2
1359241 | 3 a | vanduo šaltas - V1 2
1359284 | 3 a | vanduo šaltas - V1 2
1359335 | 3 a | vanduo šaltas - V1 2
1359339 | 3 a | vanduo šaltas - V1 2
1359491 | 3 a | vanduo šaltas - V1 2
1359495 | 3 a | vanduo šaltas - V1 2
1359544 | 3 a | vanduo šaltas - V1 2
1359557 | 3 a | vanduo šaltas - V1 2
1359565 | 3 a | vanduo šaltas - V1 2
1359612 | 3 a | vanduo šaltas - V1 2
1359616 | 3 a | vanduo šaltas - V1 2
1359688 | 2 a | vanduo šaltas - V1 2
1359722 | 3 a | vanduo šaltas - V1 2
1359726 | 3 a | vanduo šaltas - V1 2
1359933 | 3 a | vanduo šaltas - V1 2
1359937 | 3 a | vanduo šaltas - V1 2
1360044 | 3 a | vanduo šaltas - V1 2
1360090 | 3 a | vanduo šaltas - V1 2
1360094 | 3 a | vanduo šaltas - V1 2
1360334 | 2 a | vanduo šaltas - V1 2
1360367 | 3 a | vanduo šaltas - V1 2
1360407 | 3 a | vanduo šaltas - V1 2
1360411 | 3 a | vanduo šaltas - V1 2
1360590 | 3 a | vanduo šaltas - V1 2
1360600 | 3 a | vanduo šaltas - V1 2
1360608 | 3 a | vanduo šaltas - V1 2
1360658 | 3 a | vanduo šaltas - V1 2
1360660 | 3 a | vanduo šaltas - V1 2
1360727 | 3 a | vanduo šaltas - V1 2
1360737 | 3 a | vanduo šaltas - V1 2
1360782 | 3 a | vanduo šaltas - V1 2
1360786 | 3 a | vanduo šaltas - V1 2
1360868 | 3 a | vanduo šaltas - V1 2
1360907 | 3 a | vanduo šaltas - V1 2
1360911 | 3 a | vanduo šaltas - V1 2
1360979 | 3 a | vanduo šaltas - V1 8
1361010 | 3 a | vanduo šaltas - V1 8
1361014 | 3 a | vanduo šaltas - V1 8
1361048 | 3 a | vanduo šaltas - V1 2
1361079 | 3 a | vanduo šaltas - V1 2
1361083 | 3 a | vanduo šaltas - V1 2
1361146 | 3 a | vanduo šaltas - V1 2
1361150 | 3 a | vanduo šaltas - V1 2
1361184 | 3 a | vanduo šaltas - V1 2
1361220 | 3 a | vanduo šaltas - V1 2
1361224 | 3 a | vanduo šaltas - V1 2
1361295 | 3 a | vanduo šaltas - V1 2
1361299 | 3 a | vanduo šaltas - V1 2
1361407 | 3 a | vanduo šaltas - V1 2
1361411 | 3 a | vanduo šaltas - V1 2
1361564 | 2 a | vanduo šaltas - V1 2
1361624 | 3 a | vanduo šaltas - V1 2
1361638 | 3 a | vanduo šaltas - V1 2
1361691 | 3 a | vanduo šaltas - V1 2
1361695 | 3 a | vanduo šaltas - V1 2
1361757 | 3 a | vanduo šaltas - V1 2
1361796 | 3 a | vanduo šaltas - V1 2
1361800 | 3 a | vanduo šaltas - V1 2
1361876 | 3 a | vanduo šaltas - V1 2
1361915 | 3 a | vanduo šaltas - V1 2
1361919 | 3 a | vanduo šaltas - V1 2
1361973 | 3 a | vanduo šaltas - V1 2
1361985 | 3 a | vanduo šaltas - V1 2
1361995 | 3 a | vanduo šaltas - V1 2
1362049 | 3 a | vanduo šaltas - V1 2
1362053 | 3 a | vanduo šaltas - V1 2
1362124 | 3 a | vanduo šaltas - V1 2
1362243 | 3 a | vanduo šaltas - V1 2
1362253 | 3 a | vanduo šaltas - V1 2
1362303 | 3 a | vanduo šaltas - V1 2
1362307 | 3 a | vanduo šaltas - V1 2
1362381 | 3 a | vanduo šaltas - V1 2
1362385 | 3 a | vanduo šaltas - V1 2
1362422 | 3 a | vanduo šaltas - V1 2
1362460 | 3 a | vanduo šaltas - V1 2
1362464 | 3 a | vanduo šaltas - V1 2
1362535 | 3 a | vanduo šaltas - V1 2
1362539 | 3 a | vanduo šaltas - V1 2
1362744 | 3 a | vanduo šaltas - V1 2
1362770 | 3 a | vanduo šaltas - V1 2
1362784 | 3 a | vanduo šaltas - V1 2
1362818 | 3 a | vanduo šaltas - V1 2
1362858 | 3 a | vanduo šaltas - V1 2
1362915 | 3 a | vanduo šaltas - V1 2
1362919 | 3 a | vanduo šaltas - V1 2
1362965 | 3 a | vanduo šaltas - V1 2
1362973 | 3 a | vanduo šaltas - V1 2
1362986 | 3 a | vanduo šaltas - V1 2
1363026 | 3 a | vanduo šaltas - V1 2
1363030 | 3 a | vanduo šaltas - V1 2
1363073 | 3 a | vanduo šaltas - V1 2
1363112 | 3 a | vanduo šaltas - V1 2
1363116 | 3 a | vanduo šaltas - V1 2
1363179 | 3 a | vanduo šaltas - V1 2
1363183 | 3 a | vanduo šaltas - V1 2
1363231 | 3 a | vanduo šaltas - V1 2
1363292 | 3 a | vanduo šaltas - V1 2
1363296 | 3 a | vanduo šaltas - V1 2
1363576 | 3 a | vanduo šaltas - V1 2
1363602 | 3 a | vanduo šaltas - V1 2
1363624 | 3 a | vanduo šaltas - V1 2
1363663 | 3 a | vanduo šaltas - V1 2
1363700 | 3 a | vanduo šaltas - V1 2
1363704 | 3 a | vanduo šaltas - V1 2
1363772 | 3 a | vanduo šaltas - V1 2
1363776 | 3 a | vanduo šaltas - V1 2
1363869 | 3 a | vanduo šaltas - V1 2
1363873 | 3 a | vanduo šaltas - V1 2
1363933 | 3 a | vanduo šaltas - V1 2
1363937 | 3 a | vanduo šaltas - V1 2
1364006 | 3 a | vanduo šaltas - V1 2
1364039 | 3 a | vanduo šaltas - V1 2
1364043 | 3 a | vanduo šaltas - V1 2
1364077 | 3 a | vanduo šaltas - V1 2
1364128 | 3 a | vanduo šaltas - V1 2
1364132 | 3 a | vanduo šaltas - V1 2
1364173 | 3 a | vanduo šaltas - V1 2
1364194 | 3 a | vanduo šaltas - V1 2
1364255 | 3 a | vanduo šaltas - V1 2
1364259 | 3 a | vanduo šaltas - V1 2
1364362 | 3 a | vanduo šaltas - V1 2
1364367 | 3 a | vanduo šaltas - V1 2
1364513 | 3 a | vanduo šaltas - V1 2
1364527 | 3 a | vanduo šaltas - V1 2
1364535 | 3 a | vanduo šaltas - V1 2
1364583 | 3 a | vanduo šaltas - V1 2
1364587 | 3 a | vanduo šaltas - V1 2
1364674 | 3 a | vanduo šaltas - V1 2
1364678 | 3 a | vanduo šaltas - V1 2
1364722 | 3 a | vanduo šaltas - V1 2
1364730 | 3 a | vanduo šaltas - V1 2
1364772 | 3 a | vanduo šaltas - V1 2
1364776 | 3 a | vanduo šaltas - V1 2
1364861 | 3 a | vanduo šaltas - V1 2
1364869 | 3 a | vanduo šaltas - V1 2
1364879 | 3 a | vanduo šaltas - V1 2
1364898 | 3 a | vanduo šaltas - V1 2
1364954 | 3 a | vanduo šaltas - V1 2
1364958 | 3 a | vanduo šaltas - V1 2
1365192 | 3 a | vanduo šaltas - V1 2
1365196 | 3 a | vanduo šaltas - V1 2
1365231 | 3 a | vanduo šaltas - V1 2
1365235 | 3 a | vanduo šaltas - V1 2
1365281 | 3 a | vanduo šaltas - V1 2
1365319 | 3 a | vanduo šaltas - V1 2
1365323 | 3 a | vanduo šaltas - V1 2
1365393 | 3 a | vanduo šaltas - V1 2
1365397 | 3 a | vanduo šaltas - V1 2
1365501 | 3 a | vanduo šaltas - V1 2
1365505 | 3 a | vanduo šaltas - V1 2
1365543 | 3 a | vanduo šaltas - V1 2
1365608 | 3 a | vanduo šaltas - V1 2
1365618 | 3 a | vanduo šaltas - V1 2
1365712 | 3 a | vanduo šaltas - V1 2
1365789 | 3 a | vanduo šaltas - V1 2
1365793 | 3 a | vanduo šaltas - V1 2
1365841 | 3 a | vanduo šaltas - V1 2
1365882 | 3 a | vanduo šaltas - V1 2
1365886 | 3 a | vanduo šaltas - V1 2
1366009 | 3 a | vanduo šaltas - V1 2
1366013 | 3 a | vanduo šaltas - V1 2
1366049 | 3 a | vanduo šaltas - V1 2
1366093 | 3 a | vanduo šaltas - V1 2
1366097 | 3 a | vanduo šaltas - V1 2
1366164 | 3 a | vanduo šaltas - V1 2
1366197 | 3 a | vanduo šaltas - V1 2
1366201 | 3 a | vanduo šaltas - V1 2
1366262 | 3 a | vanduo šaltas - V1 2
1366266 | 3 a | vanduo šaltas - V1 2
1366348 | 2 a | vanduo šaltas - V1 2
1366372 | 3 a | vanduo šaltas - V1 2
1366380 | 3 a | vanduo šaltas - V1 2
1366441 | 3 a | vanduo šaltas - V1 2
1366447 | 3 a | vanduo šaltas - V1 2
1366524 | 3 a | vanduo šaltas - V1 2
1366528 | 3 a | vanduo šaltas - V1 2
1366580 | 3 a | vanduo šaltas - V1 2
1366588 | 3 a | vanduo šaltas - V1 2
1366677 | 3 a | vanduo šaltas - V1 2
1366681 | 3 a | vanduo šaltas - V1 2
1366772 | 3 a | vanduo šaltas - V1 2
1366776 | 3 a | vanduo šaltas - V1 2
1366982 | 3 a | vanduo šaltas - V1 2
1367047 | 3 a | vanduo šaltas - V1 2
1367051 | 3 a | vanduo šaltas - V1 2
1367156 | 3 a | vanduo šaltas - V1 2
1367160 | 3 a | vanduo šaltas - V1 2
1367201 | 3 a | vanduo šaltas - V1 2
1367235 | 3 a | vanduo šaltas - V1 2
1367239 | 3 a | vanduo šaltas - V1 2
1367298 | 3 a | vanduo šaltas - V1 2
1367553 | 3 a | vanduo šaltas - V1 2
1367567 | 3 a | vanduo šaltas - V1 2
1367575 | 3 a | vanduo šaltas - V1 2
1367652 | 3 a | vanduo šaltas - V1 2
1367656 | 3 a | vanduo šaltas - V1 2
1367689 | 3 a | vanduo šaltas - V1 2
1367723 | 3 a | vanduo šaltas - V1 2
1367727 | 3 a | vanduo šaltas - V1 2
1367778 | 3 a | vanduo šaltas - V1 2
1367813 | 3 a | vanduo šaltas - V1 2
1367821 | 3 a | vanduo šaltas - V1 2
1367890 | 3 a | vanduo šaltas - V1 2
1367894 | 3 a | vanduo šaltas - V1 2
1367933 | 3 a | vanduo šaltas - V1 2
1367941 | 3 a | vanduo šaltas - V1 2
1367986 | 3 a | vanduo šaltas - V1 2
1367990 | 3 a | vanduo šaltas - V1 2
1368029 | 2 a | vanduo šaltas - V1 2
1368041 | 3 a | vanduo šaltas - V1 2
1368097 | 3 a | vanduo šaltas - V1 2
1368101 | 3 a | vanduo šaltas - V1 2
1368147 | 3 a | vanduo šaltas - V1 2
1368213 | 3 a | vanduo šaltas - V1 2
1368217 | 3 a | vanduo šaltas - V1 2
1368376 | 3 a | vanduo šaltas - V1 2
1368391 | 3 a | vanduo šaltas - V1 2
1368445 | 3 a | vanduo šaltas - V1 2
1368447 | 3 a | vanduo šaltas - V1 2
1368535 | 3 a | vanduo šaltas - V1 2
1368539 | 3 a | vanduo šaltas - V1 2
1368615 | 3 a | vanduo šaltas - V1 2
1368619 | 3 a | vanduo šaltas - V1 2
1368715 | 3 a | vanduo šaltas - V1 2
1368719 | 3 a | vanduo šaltas - V1 2
1368756 | 3 a | vanduo šaltas - V1 2
1368803 | 3 a | vanduo šaltas - V1 2
1368807 | 3 a | vanduo šaltas - V1 2
1368842 | 3 a | vanduo šaltas - V1 2
1368892 | 3 a | vanduo šaltas - V1 2
1368896 | 3 a | vanduo šaltas - V1 2
1368992 | 3 a | vanduo šaltas - V1 2
1368996 | 3 a | vanduo šaltas - V1 2
1369135 | 2 a | vanduo šaltas - V1 2
1369151 | 2 a | vanduo šaltas - V1 2
1369175 | 2 a | vanduo šaltas - V1 2
1369185 | 2 a | vanduo šaltas - V1 2
1369254 | 2 a | vanduo šaltas - V1 2
1369260 | 2 a | vanduo šaltas - V1 2
1369303 | 2 a | vanduo šaltas - V1 2
1369331 | 2 a | vanduo šaltas - V1 2
1369377 | 2 a | vanduo šaltas - V1 2
1369381 | 2 a | vanduo šaltas - V1 2
1369455 | 2 a | vanduo šaltas - V1 2
1369509 | 2 a | vanduo šaltas - V1 2
1369513 | 2 a | vanduo šaltas - V1 2
1369651 | 2 a | vanduo šaltas - V1 2
1369653 | 2 a | vanduo šaltas - V1 2
1369725 | 2 a | vanduo šaltas - V1 2
1369771 | 2 a | vanduo šaltas - V1 2
1369775 | 2 a | vanduo šaltas - V1 2
1369825 | 2 a | vanduo šaltas - V1 2
1369872 | 2 a | vanduo šaltas - V1 2
1369876 | 2 a | vanduo šaltas - V1 2
1370096 | 2 a | vanduo šaltas - V1 2
1370100 | 2 a | vanduo šaltas - V1 2
1370216 | 2 a | vanduo šaltas - V1 2
1370264 | 2 a | vanduo šaltas - V1 2
1370268 | 2 a | vanduo šaltas - V1 2
1370343 | 2 a | vanduo šaltas - V1 2
1370345 | 2 a | vanduo šaltas - V1 2
1370406 | 2 a | vanduo šaltas - V1 2
1370410 | 2 a | vanduo šaltas - V1 2
1370527 | 2 a | vanduo šaltas - V1 2
1370556 | 2 a | vanduo šaltas - V1 2
1370752 | 2 a | vanduo šaltas - V1 2
1370756 | 2 a | vanduo šaltas - V1 2
1370836 | 2 a | vanduo šaltas - V1 2
1370850 | 2 a | vanduo šaltas - V1 2
1370890 | 2 a | vanduo šaltas - V1 2
1370894 | 2 a | vanduo šaltas - V1 2
1370933 | 2 a | vanduo šaltas - V1 2
1370977 | 2 a | vanduo šaltas - V1 2
1370981 | 2 a | vanduo šaltas - V1 2
1371069 | 2 a | vanduo šaltas - V1 2
1371073 | 2 a | vanduo šaltas - V1 2
1371163 | 2 a | vanduo šaltas - V1 2
1371240 | 2 a | vanduo šaltas - V1 2
1371244 | 2 a | vanduo šaltas - V1 2
1371473 | 2 a | vanduo šaltas - V1 2
1371508 | 2 a | vanduo šaltas - V1 2
1371512 | 2 a | vanduo šaltas - V1 2
1371557 | 2 a | vanduo šaltas - V1 2
1371598 | 2 a | vanduo šaltas - V1 2
1371602 | 2 a | vanduo šaltas - V1 2
1372337 | 2 a | vanduo šaltas - V1 2
1372341 | 2 a | vanduo šaltas - V1 2
1372543 | 2 a | vanduo šaltas - V1 2
1372596 | 2 a | vanduo šaltas - V1 2
1372644 | 2 a | vanduo šaltas - V1 2
1372648 | 2 a | vanduo šaltas - V1 2
1372806 | 2 a | vanduo šaltas - V1 2
1372810 | 2 a | vanduo šaltas - V1 2
1372877 | 2 a | vanduo šaltas - V1 2
1372889 | 2 a | vanduo šaltas - V1 2
1372922 | 2 a | vanduo šaltas - V1 2
1372926 | 2 a | vanduo šaltas - V1 2
1372993 | 2 a | vanduo šaltas - V1 2
1372997 | 2 a | vanduo šaltas - V1 2
1373152 | 2 a | vanduo šaltas - V1 2
1373156 | 2 a | vanduo šaltas - V1 2
1373246 | 2 a | vanduo šaltas - V1 2
1373285 | 2 a | vanduo šaltas - V1 2
1373289 | 2 a | vanduo šaltas - V1 2
1373388 | 2 a | vanduo šaltas - V1 2
1373419 | 2 a | vanduo šaltas - V1 2
1373423 | 2 a | vanduo šaltas - V1 2
1373533 | 2 a | vanduo šaltas - V1 2
1373537 | 2 a | vanduo šaltas - V1 2
1373577 | 2 a | vanduo šaltas - V1 2
1373613 | 2 a | vanduo šaltas - V1 2
1373617 | 2 a | vanduo šaltas - V1 2
1373656 | 2 a | vanduo šaltas - V1 2
1373689 | 2 a | vanduo šaltas - V1 2
1373693 | 2 a | vanduo šaltas - V1 2
1373856 | 2 a | vanduo šaltas - V1 2
1373860 | 2 a | vanduo šaltas - V1 2
1373948 | 2 a | vanduo šaltas - V1 2
1373983 | 2 a | vanduo šaltas - V1 2
1373991 | 2 a | vanduo šaltas - V1 2
1374629 | 2 a | vanduo šaltas - V1 2
1374631 | 2 a | vanduo šaltas - V1 2
1374931 | 2 a | vanduo šaltas - V1 2
1375283 | 2 a | vanduo šaltas - V1 2
1375444 | 2 a | vanduo šaltas - V1 2
1375489 | 2 a | vanduo šaltas - V1 2
1375493 | 2 a | vanduo šaltas - V1 2
1375578 | 2 a | vanduo šaltas - V1 2
1375582 | 2 a | vanduo šaltas - V1 2
1375615 | 2 a | vanduo šaltas - V1 2
1375663 | 2 a | vanduo šaltas - V1 2
1375667 | 2 a | vanduo šaltas - V1 2
1375759 | 2 a | vanduo šaltas - V1 2
1375763 | 2 a | vanduo šaltas - V1 2
1375830 | 2 a | vanduo šaltas - V1 2
1375834 | 2 a | vanduo šaltas - V1 2
1375888 | 2 a | vanduo šaltas - V1 2
1375892 | 2 a | vanduo šaltas - V1 2
1375925 | 2 a | vanduo šaltas - V1 2
1375935 | 2 a | vanduo šaltas - V1 2
1375995 | 2 a | vanduo šaltas - V1 2
1375999 | 2 a | vanduo šaltas - V1 2
1376103 | 2 a | vanduo šaltas - V1 2
1376107 | 2 a | vanduo šaltas - V1 2
1376167 | 2 a | vanduo šaltas - V1 2
1376171 | 2 a | vanduo šaltas - V1 2
1376254 | 2 a | vanduo šaltas - V1 2
1376262 | 2 a | vanduo šaltas - V1 2
1376297 | 2 a | vanduo šaltas - V1 2
1376301 | 2 a | vanduo šaltas - V1 2
1376360 | 2 a | vanduo šaltas - V1 2
1376364 | 2 a | vanduo šaltas - V1 2
1376424 | 2 a | vanduo šaltas - V1 2
1376428 | 2 a | vanduo šaltas - V1 2
1376494 | 2 a | vanduo šaltas - V1 2
1376498 | 2 a | vanduo šaltas - V1 2
1376541 | 2 a | vanduo šaltas - V1 2
1376549 | 2 a | vanduo šaltas - V1 2
1376596 | 2 a | vanduo šaltas - V1 2
1376600 | 2 a | vanduo šaltas - V1 2
1376661 | 2 a | vanduo šaltas - V1 2
1376665 | 2 a | vanduo šaltas - V1 2
1376743 | 2 a | vanduo šaltas - V1 2
1376747 | 2 a | vanduo šaltas - V1 2
1376811 | 2 a | vanduo šaltas - V1 2
1376815 | 2 a | vanduo šaltas - V1 2
1376879 | 2 a | vanduo šaltas - V1 2
1376883 | 2 a | vanduo šaltas - V1 2
1377119 | 2 a | vanduo šaltas - V1 2
1377123 | 2 a | vanduo šaltas - V1 2
1377197 | 2 a | vanduo šaltas - V1 2
1377201 | 2 a | vanduo šaltas - V1 2
1377258 | 2 a | vanduo šaltas - V1 2
1377268 | 2 a | vanduo šaltas - V1 2
1377300 | 2 a | vanduo šaltas - V1 2
1377331 | 2 a | vanduo šaltas - V1 2
1377335 | 2 a | vanduo šaltas - V1 2
1377435 | 2 a | vanduo šaltas - V1 2
1377439 | 2 a | vanduo šaltas - V1 2
1377511 | 2 a | vanduo šaltas - V1 2
1377517 | 2 a | vanduo šaltas - V1 2
1377594 | 2 a | vanduo šaltas - V1 2
1377598 | 2 a | vanduo šaltas - V1 2
1377664 | 2 a | vanduo šaltas - V1 2
1377684 | 2 a | vanduo šaltas - V1 2
1377719 | 2 a | vanduo šaltas - V1 2
1377745 | 2 a | vanduo šaltas - V1 2
1377759 | 2 a | vanduo šaltas - V1 2
1377793 | 2 a | vanduo šaltas - V1 2
1377797 | 2 a | vanduo šaltas - V1 2
1377903 | 2 a | vanduo šaltas - V1 2
1377907 | 2 a | vanduo šaltas - V1 2
1377969 | 2 a | vanduo šaltas - V1 2
1377973 | 2 a | vanduo šaltas - V1 2
1378019 | 2 a | vanduo šaltas - V1 2
1378063 | 2 a | vanduo šaltas - V1 2
1378067 | 2 a | vanduo šaltas - V1 2
1378234 | 2 a | vanduo šaltas - V1 2
1378238 | 2 a | vanduo šaltas - V1 2
1378297 | 2 a | vanduo šaltas - V1 2
1378301 | 2 a | vanduo šaltas - V1 2
1378363 | 2 a | vanduo šaltas - V1 2
1378367 | 2 a | vanduo šaltas - V1 2
1378446 | 2 a | vanduo šaltas - V1 2
1378504 | 2 a | vanduo šaltas - V1 2
1378508 | 2 a | vanduo šaltas - V1 2
1378565 | 2 a | vanduo šaltas - V1 2
1378569 | 2 a | vanduo šaltas - V1 2
1378606 | 2 a | vanduo šaltas - V1 2
1378614 | 2 a | vanduo šaltas - V1 2
1378643 | 2 a | vanduo šaltas - V1 2
1378647 | 2 a | vanduo šaltas - V1 2
1378708 | 2 a | vanduo šaltas - V1 2
1378712 | 2 a | vanduo šaltas - V1 2
1378773 | 2 a | vanduo šaltas - V1 2
1378777 | 2 a | vanduo šaltas - V1 2
1378844 | 2 a | vanduo šaltas - V1 2
1378848 | 2 a | vanduo šaltas - V1 2
1378892 | 2 a | vanduo šaltas - V1 2
1378938 | 2 a | vanduo šaltas - V1 2
1378944 | 2 a | vanduo šaltas - V1 2
1379238 | 2 a | vanduo šaltas - V1 2
1379242 | 2 a | vanduo šaltas - V1 2
1379333 | 2 a | vanduo šaltas - V1 2
1379337 | 2 a | vanduo šaltas - V1 2
1379382 | 2 a | vanduo šaltas - V1 2
1379430 | 2 a | vanduo šaltas - V1 2
1379434 | 2 a | vanduo šaltas - V1 2
1379552 | 2 a | vanduo šaltas - V1 2
1379556 | 2 a | vanduo šaltas - V1 2
1379596 | 2 a | vanduo šaltas - V1 2
1379641 | 2 a | vanduo šaltas - V1 2
1379645 | 2 a | vanduo šaltas - V1 2
1379716 | 2 a | vanduo šaltas - V1 2
1379720 | 2 a | vanduo šaltas - V1 2
1379786 | 2 a | vanduo šaltas - V1 2
1379790 | 2 a | vanduo šaltas - V1 2
1379826 | 2 a | vanduo šaltas - V1 2
1379860 | 2 a | vanduo šaltas - V1 2
1379864 | 2 a | vanduo šaltas - V1 2
1379926 | 2 a | vanduo šaltas - V1 2
1379930 | 2 a | vanduo šaltas - V1 2
1379987 | 2 a | vanduo šaltas - V1 2
1379991 | 2 a | vanduo šaltas - V1 2
1380032 | 2 a | vanduo šaltas - V1 2
1380072 | 2 a | vanduo šaltas - V1 2
1380076 | 2 a | vanduo šaltas - V1 2
1380169 | 2 a | vanduo šaltas - V1 2
1380173 | 2 a | vanduo šaltas - V1 2
1380286 | 2 a | vanduo šaltas - V1 2
1380300 | 2 a | vanduo šaltas - V1 2
1380308 | 2 a | vanduo šaltas - V1 2
1380348 | 2 a | vanduo šaltas - V1 2
1380352 | 2 a | vanduo šaltas - V1 2
1380428 | 2 a | vanduo šaltas - V1 2
1380432 | 2 a | vanduo šaltas - V1 2
1380484 | 2 a | vanduo šaltas - V1 2
1380523 | 2 a | vanduo šaltas - V1 2
1380527 | 2 a | vanduo šaltas - V1 2
1380585 | 2 a | vanduo šaltas - V1 2
1380589 | 2 a | vanduo šaltas - V1 2
1380642 | 2 a | vanduo šaltas - V1 2
1380678 | 2 a | vanduo šaltas - V1 2
1380682 | 2 a | vanduo šaltas - V1 2
1380738 | 2 a | vanduo šaltas - V1 2
1380746 | 2 a | vanduo šaltas - V1 2
1380756 | 2 a | vanduo šaltas - V1 2
1380789 | 2 a | vanduo šaltas - V1 2
1380793 | 2 a | vanduo šaltas - V1 2
1380827 | 2 a | vanduo šaltas - V1 2
1380837 | 2 a | vanduo šaltas - V1 2
1380883 | 2 a | vanduo šaltas - V1 2
1380887 | 2 a | vanduo šaltas - V1 2
1380984 | 2 a | vanduo šaltas - V1 2
1381028 | 2 a | vanduo šaltas - V1 2
1381032 | 2 a | vanduo šaltas - V1 2
1381135 | 2 a | vanduo šaltas - V1 2
1381139 | 2 a | vanduo šaltas - V1 2
1381220 | 2 a | vanduo šaltas - V1 2
1381224 | 2 a | vanduo šaltas - V1 2
1381292 | 2 a | vanduo šaltas - V1 2
1381296 | 2 a | vanduo šaltas - V1 2
1381365 | 2 a | vanduo šaltas - V1 2
1381369 | 2 a | vanduo šaltas - V1 2
1381437 | 2 a | vanduo šaltas - V1 2
1381441 | 2 a | vanduo šaltas - V1 2
1381501 | 2 a | vanduo šaltas - V1 2
1381533 | 2 a | vanduo šaltas - V1 2
1381537 | 2 a | vanduo šaltas - V1 2
1381571 | 2 a | vanduo šaltas - V1 2
1381603 | 2 a | vanduo šaltas - V1 2
1381607 | 2 a | vanduo šaltas - V1 2
1381667 | 2 a | vanduo šaltas - V1 2
1381671 | 2 a | vanduo šaltas - V1 2
1381737 | 2 a | vanduo šaltas - V1 2
1381767 | 2 a | vanduo šaltas - V1 2
1381771 | 2 a | vanduo šaltas - V1 2
1382012 | 2 a | vanduo šaltas - V1 2
1382051 | 2 a | vanduo šaltas - V1 2
1382055 | 2 a | vanduo šaltas - V1 2
1382279 | 2 a | vanduo šaltas - V1 2
1382283 | 2 a | vanduo šaltas - V1 2
1382347 | 2 a | vanduo šaltas - V1 2
1382362 | 2 a | vanduo šaltas - V1 2
1382374 | 2 a | vanduo šaltas - V1 2
1382413 | 2 a | vanduo šaltas - V1 2
1382417 | 2 a | vanduo šaltas - V1 2
1382531 | 2 a | vanduo šaltas - V1 2
1382535 | 2 a | vanduo šaltas - V1 2
1382606 | 2 a | vanduo šaltas - V1 2
1382610 | 2 a | vanduo šaltas - V1 2
1382653 | 2 a | vanduo šaltas - V1 2
1382688 | 2 a | vanduo šaltas - V1 2
1382692 | 2 a | vanduo šaltas - V1 2
1382750 | 2 a | vanduo šaltas - V1 2
1382754 | 2 a | vanduo šaltas - V1 2
1382826 | 2 a | vanduo šaltas - V1 2
1382830 | 2 a | vanduo šaltas - V1 2
1382903 | 2 a | vanduo šaltas - V1 2
1382907 | 2 a | vanduo šaltas - V1 2
1382969 | 2 a | vanduo šaltas - V1 2
1383647 | 2 a | vanduo šaltas - V1 2
1383655 | 2 a | vanduo šaltas - V1 2
1383669 | 2 a | vanduo šaltas - V1 2
1383699 | 2 a | vanduo šaltas - V1 2
1383703 | 2 a | vanduo šaltas - V1 2
1383763 | 2 a | vanduo šaltas - V1 2
1383767 | 2 a | vanduo šaltas - V1 2
1383832 | 2 a | vanduo šaltas - V1 2
1383836 | 2 a | vanduo šaltas - V1 2
1383894 | 2 a | vanduo šaltas - V1 2
1383914 | 2 a | vanduo šaltas - V1 2
1383943 | 2 a | vanduo šaltas - V1 2
1383955 | 2 a | vanduo šaltas - V1 2
1383965 | 2 a | vanduo šaltas - V1 2
1383991 | 2 a | vanduo šaltas - V1 2
1383995 | 2 a | vanduo šaltas - V1 2
1384036 | 2 a | vanduo šaltas - V1 2
1384072 | 2 a | vanduo šaltas - V1 2
1384076 | 2 a | vanduo šaltas - V1 2
1384148 | 2 a | vanduo šaltas - V1 2
1384152 | 2 a | vanduo šaltas - V1 2
1384220 | 2 a | vanduo šaltas - V1 2
1384224 | 2 a | vanduo šaltas - V1 2
1384314 | 2 a | vanduo šaltas - V1 2
1384318 | 2 a | vanduo šaltas - V1 2
1384375 | 2 a | vanduo šaltas - V1 2
1384411 | 2 a | vanduo šaltas - V1 2
1384415 | 2 a | vanduo šaltas - V1 2
1384509 | 2 a | vanduo šaltas - V1 2
1384513 | 2 a | vanduo šaltas - V1 2
1384551 | 2 a | vanduo šaltas - V1 2
1384585 | 2 a | vanduo šaltas - V1 2
1384589 | 2 a | vanduo šaltas - V1 2
1384619 | 2 a | vanduo šaltas - V1 2
1384729 | 2 a | vanduo šaltas - V1 2
1384733 | 2 a | vanduo šaltas - V1 2
1384775 | 2 a | vanduo šaltas - V1 2
1384813 | 2 a | vanduo šaltas - V1 2
1384817 | 2 a | vanduo šaltas - V1 2
1384891 | 2 a | vanduo šaltas - V1 2
1384895 | 2 a | vanduo šaltas - V1 2
1385034 | 2 a | vanduo šaltas - V1 2
1385038 | 2 a | vanduo šaltas - V1 2
1385088 | 2 a | vanduo šaltas - V1 2
1385092 | 2 a | vanduo šaltas - V1 2
1385159 | 2 a | vanduo šaltas - V1 2
1385163 | 2 a | vanduo šaltas - V1 2
1385271 | 2 a | vanduo šaltas - V1 2
1385332 | 2 a | vanduo šaltas - V1 2
1385336 | 2 a | vanduo šaltas - V1 2
1385439 | 2 a | vanduo šaltas - V1 2
1385477 | 2 a | vanduo šaltas - V1 2
1385481 | 2 a | vanduo šaltas - V1 2
1385557 | 2 a | vanduo šaltas - V1 2
1385561 | 2 a | vanduo šaltas - V1 2
1385608 | 2 a | vanduo šaltas - V1 2
1385644 | 2 a | vanduo šaltas - V1 2
1385648 | 2 a | vanduo šaltas - V1 2
1385899 | 2 a | vanduo šaltas - V1 2
1385935 | 2 a | vanduo šaltas - V1 2
1385939 | 2 a | vanduo šaltas - V1 2
1386223 | 2 a | vanduo šaltas - V1 2
1386445 | 2 a | vanduo šaltas - V1 2
1386480 | 2 a | vanduo šaltas - V1 2
1386520 | 2 a | vanduo šaltas - V1 2
1386524 | 2 a | vanduo šaltas - V1 2
1386758 | 2 a | vanduo šaltas - V1 2
1386768 | 2 a | vanduo šaltas - V1 2
1386810 | 2 a | vanduo šaltas - V1 2
1386814 | 2 a | vanduo šaltas - V1 2
1386876 | 2 a | vanduo šaltas - V1 2
1386880 | 2 a | vanduo šaltas - V1 2
1386968 | 2 a | vanduo šaltas - V1 2
1386972 | 2 a | vanduo šaltas - V1 2
1387035 | 2 a | vanduo šaltas - V1 2
1387091 | 2 a | vanduo šaltas - V1 2
1387095 | 2 a | vanduo šaltas - V1 2
1387163 | 2 a | vanduo šaltas - V1 2
1387167 | 2 a | vanduo šaltas - V1 2
1387239 | 2 a | vanduo šaltas - V1 2
1387243 | 2 a | vanduo šaltas - V1 2
1387309 | 2 a | vanduo šaltas - V1 2
1387321 | 2 a | vanduo šaltas - V1 2
1387331 | 2 a | vanduo šaltas - V1 2
1387442 | 2 a | vanduo šaltas - V1 2
1387446 | 2 a | vanduo šaltas - V1 2
1387511 | 2 a | vanduo šaltas - V1 2
1387515 | 2 a | vanduo šaltas - V1 2
1387615 | 2 a | vanduo šaltas - V1 2
1387619 | 2 a | vanduo šaltas - V1 2
1387658 | 2 a | vanduo šaltas - V1 2
1387668 | 2 a | vanduo šaltas - V1 2
1387676 | 2 a | vanduo šaltas - V1 2
1387709 | 2 a | vanduo šaltas - V1 2
1387713 | 2 a | vanduo šaltas - V1 2
1387829 | 2 a | vanduo šaltas - V1 2
1387874 | 2 a | vanduo šaltas - V1 2
1387920 | 2 a | vanduo šaltas - V1 2
1387959 | 2 a | vanduo šaltas - V1 2
1388014 | 2 a | vanduo šaltas - V1 2
1388050 | 2 a | vanduo šaltas - V1 2
1388054 | 2 a | vanduo šaltas - V1 2
1388092 | 2 a | vanduo šaltas - V1 2
1388128 | 2 a | vanduo šaltas - V1 2
1388132 | 2 a | vanduo šaltas - V1 2
1388202 | 2 a | vanduo šaltas - V1 2
1388206 | 2 a | vanduo šaltas - V1 2
1388273 | 2 a | vanduo šaltas - V1 2
1388277 | 2 a | vanduo šaltas - V1 2
1388351 | 2 a | vanduo šaltas - V1 2
1388355 | 2 a | vanduo šaltas - V1 2
1388389 | 2 a | vanduo šaltas - V1 2
1388484 | 2 a | vanduo šaltas - V1 2
1388488 | 2 a | vanduo šaltas - V1 2
1388549 | 2 a | vanduo šaltas - V1 2
1388553 | 2 a | vanduo šaltas - V1 2
1388597 | 2 a | vanduo šaltas - V1 2
1388634 | 2 a | vanduo šaltas - V1 2
1388638 | 2 a | vanduo šaltas - V1 2
1388715 | 2 a | vanduo šaltas - V1 2
1388719 | 2 a | vanduo šaltas - V1 2
1388848 | 2 a | vanduo šaltas - V1 2
1388900 | 2 a | vanduo šaltas - V1 2
1388904 | 2 a | vanduo šaltas - V1 2
1388976 | 2 a | vanduo šaltas - V1 2
1388980 | 2 a | vanduo šaltas - V1 2
1389059 | 2 a | vanduo šaltas - V1 2
1389063 | 2 a | vanduo šaltas - V1 2
1389148 | 2 a | vanduo šaltas - V1 2
1389152 | 2 a | vanduo šaltas - V1 2
1389237 | 2 a | vanduo šaltas - V1 2
1389241 | 2 a | vanduo šaltas - V1 2
1389289 | 2 a | vanduo šaltas - V1 2
1389324 | 2 a | vanduo šaltas - V1 2
1389328 | 2 a | vanduo šaltas - V1 2
1389457 | 2 a | vanduo šaltas - V1 2
1389501 | 2 a | vanduo šaltas - V1 2
1389505 | 2 a | vanduo šaltas - V1 2
1389647 | 2 a | vanduo šaltas - V1 2
1389679 | 2 a | vanduo šaltas - V1 2
1389683 | 2 a | vanduo šaltas - V1 2
1389843 | 2 a | vanduo šaltas - V1 2
1389887 | 2 a | vanduo šaltas - V1 2
1389891 | 2 a | vanduo šaltas - V1 2
1389963 | 2 a | vanduo šaltas - V1 2
1389967 | 2 a | vanduo šaltas - V1 2
1390039 | 2 a | vanduo šaltas - V1 2
1390043 | 2 a | vanduo šaltas - V1 2
1390116 | 2 a | vanduo šaltas - V1 2
1390126 | 2 a | vanduo šaltas - V1 2
1390175 | 2 a | vanduo šaltas - V1 2
1390179 | 2 a | vanduo šaltas - V1 2
1390228 | 2 a | vanduo šaltas - V1 2
1390238 | 2 a | vanduo šaltas - V1 2
1390260 | 2 a | vanduo šaltas - V1 2
1390298 | 2 a | vanduo šaltas - V1 2
1390302 | 2 a | vanduo šaltas - V1 2
1390344 | 2 a | vanduo šaltas - V1 2
1390352 | 2 a | vanduo šaltas - V1 2
1390396 | 2 a | vanduo šaltas - V1 2
1390400 | 2 a | vanduo šaltas - V1 2
1390485 | 2 a | vanduo šaltas - V1 2
1390489 | 2 a | vanduo šaltas - V1 2
1390571 | 2 a | vanduo šaltas - V1 2
1390575 | 2 a | vanduo šaltas - V1 2
1390613 | 2 a | vanduo šaltas - V1 2
1390668 | 2 a | vanduo šaltas - V1 2
1390672 | 2 a | vanduo šaltas - V1 2
1390828 | 2 a | vanduo šaltas - V1 2
1390882 | 2 a | vanduo šaltas - V1 2
1390886 | 2 a | vanduo šaltas - V1 2
1390957 | 2 a | vanduo šaltas - V1 2
1390961 | 2 a | vanduo šaltas - V1 2
1391001 | 2 a | vanduo šaltas - V1 2
1391103 | 2 a | vanduo šaltas - V1 2
1391113 | 2 a | vanduo šaltas - V1 2
1391169 | 2 a | vanduo šaltas - V1 2
1391173 | 2 a | vanduo šaltas - V1 2
1391224 | 2 a | vanduo šaltas - V1 2
1391258 | 2 a | vanduo šaltas - V1 2
1391262 | 2 a | vanduo šaltas - V1 2
1391302 | 2 a | vanduo šaltas - V1 2
1391356 | 2 a | vanduo šaltas - V1 2
1391360 | 2 a | vanduo šaltas - V1 2
1391424 | 2 a | vanduo šaltas - V1 2
1391428 | 2 a | vanduo šaltas - V1 2
1391491 | 2 a | vanduo šaltas - V1 2
1391495 | 2 a | vanduo šaltas - V1 2
1391596 | 2 a | vanduo šaltas - V1 2
1391600 | 2 a | vanduo šaltas - V1 2
1391638 | 2 a | vanduo šaltas - V1 2
1391672 | 2 a | vanduo šaltas - V1 2
1391676 | 2 a | vanduo šaltas - V1 2
1391722 | 2 a | vanduo šaltas - V1 2
1391766 | 2 a | vanduo šaltas - V1 2
1391770 | 2 a | vanduo šaltas - V1 2
1391859 | 2 a | vanduo šaltas - V1 2
1391863 | 2 a | vanduo šaltas - V1 2
1391966 | 2 a | vanduo šaltas - V1 2
1391968 | 2 a | vanduo šaltas - V1 2
1392064 | 2 a | vanduo šaltas - V1 2
1392068 | 2 a | vanduo šaltas - V1 2
1392146 | 2 a | vanduo šaltas - V1 2
1392150 | 2 a | vanduo šaltas - V1 2
1392355 | 2 a | vanduo šaltas - V1 2
1392365 | 2 a | vanduo šaltas - V1 2
1392603 | 2 a | vanduo šaltas - V1 2
1392611 | 2 a | vanduo šaltas - V1 2
1392654 | 2 a | vanduo šaltas - V1 2
1392713 | 2 a | vanduo šaltas - V1 2
1392717 | 2 a | vanduo šaltas - V1 2
1392759 | 2 a | vanduo šaltas - V1 2
1392809 | 2 a | vanduo šaltas - V1 2
1392813 | 2 a | vanduo šaltas - V1 2
1392843 | 2 a | vanduo šaltas - V1 2
1392874 | 2 a | vanduo šaltas - V1 2
1392878 | 2 a | vanduo šaltas - V1 2
1393018 | 2 a | vanduo šaltas - V1 2
1393022 | 2 a | vanduo šaltas - V1 2
1393060 | 2 a | vanduo šaltas - V1 2
1393074 | 2 a | vanduo šaltas - V1 2
1393088 | 2 a | vanduo šaltas - V1 2
1393098 | 2 a | vanduo šaltas - V1 2
1393124 | 2 a | vanduo šaltas - V1 2
1393134 | 2 a | vanduo šaltas - V1 2
1393145 | 2 a | vanduo šaltas - V1 2
1393202 | 2 a | vanduo šaltas - V1 2
1393206 | 2 a | vanduo šaltas - V1 2
1393270 | 2 a | vanduo šaltas - V1 2
1393274 | 2 a | vanduo šaltas - V1 2
1393397 | 2 a | vanduo šaltas - V1 2
1393405 | 2 a | vanduo šaltas - V1 2
1394068 | 2 a | vanduo šaltas - V1 2
1394082 | 2 a | vanduo šaltas - V1 2
1394104 | 2 a | vanduo šaltas - V1 2
1394116 | 2 a | vanduo šaltas - V1 2
1394171 | 2 a | vanduo šaltas - V1 2
1394175 | 2 a | vanduo šaltas - V1 2
1394231 | 2 a | vanduo šaltas - V1 2
1394241 | 2 a | vanduo šaltas - V1 2
1394249 | 2 a | vanduo šaltas - V1 2
1394289 | 2 a | vanduo šaltas - V1 2
1394293 | 2 a | vanduo šaltas - V1 2
1394354 | 2 a | vanduo šaltas - V1 2
1394358 | 2 a | vanduo šaltas - V1 2
1394392 | 2 a | vanduo šaltas - V1 2
1394430 | 2 a | vanduo šaltas - V1 2
1394434 | 2 a | vanduo šaltas - V1 2
1394504 | 2 a | vanduo šaltas - V1 2
1394508 | 2 a | vanduo šaltas - V1 2
1394542 | 2 a | vanduo šaltas - V1 2
1394575 | 2 a | vanduo šaltas - V1 2
1394579 | 2 a | vanduo šaltas - V1 2
1394646 | 2 a | vanduo šaltas - V1 2
1394650 | 2 a | vanduo šaltas - V1 2
1394715 | 2 a | vanduo šaltas - V1 2
1394719 | 2 a | vanduo šaltas - V1 2
1394818 | 2 a | vanduo šaltas - V1 2
1394822 | 2 a | vanduo šaltas - V1 2
1394879 | 2 a | vanduo šaltas - V1 2
1394918 | 2 a | vanduo šaltas - V1 2
1394922 | 2 a | vanduo šaltas - V1 2
1394956 | 2 a | vanduo šaltas - V1 2
1395029 | 2 a | vanduo šaltas - V1 2
1395033 | 2 a | vanduo šaltas - V1 2
1395081 | 2 a | vanduo šaltas - V1 2
1395093 | 2 a | vanduo šaltas - V1 2
1395103 | 2 a | vanduo šaltas - V1 2
1395164 | 2 a | vanduo šaltas - V1 2
1395168 | 2 a | vanduo šaltas - V1 2
1395370 | 2 a | vanduo šaltas - V1 2
1395380 | 2 a | vanduo šaltas - V1 2
1395429 | 2 a | vanduo šaltas - V1 2
1395433 | 2 a | vanduo šaltas - V1 2
1395534 | 2 a | vanduo šaltas - V1 2
1395544 | 2 a | vanduo šaltas - V1 2
1395588 | 2 a | vanduo šaltas - V1 2
1395592 | 2 a | vanduo šaltas - V1 2
1395653 | 2 a | vanduo šaltas - V1 2
1395657 | 2 a | vanduo šaltas - V1 2
1395736 | 1 a +-152.84 | vanduo šaltas - V1 2
1395782 | 2 a | vanduo šaltas - V1 2
1395792 | 2 a | vanduo šaltas - V1 2
1395829 | 2 a | vanduo šaltas - V1 2
1395833 | 2 a | vanduo šaltas - V1 2
1395874 | 2 a | vanduo šaltas - V1 2
1395884 | 2 a | vanduo šaltas - V1 2
1395894 | 2 a | vanduo šaltas - V1 2
1395952 | 2 a | vanduo šaltas - V1 2
1395956 | 2 a | vanduo šaltas - V1 2
1396086 | 2 a | vanduo šaltas - V1 2
1396136 | 2 a | vanduo šaltas - V1 2
1396140 | 2 a | vanduo šaltas - V1 2
1396287 | 2 a | vanduo šaltas - V1 2
1396291 | 2 a | vanduo šaltas - V1 2
1396441 | 2 a | vanduo šaltas - V1 2
1396445 | 2 a | vanduo šaltas - V1 2
1396515 | 2 a | vanduo šaltas - V1 2
1396519 | 2 a | vanduo šaltas - V1 2
1396553 | 2 a | vanduo šaltas - V1 2
1396563 | 2 a | vanduo šaltas - V1 2
1396601 | 2 a | vanduo šaltas - V1 2
1396605 | 2 a | vanduo šaltas - V1 2
1396705 | 1 a +-152.84 | vanduo šaltas - V1 2
1396723 | 2 a | vanduo šaltas - V1 2
1396774 | 2 a | vanduo šaltas - V1 2
1396815 | 2 a | vanduo šaltas - V1 2
1396819 | 2 a | vanduo šaltas - V1 2
1397072 | 2 a | vanduo šaltas - V1 2
1397076 | 2 a | vanduo šaltas - V1 2
1397120 | 2 a | vanduo šaltas - V1 2
1397164 | 2 a | vanduo šaltas - V1 2
1397195 | 2 a | vanduo šaltas - V1 2
1397320 | 2 a | vanduo šaltas - V1 2
1397435 | 2 a | vanduo šaltas - V1 2
1397455 | 2 a | vanduo šaltas - V1 2
1397509 | 2 a | vanduo šaltas - V1 2
1397513 | 2 a | vanduo šaltas - V1 2
1397551 | 2 a | vanduo šaltas - V1 2
1397583 | 2 a | vanduo šaltas - V1 2
1397587 | 2 a | vanduo šaltas - V1 2
1397623 | 2 a | vanduo šaltas - V1 2
1397666 | 2 a | vanduo šaltas - V1 2
1397670 | 2 a | vanduo šaltas - V1 2
1397718 | 2 a | vanduo šaltas - V1 2
1397757 | 2 a | vanduo šaltas - V1 2
1397761 | 2 a | vanduo šaltas - V1 2
1397803 | 2 a | vanduo šaltas - V1 2
1397838 | 2 a | vanduo šaltas - V1 2
1397842 | 2 a | vanduo šaltas - V1 2
1397907 | 2 a | vanduo šaltas - V1 2
1397911 | 2 a | vanduo šaltas - V1 2
1397991 | 2 a | vanduo šaltas - V1 2
1397995 | 2 a | vanduo šaltas - V1 2
1398033 | 2 a | vanduo šaltas - V1 2
1398066 | 2 a | vanduo šaltas - V1 2
1398070 | 2 a | vanduo šaltas - V1 2
1398258 | 2 a | vanduo šaltas - V1 2
1398266 | 2 a | vanduo šaltas - V1 2
1398286 | 2 a | vanduo šaltas - V1 2
1398309 | 2 a | vanduo šaltas - V1 2
1398323 | 2 a | vanduo šaltas - V1 2
1398360 | 2 a | vanduo šaltas - V1 2
1398364 | 2 a | vanduo šaltas - V1 2
1398425 | 2 a | vanduo šaltas - V1 2
1398429 | 2 a | vanduo šaltas - V1 2
1398499 | 2 a | vanduo šaltas - V1 2
1398503 | 2 a | vanduo šaltas - V1 2
1398657 | 1 a +-152.84 | vanduo šaltas - V1 2
1398671 | 1 a +-152.84 | vanduo šaltas - V1 2
1398701 | 1 a +-152.84 | vanduo šaltas - V1 2
1398705 | 1 a +-152.84 | vanduo šaltas - V1 2
1398772 | 1 a +-152.84 | vanduo šaltas - V1 2
1398776 | 1 a +-152.84 | vanduo šaltas - V1 2
1398889 | 1 a +-152.84 | vanduo šaltas - V1 2
1398893 | 1 a +-152.84 | vanduo šaltas - V1 2
1398984 | 1 a +-152.84 | vanduo šaltas - V1 2
1398988 | 1 a +-152.84 | vanduo šaltas - V1 2
1399099 | 1 a +-152.84 | vanduo šaltas - V1 2
1399137 | 1 a +-152.84 | vanduo šaltas - V1 2
1399141 | 1 a +-152.84 | vanduo šaltas - V1 2
1399230 | 1 a +-152.84 | vanduo šaltas - V1 2
1399310 | 1 a +-152.84 | vanduo šaltas - V1 2
1399314 | 1 a +-152.84 | vanduo šaltas - V1 2
1399396 | 1 a +-152.84 | vanduo šaltas - V1 2
1399400 | 1 a +-152.84 | vanduo šaltas - V1 2
1399471 | 1 a +-152.84 | vanduo šaltas - V1 2
1399475 | 1 a +-152.84 | vanduo šaltas - V1 2
1399539 | 1 a +-152.84 | vanduo šaltas - V1 2
1399543 | 1 a +-152.84 | vanduo šaltas - V1 2
1399608 | 1 a +-152.84 | vanduo šaltas - V1 2
1399610 | 1 a +-152.84 | vanduo šaltas - V1 2
1399685 | 1 a +-152.84 | vanduo šaltas - V1 2
1399689 | 1 a +-152.84 | vanduo šaltas - V1 2
1400129 | 1 a +-152.84 | vanduo šaltas - V1 2
1400210 | 1 a +-152.84 | vanduo šaltas - V1 2
1400214 | 1 a +-152.84 | vanduo šaltas - V1 2
1400308 | 1 a +-152.84 | vanduo šaltas - V1 2
1400312 | 1 a +-152.84 | vanduo šaltas - V1 2
1400490 | 1 a +-152.84 | vanduo šaltas - V1 2
1400534 | 1 a +-152.84 | vanduo šaltas - V1 2
1400538 | 1 a +-152.84 | vanduo šaltas - V1 2
1400631 | 1 a +-152.84 | vanduo šaltas - V1 2
1400635 | 1 a +-152.84 | vanduo šaltas - V1 2
1400683 | 1 a +-152.84 | vanduo šaltas - V1 2
1400693 | 1 a +-152.84 | vanduo šaltas - V1 2
1400706 | 1 a +-152.84 | vanduo šaltas - V1 2
1400756 | 1 a +-152.84 | vanduo šaltas - V1 2
1400760 | 1 a +-152.84 | vanduo šaltas - V1 2
1400844 | 1 a +-152.84 | vanduo šaltas - V1 2
1400848 | 1 a +-152.84 | vanduo šaltas - V1 2
1400927 | 1 a +-152.84 | vanduo šaltas - V1 2
1400946 | 1 a +-152.84 | vanduo šaltas - V1 2
1400997 | 1 a +-152.84 | vanduo šaltas - V1 2
1401001 | 1 a +-152.84 | vanduo šaltas - V1 2
1401104 | 1 a +-152.84 | vanduo šaltas - V1 2
1401108 | 1 a +-152.84 | vanduo šaltas - V1 2
1401203 | 1 a +-152.84 | vanduo šaltas - V1 2
1401207 | 1 a +-152.84 | vanduo šaltas - V1 2
1401247 | 1 a +-152.84 | vanduo šaltas - V1 2
1401296 | 1 a +-152.84 | vanduo šaltas - V1 2
1401345 | 1 a +-152.84 | vanduo šaltas - V1 2
1401349 | 1 a +-152.84 | vanduo šaltas - V1 2
1401437 | 1 a +-152.84 | vanduo šaltas - V1 2
1401451 | 1 a +-152.84 | vanduo šaltas - V1 2
1401461 | 1 a +-152.84 | vanduo šaltas - V1 2
1401469 | 1 a +-152.84 | vanduo šaltas - V1 2
1401479 | 1 a +-152.84 | vanduo šaltas - V1 2
1401487 | 1 a +-152.84 | vanduo šaltas - V1 2
1401542 | 1 a +-152.84 | vanduo šaltas - V1 2
1401546 | 1 a +-152.84 | vanduo šaltas - V1 2
1401994 | 1 a +-152.84 | vanduo šaltas - V1 2
1401998 | 1 a +-152.84 | vanduo šaltas - V1 2
1402055 | 1 a +-152.84 | vanduo šaltas - V1 2
1402114 | 1 a +-152.84 | vanduo šaltas - V1 2
1402118 | 1 a +-152.84 | vanduo šaltas - V1 2
1402201 | 1 a +-152.84 | vanduo šaltas - V1 2
1402205 | 1 a +-152.84 | vanduo šaltas - V1 2
1402273 | 1 a +-152.84 | vanduo šaltas - V1 2
1402277 | 1 a +-152.84 | vanduo šaltas - V1 2
1402341 | 1 a +-152.84 | vanduo šaltas - V1 2
1402343 | 1 a +-152.84 | vanduo šaltas - V1 2
1402377 | 1 a +-152.84 | vanduo šaltas - V1 2
1402419 | 1 a +-152.84 | vanduo šaltas - V1 2
1402423 | 1 a +-152.84 | vanduo šaltas - V1 2
1402515 | 1 a +-152.84 | vanduo šaltas - V1 2
1402519 | 1 a +-152.84 | vanduo šaltas - V1 2
1402632 | 1 a +-152.84 | vanduo šaltas - V1 2
1402700 | 1 a +-152.84 | vanduo šaltas - V1 2
1402704 | 1 a +-152.84 | vanduo šaltas - V1 2
1402769 | 1 a +-152.84 | vanduo šaltas - V1 2
1402773 | 1 a +-152.84 | vanduo šaltas - V1 2
1402861 | 1 a +-152.84 | vanduo šaltas - V1 2
1402865 | 1 a +-152.84 | vanduo šaltas - V1 2
1402910 | 1 a +-152.84 | vanduo šaltas - V1 2
1402971 | 1 a +-152.84 | vanduo šaltas - V1 2
1402975 | 1 a +-152.84 | vanduo šaltas - V1 2
1403071 | 1 a +-152.84 | vanduo šaltas - V1 2
1403075 | 1 a +-152.84 | vanduo šaltas - V1 2
1403143 | 1 a +-152.84 | vanduo šaltas - V1 2
1403147 | 1 a +-152.84 | vanduo šaltas - V1 2
1403192 | 1 a +-152.84 | vanduo šaltas - V1 2
1403215 | 1 a +-152.84 | vanduo šaltas - V1 2
1403254 | 1 a +-152.84 | vanduo šaltas - V1 2
1403258 | 1 a +-152.84 | vanduo šaltas - V1 2
1403394 | 1 a +-152.84 | vanduo šaltas - V1 2
1403398 | 1 a +-152.84 | vanduo šaltas - V1 2
1403468 | 1 a +-152.84 | vanduo šaltas - V1 2
1403472 | 1 a +-152.84 | vanduo šaltas - V1 2
1403523 | 1 a +-152.84 | vanduo šaltas - V1 2
1403533 | 1 a +-152.84 | vanduo šaltas - V1 2
1403582 | 1 a +-152.84 | vanduo šaltas - V1 2
1403586 | 1 a +-152.84 | vanduo šaltas - V1 2
1403642 | 1 a +-152.84 | vanduo šaltas - V1 2
1403650 | 1 a +-152.84 | vanduo šaltas - V1 2
1403709 | 1 a +-152.84 | vanduo šaltas - V1 2
1403713 | 1 a +-152.84 | vanduo šaltas - V1 2
1403725 | 1 a +-152.84 | vanduo šaltas - V1 2
1403771 | 1 a +-152.84 | vanduo šaltas - V1 2
1403775 | 1 a +-152.84 | vanduo šaltas - V1 2
1403848 | 1 a +-152.84 | vanduo šaltas - V1 2
1403852 | 1 a +-152.84 | vanduo šaltas - V1 2
1403914 | 1 a +-152.84 | vanduo šaltas - V1 2
1403918 | 1 a +-152.84 | vanduo šaltas - V1 2
1404006 | 1 a +-152.84 | vanduo šaltas - V1 2
1404010 | 1 a +-152.84 | vanduo šaltas - V1 2
1404083 | 1 a +-152.84 | vanduo šaltas - V1 2
1404087 | 1 a +-152.84 | vanduo šaltas - V1 2
1404184 | 1 a +-152.84 | vanduo šaltas - V1 2
1404192 | 1 a +-152.84 | vanduo šaltas - V1 2
1404232 | 1 a +-152.84 | vanduo šaltas - V1 2
1404236 | 1 a +-152.84 | vanduo šaltas - V1 2
1404292 | 1 a +-152.84 | vanduo šaltas - V1 2
1404296 | 1 a +-152.84 | vanduo šaltas - V1 2
1404375 | 1 a +-152.84 | vanduo šaltas - V1 2
1404379 | 1 a +-152.84 | vanduo šaltas - V1 2
1404726 | 1 a +-152.84 | vanduo šaltas - V1 2
1404730 | 1 a +-152.84 | vanduo šaltas - V1 2
1404780 | 1 a +-152.84 | vanduo šaltas - V1 2
1404827 | 1 a +-152.84 | vanduo šaltas - V1 2
1404831 | 1 a +-152.84 | vanduo šaltas - V1 2
1405013 | 1 a +-152.84 | vanduo šaltas - V1 2
1405017 | 1 a +-152.84 | vanduo šaltas - V1 2
1405357 | 1 a +-152.84 | vanduo šaltas - V1 2
1405361 | 1 a +-152.84 | vanduo šaltas - V1 2
1405409 | 1 a +-152.84 | vanduo šaltas - V1 2
1405457 | 1 a +-152.84 | vanduo šaltas - V1 2
1405461 | 1 a +-152.84 | vanduo šaltas - V1 2
1405520 | 1 a +-152.84 | vanduo šaltas - V1 2
1405524 | 1 a +-152.84 | vanduo šaltas - V1 2
1405596 | 1 a +-152.84 | vanduo šaltas - V1 2
1405600 | 1 a +-152.84 | vanduo šaltas - V1 2
1405740 | 1 a +-152.84 | vanduo šaltas - V1 2
1405744 | 1 a +-152.84 | vanduo šaltas - V1 2
1405822 | 1 a +-152.84 | vanduo šaltas - V1 2
1405826 | 1 a +-152.84 | vanduo šaltas - V1 2
1405895 | 1 a +-152.84 | vanduo šaltas - V1 2
1405950 | 1 a +-152.84 | vanduo šaltas - V1 2
1405954 | 1 a +-152.84 | vanduo šaltas - V1 2
1406052 | 1 a +-152.84 | vanduo šaltas - V1 2
1406057 | 1 a +-152.84 | vanduo šaltas - V1 2
1406097 | 1 a +-152.84 | vanduo šaltas - V1 2
