Properties of the parts of a building model (IFC2X3), part 31 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1464085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464079_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464085_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464079_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464147_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464087_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464151_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464087_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464145_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464147_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464145_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464151_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464184_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464311_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464184_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464211_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464196_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464196_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464200_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464211_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464219_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464213_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464219_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464221_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464283_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464221_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464277_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464279_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464277_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464283_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464301_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464311_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464311_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464315_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464362_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464315_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464358_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464360_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464382_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464476_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464390_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464391_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464390_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464477_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464391_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464859_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464394_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464447_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464394_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464443_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464445_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464443_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464447_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464463_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464480_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464463_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464474_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464476_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464474_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464480_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464476_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464477_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464627_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465289_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464631_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464632_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464631_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492178_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464665_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464666_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464665_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1492120_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464665_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464738_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464738_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464757_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464746_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464757_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464746_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464771_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464759_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464771_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464759_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464783_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464773_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464783_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464773_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465219_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464785_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465219_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464785_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464815_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464804_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464815_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464804_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464844_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464817_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464844_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464817_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464859_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465139_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464870_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465138_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464870_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464892_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464900_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464892_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465006_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464902_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465006_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464902_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464932_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464984_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464932_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464978_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464980_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464978_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464984_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465006_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465017_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465017_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465108_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465027_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465112_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465106_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465108_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465106_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465112_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465130_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465138_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465130_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465187_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465138_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465139_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465142_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465191_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465142_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465183_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465185_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465183_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465191_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465185_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465187_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465219_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465230_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465230_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465258_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465244_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465258_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465244_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465274_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465288_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465274_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465300_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465288_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465289_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465292_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465300_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465292_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465311_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465302_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465311_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465302_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465321_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465313_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465321_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465313_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465323_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465371_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465323_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465367_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465369_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465367_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465371_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465409_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465427_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465409_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465647_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465427_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465429_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465475_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465483_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465475_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465529_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465483_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465484_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465529_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490560_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465560_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1490291_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465560_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465610_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465600_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465608_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465600_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466589_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465608_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465610_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465631_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466494_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465631_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465655_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465647_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466737_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465649_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465757_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465649_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465655_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466143_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465657_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465665_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465657_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465677_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465665_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465667_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465671_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465677_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465671_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491824_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465679_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465731_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465725_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1491824_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465725_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465731_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465749_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465757_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465749_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466233_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465757_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465758_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466053_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465761_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466233_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465761_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465822_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465769_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465826_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465820_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465822_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465820_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465826_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465873_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465964_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465873_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465891_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466054_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465881_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465882_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465881_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465965_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465882_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466142_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465885_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465891_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465885_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465933_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465893_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465937_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465893_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465931_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465933_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465931_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465958_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465964_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465964_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465965_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465968_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466027_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465968_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466021_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466023_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466021_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466043_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466053_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466043_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466053_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466054_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466057_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466113_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466057_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466109_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466111_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466109_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466113_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466134_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466142_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466134_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466142_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466143_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466146_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466200_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466146_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466194_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466196_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466233_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466384_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466244_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466383_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466244_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466263_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466254_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466263_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466254_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466265_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466358_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466301_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466303_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466367_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466383_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466367_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466395_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466383_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466384_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466387_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466395_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466387_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466462_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466397_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466464_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466397_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466460_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466462_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466460_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466464_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466482_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466494_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466482_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466508_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466494_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466495_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466736_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466498_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466498_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466561_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466510_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466563_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466510_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466559_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466561_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466559_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466581_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466589_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466581_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466597_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466591_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466668_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466591_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466609_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466597_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466669_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466599_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466609_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466599_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466660_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466668_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466660_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466699_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466668_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466669_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466672_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466699_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466672_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466720_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466736_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466720_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466748_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466736_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466737_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466740_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466748_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466740_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466756_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466750_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466756_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466750_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466766_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466758_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466766_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466850_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466768_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466768_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466776_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466784_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466776_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466829_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466786_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466831_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466786_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466827_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466829_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466827_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466831_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466850_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466861_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466861_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466883_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466875_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466883_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466875_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466927_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466885_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466929_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466885_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466925_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466927_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466925_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466929_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1466961_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467003_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1466961_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467015_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467003_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467004_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467009_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468039_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467009_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467085_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467015_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468040_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467077_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467085_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467077_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467192_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467204_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467192_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467204_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467205_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467208_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467238_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467208_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488690_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467240_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1488690_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467240_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467258_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467252_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467258_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467260_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467268_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467260_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467801_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467270_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467561_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467270_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467348_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467340_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467348_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467356_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467350_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467533_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467350_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467405_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467356_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467534_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467358_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467411_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467403_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467407_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467403_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467411_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467405_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467407_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467520_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467537_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467520_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467531_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467533_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467537_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467533_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467553_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467561_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467553_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467575_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467561_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467562_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467562_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467780_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467565_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467687_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467565_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467589_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467575_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467577_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467688_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467581_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467589_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467581_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467591_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467663_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467591_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467657_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467659_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467657_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467663_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467679_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467687_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467687_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467688_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467691_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467697_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467691_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467699_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467749_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467743_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467745_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467743_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467749_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467767_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467784_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467778_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467780_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467778_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467780_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467781_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467781_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467801_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467801_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467835_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467835_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467948_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467937_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467950_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467946_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467948_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467946_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467950_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468031_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468039_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468031_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468049_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468039_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468040_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468043_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468049_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468043_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488726_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468051_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488726_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468051_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468075_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468069_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468075_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468069_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468085_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468085_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468087_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468087_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468196_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468208_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468353_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468208_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468209_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468208_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486826_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468345_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468353_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468345_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468361_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468361_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468758_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468674_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468717_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468674_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468732_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468717_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468718_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468717_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486858_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468724_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468732_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468724_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468740_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468740_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469595_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469084_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468764_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468886_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468764_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468774_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468854_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468804_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468806_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468810_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468858_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468810_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468852_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468854_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468852_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468858_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468874_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468886_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468874_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468927_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468886_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468887_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468887_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468890_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468931_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468890_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468925_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468927_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468925_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468931_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468960_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468980_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468960_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469003_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468980_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468981_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468981_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469084_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468984_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469003_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468984_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469063_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469005_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469067_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469005_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469061_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469063_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469067_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469084_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469134_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469134_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469186_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469178_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469186_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469178_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469200_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469188_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469655_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469188_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469208_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469656_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469202_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469328_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469202_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469208_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469410_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469210_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469238_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469210_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469236_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469242_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469288_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469242_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469282_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469284_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469282_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469288_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469318_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469328_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469318_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469375_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469328_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469329_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469329_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469409_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469332_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469379_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469373_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469375_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469373_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469379_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469401_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469409_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469401_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469419_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469409_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469413_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469518_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469413_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469429_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469419_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469519_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469421_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469429_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469421_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469488_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469431_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469492_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469431_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469486_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469488_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469486_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469492_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469510_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469518_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469510_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469518_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469519_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469522_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469577_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469571_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469573_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469595_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469611_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469603_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469611_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469603_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469619_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469613_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469619_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469613_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469631_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469621_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469631_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469621_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1469645_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469655_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469645_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469672_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469655_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469656_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469659_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469683_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469672_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469754_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469674_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469683_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469674_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469723_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469685_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469725_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469685_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469721_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469723_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469721_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469725_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469741_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469835_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469741_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469753_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469754_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469753_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469836_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469757_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469757_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469804_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469806_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469824_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469869_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469824_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469833_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469835_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469869_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469835_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469836_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 11
Port_1469923_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469924_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469923_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483398_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469923_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470600_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469959_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470671_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469959_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469995_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469977_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470119_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469977_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470021_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469993_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469995_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469993_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470304_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469999_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470023_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469999_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470035_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470021_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470027_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470035_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470037_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470089_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470037_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470083_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470085_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470105_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470119_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470105_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470137_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470119_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470120_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470120_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470123_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470137_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470123_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470183_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470139_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470187_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470139_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470181_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470183_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470181_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470187_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470203_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470213_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470203_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470225_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470213_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470214_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470214_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470217_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470225_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470217_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
