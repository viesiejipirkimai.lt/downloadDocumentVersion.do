Properties of the parts of a building model (IFC2X3), part 53 of 57

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1380986 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1381026 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1381048 | 2 a | 321.227 | 7690 | vanduo šaltas - V1 2
1381059 | 2 a | 263.362 | 7684 | vanduo šaltas - V1 2
1381062 | 2 a | 110.5 | 7692.3 | vanduo šaltas - V1 2
1381091 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1381133 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1381165 | 2 a | 158 | 7692.3 | vanduo šaltas - V1 2
1381174 | 2 a | 1579.27 | 7690 | vanduo šaltas - V1 2
1381177 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1381218 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1381240 | 2 a | 450 | 7692.3 | vanduo šaltas - V1 2
1381251 | 2 a | 1796.49 | 7684 | vanduo šaltas - V1 2
1381254 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1381290 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1381314 | 2 a | 210 | 7692.3 | vanduo šaltas - V1 2
1381325 | 2 a | 648.321 | 7684 | vanduo šaltas - V1 2
1381328 | 2 a | 60 | 5342.3 | vanduo šaltas - V1 2
1381363 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1381385 | 2 a | 210 | 7692.3 | vanduo šaltas - V1 2
1381398 | 2 a | 174.466 | 7684 | vanduo šaltas - V1 2
1381401 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1381435 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1381473 | 2 a | 2165.17 | 7692.3 | vanduo šaltas - V1 2
1381490 | 2 a | 96.1457 | 7684 | vanduo šaltas - V1 2
1381493 | 2 a | 200 | 7692.3 | vanduo šaltas - V1 2
1381503 | 2 a | 50 | 5142.3 | vanduo šaltas - V1 2
1381531 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1381553 | 2 a | 280 | 7692.3 | vanduo šaltas - V1 2
1381562 | 2 a | 1931.57 | 7690 | vanduo šaltas - V1 2
1381565 | 2 a | 120 | 7692.3 | vanduo šaltas - V1 2
1381573 | 2 a | 60 | 5342.3 | vanduo šaltas - V1 2
1381601 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1381623 | 2 a | 157 | 7692.3 | vanduo šaltas - V1 2
1381632 | 2 a | 1673.26 | 7690 | vanduo šaltas - V1 2
1381635 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1381665 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1381706 | 2 a | 170 | 7692.3 | vanduo šaltas - V1 2
1381717 | 2 a | 2371.04 | 7684 | vanduo šaltas - V1 2
1381720 | 2 a | 80 | 7692.3 | vanduo šaltas - V1 2
1381739 | 2 a | 61.2291 | 5142.3 | vanduo šaltas - V1 2
1381765 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1381978 | 2 a | 1832.08 | 7690 | vanduo šaltas - V1 2
1381986 | 2 a | 524 | 7692.3 | vanduo šaltas - V1 2
1382018 | 2 a | 55 | 5142.3 | vanduo šaltas - V1 2
1382049 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1382213 | 2 a | 90.5 | 7692.3 | vanduo šaltas - V1 2
1382228 | 2 a | 1335.92 | 7690 | vanduo šaltas - V1 2
1382231 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1382277 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1382305 | 2 a | 1187.49 | 7690 | vanduo šaltas - V1 2
1382318 | 2 a | 88.2034 | 7684 | vanduo šaltas - V1 2
1382321 | 2 a | 516.39 | 7690 | vanduo šaltas - V1 2
1382349 | 2 a | 269 | 7692.3 | vanduo šaltas - V1 2
1382368 | 2 a | 100 | 7692.3 | vanduo šaltas - V1 2
1382376 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1382411 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1382470 | 2 a | 118 | 7692.3 | vanduo šaltas - V1 2
1382481 | 2 a | 1519.61 | 7690 | vanduo šaltas - V1 2
1382484 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1382529 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1382551 | 2 a | 303 | 7692.3 | vanduo šaltas - V1 2
1382562 | 2 a | 271.932 | 7690 | vanduo šaltas - V1 2
1382565 | 2 a | 55 | 4842.3 | vanduo šaltas - V1 2
1382604 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1382628 | 2 a | 1618 | 7692.3 | vanduo šaltas - V1 2
1382639 | 2 a | 433.04 | 7690 | vanduo šaltas - V1 2
1382642 | 2 a | 140 | 7692.3 | vanduo šaltas - V1 2
1382655 | 2 a | 56.8849 | 5142.3 | vanduo šaltas - V1 2
1382686 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1382711 | 2 a | 78 | 7692.3 | vanduo šaltas - V1 2
1382722 | 2 a | 654.547 | 7690 | vanduo šaltas - V1 2
1382725 | 2 a | 140 | 5342.3 | vanduo šaltas - V1 2
1382748 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1382772 | 2 a | 58 | 7692.3 | vanduo šaltas - V1 2
1382785 | 2 a | 720.991 | 7690 | vanduo šaltas - V1 2
1382788 | 2 a | 19 | 4842.3 | vanduo šaltas - V1 2
1382824 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1382856 | 2 a | 638 | 7692.3 | vanduo šaltas - V1 2
1382865 | 2 a | 565.711 | 7690 | vanduo šaltas - V1 2
1382868 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1382901 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1382945 | 2 a | 821 | 7692.3 | vanduo šaltas - V1 2
1382961 | 2 a | 100 | 7692.3 | vanduo šaltas - V1 2
1383505 | 1 a +-152.84 | 4036.22 | 3544 | vanduo šaltas - V1 2
1383526 | 2 a | 708.509 | 7604.22 | vanduo šaltas - V1 2
1383623 | 2 a | 648 | 7604.22 | vanduo šaltas - V1 2
1383636 | 2 a | 3480.19 | 7598.22 | vanduo šaltas - V1 2
1383639 | 2 a | 120.946 | 7604.22 | vanduo šaltas - V1 2
1383649 | 2 a | 1599 | 7606.52 | vanduo šaltas - V1 2
1383661 | 2 a | 220 | 7606.52 | vanduo šaltas - V1 2
1383671 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1383697 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1383719 | 2 a | 298 | 7606.52 | vanduo šaltas - V1 2
1383730 | 2 a | 710.351 | 7604.22 | vanduo šaltas - V1 2
1383733 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1383761 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1383785 | 2 a | 278 | 7606.52 | vanduo šaltas - V1 2
1383798 | 2 a | 224.703 | 7604.22 | vanduo šaltas - V1 2
1383801 | 2 a | 60 | 5342.3 | vanduo šaltas - V1 2
1383830 | 2 a | 2224.22 | 5370 | vanduo šaltas - V1 2
1383860 | 2 a | 5148 | 7604.22 | vanduo šaltas - V1 2
1383883 | 2 a | 253.066 | 7598.22 | vanduo šaltas - V1 2
1383896 | 2 a | 539.753 | 7604.22 | vanduo šaltas - V1 2
1383908 | 2 a | 380.774 | 7604.22 | vanduo šaltas - V1 2
1383916 | 2 a | 2519 | 7606.52 | vanduo šaltas - V1 2
1383949 | 2 a | 420 | 7606.52 | vanduo šaltas - V1 2
1383957 | 2 a | 340 | 7606.52 | vanduo šaltas - V1 2
1383967 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1383989 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1384011 | 2 a | 92.7493 | 7606.52 | vanduo šaltas - V1 2
1384022 | 2 a | 512.846 | 7604.22 | vanduo šaltas - V1 2
1384025 | 2 a | 80 | 7606.52 | vanduo šaltas - V1 2
1384038 | 2 a | 140 | 5142.3 | vanduo šaltas - V1 2
1384070 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1384097 | 2 a | 166.551 | 7606.52 | vanduo šaltas - V1 2
1384106 | 2 a | 2565.25 | 7606.52 | vanduo šaltas - V1 2
1384109 | 2 a | 45 | 5142.3 | vanduo šaltas - V1 2
1384146 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1384176 | 2 a | 338 | 7606.52 | vanduo šaltas - V1 2
1384185 | 2 a | 1058.68 | 7604.22 | vanduo šaltas - V1 2
1384188 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1384218 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1384271 | 2 a | 338 | 7606.52 | vanduo šaltas - V1 2
1384280 | 2 a | 336.549 | 7604.22 | vanduo šaltas - V1 2
1384283 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1384312 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1384351 | 2 a | 974.086 | 7606.52 | vanduo šaltas - V1 2
1384364 | 2 a | 479.06 | 7604.22 | vanduo šaltas - V1 2
1384367 | 2 a | 336.822 | 7606.52 | vanduo šaltas - V1 2
1384377 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1384409 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1384443 | 2 a | 180 | 7606.52 | vanduo šaltas - V1 2
1384452 | 2 a | 223.914 | 7606.52 | vanduo šaltas - V1 2
1384455 | 2 a | 120 | 4842.3 | vanduo šaltas - V1 2
1384507 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1384529 | 2 a | 941.768 | 7606.52 | vanduo šaltas - V1 2
1384540 | 2 a | 784.342 | 7604.22 | vanduo šaltas - V1 2
1384543 | 2 a | 80 | 7606.52 | vanduo šaltas - V1 2
1384553 | 2 a | 137.763 | 5142.3 | vanduo šaltas - V1 2
1384583 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1384604 | 2 a | 160 | 4842.3 | vanduo šaltas - V1 2
1384613 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1384616 | 2 a | 416.232 | 7606.52 | vanduo šaltas - V1 2
1384645 | 2 a | 130 | 7606.52 | vanduo šaltas - V1 2
1384654 | 2 a | 1633.23 | 7598.22 | vanduo šaltas - V1 2
1384657 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1384727 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1384751 | 2 a | 159.519 | 7606.52 | vanduo šaltas - V1 2
1384764 | 2 a | 2653.55 | 7598.22 | vanduo šaltas - V1 2
1384767 | 2 a | 300 | 7606.52 | vanduo šaltas - V1 2
1384777 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1384811 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1384835 | 2 a | 2341.44 | 7604.22 | vanduo šaltas - V1 2
1384850 | 2 a | 2543.6 | 7598.22 | vanduo šaltas - V1 2
1384853 | 2 a | 178 | 5340 | vanduo šaltas - V1 2
1384889 | 2 a | 2220.22 | 5372 | vanduo šaltas - V1 2
1384990 | 2 a | 278 | 7606.52 | vanduo šaltas - V1 2
1384999 | 2 a | 1955.14 | 7604.22 | vanduo šaltas - V1 2
1385002 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1385032 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1385053 | 2 a | 168 | 7606.52 | vanduo šaltas - V1 2
1385062 | 2 a | 111.419 | 7604.22 | vanduo šaltas - V1 2
1385065 | 2 a | 45 | 5142.3 | vanduo šaltas - V1 2
1385086 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1385109 | 2 a | 135.016 | 7606.52 | vanduo šaltas - V1 2
1385120 | 2 a | 155.411 | 7598.22 | vanduo šaltas - V1 2
1385123 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1385157 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1385246 | 2 a | 1931.63 | 7604.22 | vanduo šaltas - V1 2
1385257 | 2 a | 2423.8 | 7598.22 | vanduo šaltas - V1 2
1385260 | 2 a | 49 | 7606.52 | vanduo šaltas - V1 2
1385277 | 2 a | 125 | 5142.3 | vanduo šaltas - V1 2
1385330 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1385408 | 2 a | 2178 | 7606.52 | vanduo šaltas - V1 2
1385419 | 2 a | 1208.54 | 7604.22 | vanduo šaltas - V1 2
1385422 | 2 a | 105 | 7606.52 | vanduo šaltas - V1 2
1385441 | 2 a | 35 | 5142.3 | vanduo šaltas - V1 2
1385475 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1385499 | 2 a | 338 | 7606.52 | vanduo šaltas - V1 2
1385508 | 2 a | 355.278 | 7604.22 | vanduo šaltas - V1 2
1385511 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1385555 | 2 a | 2724.22 | 4870 | vanduo šaltas - V1 2
1385596 | 2 a | 319 | 7606.52 | vanduo šaltas - V1 2
1385614 | 2 a | 80 | 5342.3 | vanduo šaltas - V1 2
1385642 | 2 a | 2224.22 | 5370 | vanduo šaltas - V1 2
1385879 | 2 a | 10 | 7606.52 | vanduo šaltas - V1 2
1385888 | 2 a | 2814.98 | 7606.52 | vanduo šaltas - V1 2
1385891 | 2 a | 6640 | 7606.52 | vanduo šaltas - V1 2
1385901 | 2 a | 180 | 5142.3 | vanduo šaltas - V1 2
1385933 | 2 a | 2424.22 | 5170 | vanduo šaltas - V1 2
1386030 | 0 a | 11132.4 | 3450 | vanduo šaltas - V1 2
1386033 | 2 a | 7265 | 3467 | vanduo šaltas - V1 2
1386221 | 2 a | 4148 | 3506 | vanduo šaltas - V1 2
1386433 | 2 a | 108.133 | 7670 | vanduo šaltas - V1 2
1386466 | 2 a | 2419 | 7672.3 | vanduo šaltas - V1 2
1386486 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1386518 | 2 a | 2490 | 5170 | vanduo šaltas - V1 2
1386732 | 2 a | 2008.75 | 7672.3 | vanduo šaltas - V1 2
1386747 | 2 a | 816.001 | 7670 | vanduo šaltas - V1 2
1386750 | 2 a | 260 | 7672.3 | vanduo šaltas - V1 2
1386760 | 2 a | 360 | 7672.3 | vanduo šaltas - V1 2
1386770 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1386808 | 2 a | 2490 | 5170 | vanduo šaltas - V1 2
1386829 | 2 a | 278 | 7672.3 | vanduo šaltas - V1 2
1386840 | 2 a | 105.936 | 7670 | vanduo šaltas - V1 2
1386843 | 2 a | 140 | 4842.3 | vanduo šaltas - V1 2
1386874 | 2 a | 2790 | 4870 | vanduo šaltas - V1 2
1386895 | 2 a | 140 | 7672.3 | vanduo šaltas - V1 2
1386904 | 2 a | 110.41 | 7667 | vanduo šaltas - V1 2
1386907 | 2 a | 60 | 4842.3 | vanduo šaltas - V1 2
1386966 | 2 a | 2790 | 4870 | vanduo šaltas - V1 2
1387006 | 2 a | 733.345 | 7670 | vanduo šaltas - V1 2
1387021 | 2 a | 177.111 | 7667 | vanduo šaltas - V1 2
1387024 | 2 a | 79 | 7672.3 | vanduo šaltas - V1 2
1387041 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1387089 | 2 a | 2490 | 5170 | vanduo šaltas - V1 2
1387116 | 2 a | 143 | 7672.3 | vanduo šaltas - V1 2
1387125 | 2 a | 742.55 | 7670 | vanduo šaltas - V1 2
1387128 | 2 a | 55 | 4942.3 | vanduo šaltas - V1 2
1387161 | 2 a | 2690 | 4970 | vanduo šaltas - V1 2
1387189 | 2 a | 338 | 7672.3 | vanduo šaltas - V1 2
1387198 | 2 a | 516.105 | 7670 | vanduo šaltas - V1 2
1387201 | 2 a | 120 | 4842.3 | vanduo šaltas - V1 2
1387237 | 2 a | 2790 | 4870 | vanduo šaltas - V1 2
1387262 | 2 a | 152.827 | 7670 | vanduo šaltas - V1 2
1387295 | 2 a | 110.41 | 7667 | vanduo šaltas - V1 2
1387298 | 2 a | 899 | 7672.3 | vanduo šaltas - V1 2
1387315 | 2 a | 500 | 7672.3 | vanduo šaltas - V1 2
1387323 | 2 a | 200 | 7672.3 | vanduo šaltas - V1 2
1387333 | 2 a | 90 | 4992.3 | vanduo šaltas - V1 2
1387440 | 2 a | 2640 | 5020 | vanduo šaltas - V1 2
1387462 | 2 a | 293 | 7672.3 | vanduo šaltas - V1 2
1387471 | 2 a | 667.15 | 7670 | vanduo šaltas - V1 2
1387474 | 2 a | 55 | 4942.3 | vanduo šaltas - V1 2
1387509 | 2 a | 2690 | 4970 | vanduo šaltas - V1 2
1387566 | 2 a | 458 | 7672.3 | vanduo šaltas - V1 2
1387575 | 2 a | 512.023 | 7670 | vanduo šaltas - V1 2
1387578 | 2 a | 100 | 4942.3 | vanduo šaltas - V1 2
1387613 | 2 a | 2690 | 4970 | vanduo šaltas - V1 2
1387634 | 2 a | 800 | 7672.3 | vanduo šaltas - V1 2
1387643 | 2 a | 149.253 | 7672.3 | vanduo šaltas - V1 2
1387646 | 2 a | 2300 | 7672.3 | vanduo šaltas - V1 2
1387660 | 2 a | 1640 | 7672.3 | vanduo šaltas - V1 2
1387670 | 2 a | 80 | 7672.3 | vanduo šaltas - V1 2
1387678 | 2 a | 180 | 5142.3 | vanduo šaltas - V1 2
1387707 | 2 a | 2490 | 5170 | vanduo šaltas - V1 2
1387788 | 2 a | 5280.13 | 3467 | vanduo šaltas - V1 2
1387816 | 0 a | 11803.6 | 3450 | vanduo šaltas - V1 2
1387819 | 2 a | 617.015 | 3467 | vanduo šaltas - V1 2
1387906 | 2 a | 4342 | 3506 | vanduo šaltas - V1 2
1387939 | 2 a | 110.746 | 7861 | vanduo šaltas - V1 2
1387947 | 2 a | 1322.29 | 7864 | vanduo šaltas - V1 2
1387965 | 2 a | 279 | 7866.3 | vanduo šaltas - V1 2
1388020 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1388048 | 2 a | 2984 | 4870 | vanduo šaltas - V1 2
1388070 | 2 a | 292.92 | 7866.3 | vanduo šaltas - V1 2
1388083 | 2 a | 482 | 7864 | vanduo šaltas - V1 2
1388086 | 2 a | 84.1383 | 7866.3 | vanduo šaltas - V1 2
1388094 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1388126 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1388148 | 2 a | 185 | 7866.3 | vanduo šaltas - V1 2
1388165 | 2 a | 1305.08 | 7866.3 | vanduo šaltas - V1 2
1388168 | 2 a | 55 | 5142.3 | vanduo šaltas - V1 2
1388200 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1388224 | 2 a | 278 | 7866.3 | vanduo šaltas - V1 2
1388235 | 2 a | 1208.96 | 7864 | vanduo šaltas - V1 2
1388238 | 2 a | 60 | 4842.3 | vanduo šaltas - V1 2
1388271 | 2 a | 2984 | 4870 | vanduo šaltas - V1 2
1388293 | 2 a | 298 | 7866.3 | vanduo šaltas - V1 2
1388304 | 2 a | 750.664 | 7864 | vanduo šaltas - V1 2
1388307 | 2 a | 60 | 4842.3 | vanduo šaltas - V1 2
1388349 | 2 a | 2984 | 4870 | vanduo šaltas - V1 2
1388371 | 2 a | 724.85 | 7866.3 | vanduo šaltas - V1 2
1388380 | 2 a | 2372.08 | 7864 | vanduo šaltas - V1 2
1388383 | 2 a | 180 | 7866.3 | vanduo šaltas - V1 2
1388391 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1388482 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1388504 | 2 a | 200 | 7866.3 | vanduo šaltas - V1 2
1388515 | 2 a | 673.15 | 7866.3 | vanduo šaltas - V1 2
1388518 | 2 a | 60 | 4942.3 | vanduo šaltas - V1 2
1388547 | 2 a | 2884 | 4970 | vanduo šaltas - V1 2
1388569 | 2 a | 154 | 7866.3 | vanduo šaltas - V1 2
1388586 | 2 a | 1456.49 | 7861 | vanduo šaltas - V1 2
1388589 | 2 a | 680 | 7866.3 | vanduo šaltas - V1 2
1388599 | 2 a | 80 | 5342.3 | vanduo šaltas - V1 2
1388632 | 2 a | 2484 | 5370 | vanduo šaltas - V1 2
1388660 | 2 a | 2934 | 7866.3 | vanduo šaltas - V1 2
1388673 | 2 a | 2567.88 | 7861 | vanduo šaltas - V1 2
1388676 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1388713 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1388814 | 2 a | 85.6933 | 7864 | vanduo šaltas - V1 2
1388837 | 2 a | 5927.26 | 7861 | vanduo šaltas - V1 2
1388840 | 2 a | 99 | 7866.3 | vanduo šaltas - V1 2
1388854 | 2 a | 180 | 5142.3 | vanduo šaltas - V1 2
1388898 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1388919 | 2 a | 168 | 7866.3 | vanduo šaltas - V1 2
1388932 | 2 a | 3757.91 | 7864 | vanduo šaltas - V1 2
1388935 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1388974 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1388996 | 2 a | 193 | 7866.3 | vanduo šaltas - V1 2
1389007 | 2 a | 3990.38 | 7864 | vanduo šaltas - V1 2
1389010 | 2 a | 70 | 5342.3 | vanduo šaltas - V1 2
1389057 | 2 a | 2484 | 5370 | vanduo šaltas - V1 2
1389079 | 2 a | 188 | 7866.3 | vanduo šaltas - V1 2
1389090 | 2 a | 73.0185 | 7864 | vanduo šaltas - V1 2
1389093 | 2 a | 65 | 5342.3 | vanduo šaltas - V1 2
1389146 | 2 a | 2484 | 5370 | vanduo šaltas - V1 2
1389174 | 2 a | 74 | 3472.3 | vanduo šaltas - V1 2
1389183 | 2 a | 150.985 | 3467 | vanduo šaltas - V1 2
1389186 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1389235 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1389261 | 2 a | 4634 | 7866.3 | vanduo šaltas - V1 2
1389278 | 2 a | 706.625 | 7861 | vanduo šaltas - V1 2
1389281 | 2 a | 815 | 7866.3 | vanduo šaltas - V1 2
1389291 | 2 a | 105 | 5142.3 | vanduo šaltas - V1 2
1389322 | 2 a | 2684 | 5170 | vanduo šaltas - V1 2
1389365 | 2 a | 921.504 | 7735.4 | vanduo šaltas - V1 2
1389441 | 2 a | 4195.4 | 3519 | vanduo šaltas - V1 2
1389449 | 2 a | 1925 | 7740.7 | vanduo šaltas - V1 2
1389463 | 2 a | 95 | 4842.3 | vanduo šaltas - V1 2
1389499 | 2 a | 2858.4 | 4870 | vanduo šaltas - V1 2
1389617 | 2 a | 226.5 | 7740.7 | vanduo šaltas - V1 2
1389632 | 2 a | 510.981 | 7735.4 | vanduo šaltas - V1 2
1389635 | 2 a | 375 | 7740.7 | vanduo šaltas - V1 2
1389649 | 2 a | 65 | 5142.3 | vanduo šaltas - V1 2
1389677 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1389825 | 2 a | 104 | 7740.7 | vanduo šaltas - V1 2
1389834 | 2 a | 290 | 7735.4 | vanduo šaltas - V1 2
1389837 | 2 a | 145 | 7740.7 | vanduo šaltas - V1 2
1389845 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1389885 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1389912 | 2 a | 1924 | 7740.7 | vanduo šaltas - V1 2
1389921 | 2 a | 625.498 | 7735.4 | vanduo šaltas - V1 2
1389924 | 2 a | 70 | 4842.3 | vanduo šaltas - V1 2
1389961 | 2 a | 2858.4 | 4870 | vanduo šaltas - V1 2
1389983 | 2 a | 654 | 7740.7 | vanduo šaltas - V1 2
1389992 | 2 a | 869.691 | 7735.4 | vanduo šaltas - V1 2
1389995 | 2 a | 106.759 | 5142.3 | vanduo šaltas - V1 2
1390037 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1390098 | 2 a | 780.759 | 7740.7 | vanduo šaltas - V1 2
1390107 | 2 a | 679.185 | 7735.4 | vanduo šaltas - V1 2
1390110 | 2 a | 1240 | 7740.7 | vanduo šaltas - V1 2
1390118 | 2 a | 160 | 7740.7 | vanduo šaltas - V1 2
1390128 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1390173 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1390210 | 2 a | 1152 | 7738.4 | vanduo šaltas - V1 2
1390219 | 2 a | 119.141 | 7735.4 | vanduo šaltas - V1 2
1390222 | 2 a | 2656 | 7738.4 | vanduo šaltas - V1 2
1390230 | 2 a | 201.409 | 7738.4 | vanduo šaltas - V1 2
1390240 | 2 a | 119 | 7740.7 | vanduo šaltas - V1 2
1390266 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1390296 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1390320 | 2 a | 2298 | 7740.7 | vanduo šaltas - V1 2
1390333 | 2 a | 713.182 | 7738.4 | vanduo šaltas - V1 2
1390336 | 2 a | 500 | 7740.7 | vanduo šaltas - V1 2
1390346 | 2 a | 280 | 7740.7 | vanduo šaltas - V1 2
1390354 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1390394 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1390424 | 2 a | 216.507 | 7740.7 | vanduo šaltas - V1 2
1390435 | 2 a | 329.364 | 7738.4 | vanduo šaltas - V1 2
1390438 | 2 a | 105 | 5142.3 | vanduo šaltas - V1 2
1390483 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1390505 | 2 a | 2618 | 7740.7 | vanduo šaltas - V1 2
1390518 | 2 a | 1026.22 | 7738.4 | vanduo šaltas - V1 2
1390521 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1390569 | 2 a | 2858.4 | 4870 | vanduo šaltas - V1 2
1390591 | 2 a | 1138 | 7740.7 | vanduo šaltas - V1 2
1390602 | 2 a | 3865.83 | 7738.4 | vanduo šaltas - V1 2
1390605 | 2 a | 120 | 7740.7 | vanduo šaltas - V1 2
1390615 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1390666 | 2 a | 2558.4 | 5170 | vanduo šaltas - V1 2
1390717 | 2 a | 145.652 | 7721.16 | vanduo šaltas - V1 2
1390788 | 2 a | 3822.16 | 3831 | vanduo šaltas - V1 2
1390812 | 2 a | 125.581 | 7679.46 | vanduo šaltas - V1 2
1390820 | 2 a | 740 | 7679.46 | vanduo šaltas - V1 2
1390830 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1390880 | 2 a | 2497.16 | 5170 | vanduo šaltas - V1 2
1390901 | 2 a | 680 | 7679.46 | vanduo šaltas - V1 2
1390910 | 2 a | 2634.42 | 7679.46 | vanduo šaltas - V1 2
1390913 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1390955 | 2 a | 2497.16 | 5170 | vanduo šaltas - V1 2
1390979 | 2 a | 873.594 | 7887.82 | vanduo šaltas - V1 2
1390991 | 2 a | 413.263 | 7890.82 | vanduo šaltas - V1 2
1391007 | 2 a | 3790.5 | 7893.12 | vanduo šaltas - V1 2
1391097 | 2 a | 1740 | 7893.12 | vanduo šaltas - V1 2
1391105 | 2 a | 180 | 7893.12 | vanduo šaltas - V1 2
1391115 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1391167 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1391202 | 2 a | 638 | 7893.12 | vanduo šaltas - V1 2
1391213 | 2 a | 307.041 | 7890.82 | vanduo šaltas - V1 2
1391216 | 2 a | 320 | 7893.12 | vanduo šaltas - V1 2
1391226 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1391256 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1391278 | 2 a | 323.018 | 7893.12 | vanduo šaltas - V1 2
1391291 | 2 a | 75.4029 | 7890.82 | vanduo šaltas - V1 2
1391294 | 2 a | 260 | 7893.12 | vanduo šaltas - V1 2
1391304 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1391354 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1391376 | 2 a | 195 | 7893.12 | vanduo šaltas - V1 2
1391385 | 2 a | 1334.98 | 7893.12 | vanduo šaltas - V1 2
1391388 | 2 a | 65 | 5142.3 | vanduo šaltas - V1 2
1391422 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1391444 | 2 a | 638 | 7893.12 | vanduo šaltas - V1 2
1391458 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1391489 | 2 a | 3010.82 | 4870 | vanduo šaltas - V1 2
1391511 | 2 a | 304.547 | 7893.12 | vanduo šaltas - V1 2
1391526 | 2 a | 978.494 | 7890.82 | vanduo šaltas - V1 2
1391577 | 2 a | 242.064 | 7890.82 | vanduo šaltas - V1 2
1391581 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1391594 | 2 a | 3010.82 | 4870 | vanduo šaltas - V1 2
1391618 | 2 a | 65 | 7893.12 | vanduo šaltas - V1 2
1391629 | 2 a | 783.631 | 7893.12 | vanduo šaltas - V1 2
1391632 | 2 a | 105 | 7893.12 | vanduo šaltas - V1 2
1391640 | 2 a | 75 | 4842.3 | vanduo šaltas - V1 2
1391670 | 2 a | 3010.82 | 4870 | vanduo šaltas - V1 2
1391692 | 2 a | 565.408 | 7893.12 | vanduo šaltas - V1 2
1391711 | 2 a | 652.236 | 7890.82 | vanduo šaltas - V1 2
1391714 | 2 a | 340 | 7893.12 | vanduo šaltas - V1 2
1391724 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1391764 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1391805 | 2 a | 280 | 7893.12 | vanduo šaltas - V1 2
1391814 | 2 a | 542.592 | 7893.12 | vanduo šaltas - V1 2
1391817 | 2 a | 70 | 5142.3 | vanduo šaltas - V1 2
1391857 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1391911 | 2 a | 593.12 | 7893.12 | vanduo šaltas - V1 2
1391924 | 2 a | 518.667 | 7887.82 | vanduo šaltas - V1 2
1391927 | 2 a | 328.963 | 4842.3 | vanduo šaltas - V1 2
1391964 | 2 a | 3010.82 | 4870 | vanduo šaltas - V1 2
1391984 | 2 a | 180 | 7893.12 | vanduo šaltas - V1 2
1391993 | 2 a | 60.8804 | 7893.12 | vanduo šaltas - V1 2
1391996 | 2 a | 60 | 4842.3 | vanduo šaltas - V1 2
1392062 | 2 a | 3010.82 | 4870 | vanduo šaltas - V1 2
1392089 | 2 a | 1934 | 7893.12 | vanduo šaltas - V1 2
1392102 | 2 a | 4710.74 | 7887.82 | vanduo šaltas - V1 2
1392105 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1392144 | 2 a | 2710.82 | 5170 | vanduo šaltas - V1 2
1392239 | 2 a | 82.2796 | 7700.87 | vanduo šaltas - V1 2
1392287 | 2 a | 12 | 7656.87 | vanduo šaltas - V1 2
1392321 | 2 a | 3801.87 | 3831 | vanduo šaltas - V1 2
1392347 | 2 a | 116 | 7656.87 | vanduo šaltas - V1 2
1392357 | 2 a | 115.415 | 7656.87 | vanduo šaltas - V1 2
1392587 | 2 a | 3942 | 7807.15 | vanduo šaltas - V1 2
1392595 | 2 a | 5020.22 | 7807.15 | vanduo šaltas - V1 2
1392605 | 2 a | 396 | 7807.15 | vanduo šaltas - V1 2
1392613 | 2 a | 144 | 7809.45 | vanduo šaltas - V1 2
1392660 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1392711 | 2 a | 2627.15 | 5170 | vanduo šaltas - V1 2
1392736 | 2 a | 3530.83 | 7656.87 | vanduo šaltas - V1 2
1392747 | 2 a | 156.616 | 7656.87 | vanduo šaltas - V1 2
1392750 | 2 a | 579 | 7659.17 | vanduo šaltas - V1 2
1392765 | 2 a | 140 | 5142.3 | vanduo šaltas - V1 2
1392807 | 2 a | 2476.87 | 5170 | vanduo šaltas - V1 2
1392831 | 2 a | 109 | 7659.17 | vanduo šaltas - V1 2
1392849 | 2 a | 210 | 5142.3 | vanduo šaltas - V1 2
1392872 | 2 a | 2476.87 | 5170 | vanduo šaltas - V1 2
1392953 | 2 a | 173 | 7659.17 | vanduo šaltas - V1 2
1392962 | 2 a | 285.057 | 7656.87 | vanduo šaltas - V1 2
1392965 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1393016 | 2 a | 2476.87 | 5170 | vanduo šaltas - V1 2
1393038 | 2 a | 286 | 7656.87 | vanduo šaltas - V1 2
1393049 | 2 a | 4540.17 | 7656.87 | vanduo šaltas - V1 2
1393052 | 2 a | 656 | 7656.87 | vanduo šaltas - V1 2
1393062 | 2 a | 286 | 7656.87 | vanduo šaltas - V1 2
1393106 | 2 a | 158 | 7659.17 | vanduo šaltas - V1 2
1393115 | 2 a | 2657.91 | 7656.87 | vanduo šaltas - V1 2
1393118 | 2 a | 10080 | 7659.17 | vanduo šaltas - V1 2
1393126 | 2 a | 69.5817 | 7659.17 | vanduo šaltas - V1 2
1393136 | 2 a | 225 | 7659.17 | vanduo šaltas - V1 2
1393147 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1393200 | 2 a | 2476.87 | 5170 | vanduo šaltas - V1 2
1393223 | 2 a | 140 | 7659.17 | vanduo šaltas - V1 2
1393234 | 2 a | 300.418 | 7659.17 | vanduo šaltas - V1 2
1393237 | 2 a | 85 | 5142.3 | vanduo šaltas - V1 2
1393268 | 2 a | 2476.87 | 5170 | vanduo šaltas - V1 2
1393299 | 2 a | 4159.05 | 8002.62 | vanduo šaltas - V1 2
1393345 | 2 a | 18 | 7803.41 | vanduo šaltas - V1 2
1393362 | 2 a | 3951.41 | 3831 | vanduo šaltas - V1 2
1393389 | 2 a | 528 | 7803.41 | vanduo šaltas - V1 2
1393904 | 2 a | 108.228 | 7803.41 | vanduo šaltas - V1 2
1393922 | 2 a | 368.5 | 7806.41 | vanduo šaltas - V1 2
1394056 | 2 a | 876 | 7806.41 | vanduo šaltas - V1 2
1394070 | 2 a | 4736 | 7806.41 | vanduo šaltas - V1 2
1394084 | 2 a | 1444 | 7808.71 | vanduo šaltas - V1 2
1394110 | 2 a | 80 | 7808.71 | vanduo šaltas - V1 2
1394118 | 2 a | 150 | 5142.3 | vanduo šaltas - V1 2
1394169 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1394213 | 2 a | 3994 | 7808.71 | vanduo šaltas - V1 2
1394222 | 2 a | 304.464 | 7803.41 | vanduo šaltas - V1 2
1394225 | 2 a | 440 | 7808.71 | vanduo šaltas - V1 2
1394233 | 2 a | 1120 | 7808.71 | vanduo šaltas - V1 2
1394243 | 2 a | 740 | 7808.71 | vanduo šaltas - V1 2
1394251 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1394287 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1394309 | 2 a | 444 | 7808.71 | vanduo šaltas - V1 2
1394318 | 2 a | 416.539 | 7803.41 | vanduo šaltas - V1 2
1394321 | 2 a | 70 | 5342.3 | vanduo šaltas - V1 2
1394352 | 2 a | 2426.41 | 5370 | vanduo šaltas - V1 2
1394374 | 2 a | 194 | 7808.71 | vanduo šaltas - V1 2
1394383 | 2 a | 977.294 | 7803.41 | vanduo šaltas - V1 2
1394386 | 2 a | 180 | 7808.71 | vanduo šaltas - V1 2
1394394 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1394428 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1394450 | 2 a | 444 | 7808.71 | vanduo šaltas - V1 2
1394459 | 2 a | 423.763 | 7803.41 | vanduo šaltas - V1 2
1394462 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1394502 | 2 a | 2926.41 | 4870 | vanduo šaltas - V1 2
1394524 | 2 a | 2454 | 7808.71 | vanduo šaltas - V1 2
1394533 | 2 a | 728.293 | 7803.41 | vanduo šaltas - V1 2
1394536 | 2 a | 380 | 7808.71 | vanduo šaltas - V1 2
1394544 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1394573 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1394597 | 2 a | 654 | 7808.71 | vanduo šaltas - V1 2
1394606 | 2 a | 1096.48 | 7803.41 | vanduo šaltas - V1 2
1394609 | 2 a | 120 | 5342.3 | vanduo šaltas - V1 2
1394644 | 2 a | 2426.41 | 5370 | vanduo šaltas - V1 2
1394666 | 2 a | 2174 | 7808.71 | vanduo šaltas - V1 2
1394675 | 2 a | 165.2 | 7803.41 | vanduo šaltas - V1 2
1394678 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1394713 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1394771 | 2 a | 434 | 7808.71 | vanduo šaltas - V1 2
1394780 | 2 a | 216.072 | 7803.41 | vanduo šaltas - V1 2
1394783 | 2 a | 80 | 8042.3 | vanduo šaltas - V1 2
1394816 | 2 a | 193.592 | 7836.41 | vanduo šaltas - V1 2
1394861 | 2 a | 1694 | 7808.71 | vanduo šaltas - V1 2
1394870 | 2 a | 6237.85 | 7803.41 | vanduo šaltas - V1 2
1394873 | 2 a | 220 | 7808.71 | vanduo šaltas - V1 2
1394881 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1394916 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1394938 | 2 a | 1134 | 7808.71 | vanduo šaltas - V1 2
1394947 | 2 a | 1830.32 | 7803.41 | vanduo šaltas - V1 2
1394950 | 2 a | 200 | 7808.71 | vanduo šaltas - V1 2
1394958 | 2 a | 229.944 | 5142.3 | vanduo šaltas - V1 2
1395027 | 2 a | 2626.41 | 5170 | vanduo šaltas - V1 2
1395063 | 2 a | 131.213 | 7850.41 | vanduo šaltas - V1 2
1395071 | 2 a | 1756 | 8005.62 | vanduo šaltas - V1 2
1395087 | 2 a | 86.7302 | 8005.62 | vanduo šaltas - V1 2
1395095 | 2 a | 99 | 8007.92 | vanduo šaltas - V1 2
1395109 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1395162 | 2 a | 2825.62 | 5170 | vanduo šaltas - V1 2
1395352 | 2 a | 68 | 8007.92 | vanduo šaltas - V1 2
1395361 | 2 a | 4854.27 | 8005.62 | vanduo šaltas - V1 2
1395364 | 2 a | 220 | 8007.92 | vanduo šaltas - V1 2
1395372 | 2 a | 145 | 8007.92 | vanduo šaltas - V1 2
1395382 | 2 a | 50 | 5142.3 | vanduo šaltas - V1 2
1395427 | 2 a | 2825.62 | 5170 | vanduo šaltas - V1 2
1395516 | 2 a | 4014 | 8007.92 | vanduo šaltas - V1 2
1395525 | 2 a | 3883.95 | 8002.62 | vanduo šaltas - V1 2
1395528 | 2 a | 93.2279 | 8007.92 | vanduo šaltas - V1 2
1395536 | 2 a | 200 | 8007.92 | vanduo šaltas - V1 2
1395546 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1395586 | 2 a | 2825.62 | 5170 | vanduo šaltas - V1 2
1395607 | 2 a | 240 | 8007.92 | vanduo šaltas - V1 2
1395616 | 2 a | 406.772 | 8007.92 | vanduo šaltas - V1 2
1395619 | 2 a | 71.8163 | 5142.3 | vanduo šaltas - V1 2
1395651 | 2 a | 2825.62 | 5170 | vanduo šaltas - V1 2
1395693 | 1 a +-152.84 | 453.899 | 8017.35 | vanduo šaltas - V1 2
1395708 | 1 a +-152.84 | 180.573 | 7815.78 | vanduo šaltas - V1 2
1395728 | 2 a | 212.036 | 8017.35 | vanduo šaltas - V1 2
1395738 | 2 a | 3270.5 | 8022.65 | vanduo šaltas - V1 2
1395776 | 2 a | 980 | 8022.65 | vanduo šaltas - V1 2
1395784 | 2 a | 240 | 8022.65 | vanduo šaltas - V1 2
1395794 | 2 a | 140 | 5142.3 | vanduo šaltas - V1 2
1395827 | 2 a | 2840.35 | 5170 | vanduo šaltas - V1 2
1395848 | 2 a | 7074 | 8022.65 | vanduo šaltas - V1 2
1395863 | 2 a | 2291.58 | 8017.35 | vanduo šaltas - V1 2
1395866 | 2 a | 400 | 8022.65 | vanduo šaltas - V1 2
1395876 | 2 a | 600 | 8022.65 | vanduo šaltas - V1 2
1395886 | 2 a | 240 | 8022.65 | vanduo šaltas - V1 2
1395896 | 2 a | 140 | 5142.3 | vanduo šaltas - V1 2
1395950 | 2 a | 2840.35 | 5170 | vanduo šaltas - V1 2
1396062 | 2 a | 460 | 8022.65 | vanduo šaltas - V1 2
1396075 | 2 a | 680 | 8022.65 | vanduo šaltas - V1 2
1396078 | 2 a | 185 | 8022.65 | vanduo šaltas - V1 2
1396088 | 2 a | 59.6238 | 5142.3 | vanduo šaltas - V1 2
1396134 | 2 a | 2840.35 | 5170 | vanduo šaltas - V1 2
1396199 | 2 a | 2325.42 | 3750 | vanduo šaltas - V1 2
1396204 | 2 a | 5 | 3772.3 | vanduo šaltas - V1 2
1396252 | 2 a | 270 | 5142.3 | vanduo šaltas - V1 2
1396285 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1396372 | 2 a | 280 | 3772.3 | vanduo šaltas - V1 2
1396386 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1396439 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1396460 | 2 a | 1774 | 8022.65 | vanduo šaltas - V1 2
1396473 | 2 a | 2180.88 | 8017.35 | vanduo šaltas - V1 2
1396476 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1396513 | 2 a | 2840.35 | 5170 | vanduo šaltas - V1 2
1396535 | 2 a | 3694 | 8022.65 | vanduo šaltas - V1 2
1396544 | 1 a +-152.84 | 204.101 | 8017.35 | vanduo šaltas - V1 2
1396547 | 2 a | 920 | 8022.65 | vanduo šaltas - V1 2
1396555 | 2 a | 140 | 8022.65 | vanduo šaltas - V1 2
1396565 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1396599 | 2 a | 2840.35 | 5170 | vanduo šaltas - V1 2
1396664 | 1 a +-152.84 | 22 | 7771.78 | vanduo šaltas - V1 2
1396675 | 1 a +-152.84 | 3916.78 | 3831 | vanduo šaltas - V1 2
1396697 | 2 a | 956 | 7771.78 | vanduo šaltas - V1 2
1396707 | 2 a | 1370.6 | 7771.78 | vanduo šaltas - V1 2
1396725 | 2 a | 1179 | 7774.08 | vanduo šaltas - V1 2
1396780 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1396813 | 2 a | 2891.78 | 4870 | vanduo šaltas - V1 2
1397004 | 2 a | 1358 | 7774.08 | vanduo šaltas - V1 2
1397019 | 2 a | 1068.94 | 7771.78 | vanduo šaltas - V1 2
1397022 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1397070 | 2 a | 2591.78 | 5170 | vanduo šaltas - V1 2
1397096 | 2 a | 598 | 7774.08 | vanduo šaltas - V1 2
1397109 | 2 a | 12596.5 | 7771.78 | vanduo šaltas - V1 2
1397112 | 2 a | 70 | 7774.08 | vanduo šaltas - V1 2
1397122 | 2 a | 81.5427 | 4942.3 | vanduo šaltas - V1 2
1397162 | 2 a | 2791.78 | 4970 | vanduo šaltas - V1 2
1397267 | 2 a | 418 | 7720.64 | vanduo šaltas - V1 2
1397278 | 2 a | 3880.64 | 3819 | vanduo šaltas - V1 2
1397306 | 2 a | 1608.98 | 7720.64 | vanduo šaltas - V1 2
1397419 | 2 a | 5111.74 | 7723.64 | vanduo šaltas - V1 2
1397441 | 2 a | 199 | 7725.94 | vanduo šaltas - V1 2
1397461 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1397507 | 2 a | 2543.64 | 5170 | vanduo šaltas - V1 2
1397531 | 2 a | 438 | 7725.94 | vanduo šaltas - V1 2
1397542 | 2 a | 944.83 | 7723.64 | vanduo šaltas - V1 2
1397545 | 2 a | 160 | 7725.94 | vanduo šaltas - V1 2
1397553 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1397581 | 2 a | 2543.64 | 5170 | vanduo šaltas - V1 2
1397603 | 2 a | 1378 | 7725.94 | vanduo šaltas - V1 2
1397612 | 2 a | 155.387 | 7723.64 | vanduo šaltas - V1 2
1397615 | 2 a | 280 | 7725.94 | vanduo šaltas - V1 2
1397625 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1397664 | 2 a | 2843.64 | 4870 | vanduo šaltas - V1 2
1397700 | 2 a | 558 | 7725.94 | vanduo šaltas - V1 2
1397709 | 2 a | 832.378 | 7723.64 | vanduo šaltas - V1 2
1397712 | 2 a | 260 | 7725.94 | vanduo šaltas - V1 2
1397720 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1397755 | 2 a | 2543.64 | 5170 | vanduo šaltas - V1 2
1397785 | 2 a | 1066.94 | 7725.94 | vanduo šaltas - V1 2
1397794 | 2 a | 1321.42 | 7723.64 | vanduo šaltas - V1 2
1397797 | 2 a | 260 | 7725.94 | vanduo šaltas - V1 2
1397805 | 2 a | 105 | 5342.3 | vanduo šaltas - V1 2
1397836 | 2 a | 2343.64 | 5370 | vanduo šaltas - V1 2
1397860 | 2 a | 230 | 7725.94 | vanduo šaltas - V1 2
1397873 | 2 a | 386.064 | 7725.94 | vanduo šaltas - V1 2
1397876 | 2 a | 75 | 4842.3 | vanduo šaltas - V1 2
1397905 | 2 a | 2843.64 | 4870 | vanduo šaltas - V1 2
1397927 | 2 a | 213 | 7725.94 | vanduo šaltas - V1 2
1397936 | 2 a | 170.238 | 7723.64 | vanduo šaltas - V1 2
1397939 | 2 a | 90 | 5142.3 | vanduo šaltas - V1 2
1397989 | 2 a | 2543.64 | 5170 | vanduo šaltas - V1 2
1398011 | 2 a | 4 | 7725.94 | vanduo šaltas - V1 2
1398022 | 2 a | 184.021 | 7720.64 | vanduo šaltas - V1 2
1398025 | 2 a | 430 | 7725.94 | vanduo šaltas - V1 2
1398035 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1398064 | 2 a | 2543.64 | 5170 | vanduo šaltas - V1 2
1398236 | 2 a | 192 | 7799.33 | vanduo šaltas - V1 2
1398245 | 2 a | 1248.6 | 7796.33 | vanduo šaltas - V1 2
1398248 | 2 a | 4816 | 7799.33 | vanduo šaltas - V1 2
1398260 | 2 a | 4016 | 7799.33 | vanduo šaltas - V1 2
1398268 | 2 a | 5596 | 7799.33 | vanduo šaltas - V1 2
1398288 | 2 a | 779.639 | 7801.63 | vanduo šaltas - V1 2
1398315 | 2 a | 600 | 7801.63 | vanduo šaltas - V1 2
1398325 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1398358 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1398379 | 2 a | 580 | 7801.63 | vanduo šaltas - V1 2
1398388 | 2 a | 824.837 | 7801.63 | vanduo šaltas - V1 2
1398391 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1398423 | 2 a | 2919.33 | 4870 | vanduo šaltas - V1 2
1398445 | 2 a | 580 | 7801.63 | vanduo šaltas - V1 2
1398454 | 2 a | 154.524 | 7801.63 | vanduo šaltas - V1 2
1398457 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1398497 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1398558 | 1 a +-152.84 | 565.037 | 3767 | vanduo šaltas - V1 2
1398571 | 1 a +-152.84 | 1300.44 | 3750 | vanduo šaltas - V1 2
1398647 | 1 a +-152.84 | 1440 | 3772.3 | vanduo šaltas - V1 2
1398663 | 1 a +-152.84 | 195 | 3772.3 | vanduo šaltas - V1 2
1398673 | 1 a +-152.84 | 85 | 642.3 | vanduo šaltas - V1 2
1398699 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1398721 | 1 a +-152.84 | 1639 | 3772.3 | vanduo šaltas - V1 2
1398732 | 1 a +-152.84 | 649.905 | 3767 | vanduo šaltas - V1 2
1398735 | 1 a +-152.84 | 100 | 642.3 | vanduo šaltas - V1 2
1398770 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1398841 | 1 a +-152.84 | 1654 | 3772.3 | vanduo šaltas - V1 2
1398854 | 1 a +-152.84 | 317.453 | 3767 | vanduo šaltas - V1 2
1398857 | 1 a +-152.84 | 115 | 642.3 | vanduo šaltas - V1 2
1398887 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1398926 | 1 a +-152.84 | 1734 | 3772.3 | vanduo šaltas - V1 2
1398939 | 1 a +-152.84 | 3894.14 | 3767 | vanduo šaltas - V1 2
1398942 | 1 a +-152.84 | 100 | 642.3 | vanduo šaltas - V1 2
1398982 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1399071 | 1 a +-152.84 | 1409 | 3772.3 | vanduo šaltas - V1 2
1399088 | 1 a +-152.84 | 495.699 | 3767 | vanduo šaltas - V1 2
1399091 | 1 a +-152.84 | 355 | 3772.3 | vanduo šaltas - V1 2
1399101 | 1 a +-152.84 | 140 | 642.3 | vanduo šaltas - V1 2
1399135 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1399198 | 1 a +-152.84 | 1639.23 | 3770 | vanduo šaltas - V1 2
1399211 | 1 a +-152.84 | 1623.71 | 3767 | vanduo šaltas - V1 2
1399214 | 1 a +-152.84 | 199 | 3772.3 | vanduo šaltas - V1 2
1399236 | 1 a +-152.84 | 140 | 342.299 | vanduo šaltas - V1 2
1399308 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1399330 | 1 a +-152.84 | 258 | 3772.3 | vanduo šaltas - V1 2
1399343 | 1 a +-152.84 | 821.143 | 3770 | vanduo šaltas - V1 2
1399346 | 1 a +-152.84 | 141.985 | 342.299 | vanduo šaltas - V1 2
1399394 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1399416 | 1 a +-152.84 | 258 | 3772.3 | vanduo šaltas - V1 2
1399427 | 1 a +-152.84 | 727.617 | 3770 | vanduo šaltas - V1 2
1399430 | 1 a +-152.84 | 119 | 342.3 | vanduo šaltas - V1 2
1399469 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1399490 | 1 a +-152.84 | 278 | 3772.3 | vanduo šaltas - V1 2
1399501 | 1 a +-152.84 | 204.011 | 3770 | vanduo šaltas - V1 2
1399504 | 1 a +-152.84 | 140 | 342.299 | vanduo šaltas - V1 2
1399537 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1399559 | 1 a +-152.84 | 574 | 3772.3 | vanduo šaltas - V1 2
1399568 | 1 a +-152.84 | 268.442 | 3767 | vanduo šaltas - V1 2
1399571 | 1 a +-152.84 | 130.442 | 442.299 | vanduo šaltas - V1 2
1399606 | 1 a +-152.84 | 3290 | 470 | vanduo šaltas - V1 2
1399626 | 1 a +-152.84 | 2469 | 3772.3 | vanduo šaltas - V1 2
1399641 | 1 a +-152.84 | 98.0833 | 3767 | vanduo šaltas - V1 2
1399644 | 1 a +-152.84 | 120 | 642.3 | vanduo šaltas - V1 2
1399683 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400105 | 1 a +-152.84 | 754.451 | 3772.3 | vanduo šaltas - V1 2
1400118 | 1 a +-152.84 | 275.531 | 3767 | vanduo šaltas - V1 2
1400121 | 1 a +-152.84 | 410 | 3772.3 | vanduo šaltas - V1 2
1400131 | 1 a +-152.84 | 70 | 642.3 | vanduo šaltas - V1 2
1400208 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400235 | 1 a +-152.84 | 400 | 3772.3 | vanduo šaltas - V1 2
1400244 | 1 a +-152.84 | 279.549 | 3772.3 | vanduo šaltas - V1 2
1400247 | 1 a +-152.84 | 60 | 642.3 | vanduo šaltas - V1 2
1400306 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400416 | 1 a +-152.84 | 119.027 | 3770 | vanduo šaltas - V1 2
1400456 | 1 a +-152.84 | 2964.58 | 3750 | vanduo šaltas - V1 2
1400461 | 1 a +-152.84 | 79 | 3772.3 | vanduo šaltas - V1 2
1400496 | 1 a +-152.84 | 200 | 642.3 | vanduo šaltas - V1 2
1400532 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400567 | 1 a +-152.84 | 168 | 3772.3 | vanduo šaltas - V1 2
1400582 | 1 a +-152.84 | 85.5715 | 3770 | vanduo šaltas - V1 2
1400585 | 1 a +-152.84 | 90 | 642.3 | vanduo šaltas - V1 2
1400629 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400653 | 1 a +-152.84 | 5078 | 3772.3 | vanduo šaltas - V1 2
1400672 | 1 a +-152.84 | 3673.4 | 3770 | vanduo šaltas - V1 2
1400675 | 1 a +-152.84 | 2620 | 3772.3 | vanduo šaltas - V1 2
1400685 | 1 a +-152.84 | 752.286 | 3772.3 | vanduo šaltas - V1 2
1400695 | 1 a +-152.84 | 500 | 3772.3 | vanduo šaltas - V1 2
1400708 | 1 a +-152.84 | 140 | 642.3 | vanduo šaltas - V1 2
1400754 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400781 | 1 a +-152.84 | 520 | 3772.3 | vanduo šaltas - V1 2
1400794 | 1 a +-152.84 | 1287.71 | 3772.3 | vanduo šaltas - V1 2
1400797 | 1 a +-152.84 | 140 | 642.299 | vanduo šaltas - V1 2
1400842 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1400864 | 1 a +-152.84 | 4142 | 3770 | vanduo šaltas - V1 2
1400914 | 2 a | 2766.68 | 3759.5 | vanduo šaltas - V1 2
1400929 | 1 a +-152.84 | 437.033 | 3772.3 | vanduo šaltas - V1 2
1400952 | 1 a +-152.84 | 120 | 642.299 | vanduo šaltas - V1 2
1400995 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1401025 | 1 a +-152.84 | 456.033 | 3772.3 | vanduo šaltas - V1 2
1401036 | 1 a +-152.84 | 811.079 | 3770 | vanduo šaltas - V1 2
1401087 | 1 a +-152.84 | 136.048 | 3770 | vanduo šaltas - V1 2
1401091 | 1 a +-152.84 | 100 | 642.3 | vanduo šaltas - V1 2
1401102 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1401137 | 1 a +-152.84 | 518 | 3772.3 | vanduo šaltas - V1 2
1401148 | 1 a +-152.84 | 551.655 | 3770 | vanduo šaltas - V1 2
1401151 | 1 a +-152.84 | 51.4686 | 642.3 | vanduo šaltas - V1 2
1401201 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1401223 | 1 a +-152.84 | 878 | 3772.3 | vanduo šaltas - V1 2
1401234 | 1 a +-152.84 | 1010.37 | 3770 | vanduo šaltas - V1 2
1401249 | 1 a +-152.84 | 220 | 3772.3 | vanduo šaltas - V1 2
1401290 | 1 a +-152.84 | 305 | 3772.3 | vanduo šaltas - V1 2
1401298 | 1 a +-152.84 | 60 | 642.3 | vanduo šaltas - V1 2
1401343 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1401415 | 1 a +-152.84 | 380 | 3772.3 | vanduo šaltas - V1 2
1401426 | 2 a | 162.576 | 3772.3 | vanduo šaltas - V1 2
1401429 | 1 a +-152.84 | 80 | 3772.3 | vanduo šaltas - V1 2
1401439 | 1 a +-152.84 | 360 | 3772.3 | vanduo šaltas - V1 2
1401453 | 1 a +-152.84 | 2960 | 3772.3 | vanduo šaltas - V1 2
1401463 | 1 a +-152.84 | 11260 | 3772.3 | vanduo šaltas - V1 2
1401471 | 1 a +-152.84 | 2720 | 3772.3 | vanduo šaltas - V1 2
1401481 | 1 a +-152.84 | 140 | 3772.3 | vanduo šaltas - V1 2
1401489 | 1 a +-152.84 | 85 | 642.299 | vanduo šaltas - V1 2
1401540 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1401712 | 1 a +-152.84 | 6939.76 | 3750 | vanduo šaltas - V1 2
1401724 | 1 a +-152.84 | 198 | 3770 | vanduo šaltas - V1 2
1401735 | 2 a | 144.288 | 3750 | vanduo šaltas - V1 2
1401992 | 1 a +-152.84 | 236 | 3522 | vanduo šaltas - V1 2
1402022 | 1 a +-152.84 | 835.046 | 3490 | vanduo šaltas - V1 2
1402044 | 1 a +-152.84 | 599 | 3492.3 | vanduo šaltas - V1 2
1402061 | 1 a +-152.84 | 180 | 642.3 | vanduo šaltas - V1 2
1402112 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402143 | 1 a +-152.84 | 618 | 3492.3 | vanduo šaltas - V1 2
1402152 | 1 a +-152.84 | 872.531 | 3490 | vanduo šaltas - V1 2
1402155 | 1 a +-152.84 | 180 | 642.3 | vanduo šaltas - V1 2
1402199 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402221 | 1 a +-152.84 | 618 | 3492.3 | vanduo šaltas - V1 2
1402230 | 1 a +-152.84 | 489.058 | 3490 | vanduo šaltas - V1 2
1402233 | 1 a +-152.84 | 160 | 642.299 | vanduo šaltas - V1 2
1402271 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402296 | 1 a +-152.84 | 238 | 3492.3 | vanduo šaltas - V1 2
1402305 | 1 a +-152.84 | 2631.59 | 3490 | vanduo šaltas - V1 2
1402308 | 1 a +-152.84 | 136.977 | 642.3 | vanduo šaltas - V1 2
1402339 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402359 | 1 a +-152.84 | 378 | 3492.3 | vanduo šaltas - V1 2
1402368 | 1 a +-152.84 | 107.776 | 3490 | vanduo šaltas - V1 2
1402371 | 1 a +-152.84 | 140 | 3492.3 | vanduo šaltas - V1 2
1402379 | 1 a +-152.84 | 140 | 642.3 | vanduo šaltas - V1 2
1402417 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402452 | 1 a +-152.84 | 798 | 3770 | vanduo šaltas - V1 2
1402471 | 2 a | 270.84 | 3750 | vanduo šaltas - V1 2
1402513 | 1 a +-152.84 | 236 | 3522 | vanduo šaltas - V1 2
1402523 | 1 a +-152.84 | 672.756 | 3490 | vanduo šaltas - V1 2
1402565 | 1 a +-152.84 | 399 | 3492.3 | vanduo šaltas - V1 2
1402638 | 1 a +-152.84 | 160 | 642.3 | vanduo šaltas - V1 2
1402698 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402719 | 1 a +-152.84 | 438 | 3492.3 | vanduo šaltas - V1 2
1402728 | 1 a +-152.84 | 862.433 | 3490 | vanduo šaltas - V1 2
1402731 | 1 a +-152.84 | 160 | 642.3 | vanduo šaltas - V1 2
1402767 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402804 | 1 a +-152.84 | 398 | 3492.3 | vanduo šaltas - V1 2
1402813 | 1 a +-152.84 | 513.841 | 3490 | vanduo šaltas - V1 2
1402816 | 1 a +-152.84 | 140 | 642.3 | vanduo šaltas - V1 2
1402859 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1402881 | 1 a +-152.84 | 876.757 | 3490 | vanduo šaltas - V1 2
1402892 | 1 a +-152.84 | 60.969 | 3490 | vanduo šaltas - V1 2
1402895 | 1 a +-152.84 | 399 | 3492.3 | vanduo šaltas - V1 2
1402916 | 1 a +-152.84 | 200 | 342.299 | vanduo šaltas - V1 2
1402969 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1403004 | 1 a +-152.84 | 478 | 3492.3 | vanduo šaltas - V1 2
1403019 | 1 a +-152.84 | 788.921 | 3490 | vanduo šaltas - V1 2
1403022 | 1 a +-152.84 | 60 | 342.3 | vanduo šaltas - V1 2
1403069 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1403091 | 1 a +-152.84 | 478 | 3492.3 | vanduo šaltas - V1 2
1403102 | 1 a +-152.84 | 89.3225 | 3490 | vanduo šaltas - V1 2
1403105 | 1 a +-152.84 | 140 | 342.299 | vanduo šaltas - V1 2
1403141 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1403168 | 1 a +-152.84 | 94.4331 | 3770 | vanduo šaltas - V1 2
1403177 | 2 a | 241.45 | 3750 | vanduo šaltas - V1 2
1403182 | 1 a +-152.84 | 850.097 | 3770 | vanduo šaltas - V1 2
1403194 | 1 a +-152.84 | 179 | 3772.3 | vanduo šaltas - V1 2
1403221 | 1 a +-152.84 | 79.5 | 842.3 | vanduo šaltas - V1 2
1403252 | 1 a +-152.84 | 2890 | 870 | vanduo šaltas - V1 2
1403341 | 1 a +-152.84 | 183 | 3772.3 | vanduo šaltas - V1 2
1403352 | 1 a +-152.84 | 869.845 | 3770 | vanduo šaltas - V1 2
1403355 | 1 a +-152.84 | 81.5 | 842.299 | vanduo šaltas - V1 2
1403392 | 1 a +-152.84 | 2890 | 870 | vanduo šaltas - V1 2
1403416 | 1 a +-152.84 | 183 | 3772.3 | vanduo šaltas - V1 2
1403427 | 1 a +-152.84 | 258.352 | 3770 | vanduo šaltas - V1 2
1403430 | 1 a +-152.84 | 70 | 842.3 | vanduo šaltas - V1 2
1403466 | 1 a +-152.84 | 2890 | 870 | vanduo šaltas - V1 2
1403501 | 1 a +-152.84 | 38 | 3772.3 | vanduo šaltas - V1 2
1403512 | 1 a +-152.84 | 223.567 | 3770 | vanduo šaltas - V1 2
1403515 | 1 a +-152.84 | 60 | 3772.3 | vanduo šaltas - V1 2
1403525 | 1 a +-152.84 | 60 | 3772.3 | vanduo šaltas - V1 2
1403535 | 1 a +-152.84 | 120 | 642.3 | vanduo šaltas - V1 2
1403580 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1403606 | 1 a +-152.84 | 2358 | 3770 | vanduo šaltas - V1 2
1403627 | 2 a | 321.129 | 3750 | vanduo šaltas - V1 2
1403632 | 1 a +-152.84 | 341.776 | 3770 | vanduo šaltas - V1 2
1403644 | 1 a +-152.84 | 1919 | 3772.3 | vanduo šaltas - V1 2
1403656 | 1 a +-152.84 | 777.221 | 3492.3 | vanduo šaltas - V1 2
1403707 | 1 a +-152.84 | 240 | 3520 | vanduo šaltas - V1 2
1403717 | 1 a +-152.84 | 140 | 3492.3 | vanduo šaltas - V1 2
1403727 | 1 a +-152.84 | 80 | 442.3 | vanduo šaltas - V1 2
1403769 | 1 a +-152.84 | 3010 | 470 | vanduo šaltas - V1 2
1403803 | 1 a +-152.84 | 160 | 3492.3 | vanduo šaltas - V1 2
1403812 | 1 a +-152.84 | 122.779 | 3492.3 | vanduo šaltas - V1 2
1403815 | 1 a +-152.84 | 70 | 442.299 | vanduo šaltas - V1 2
1403846 | 1 a +-152.84 | 3010 | 470 | vanduo šaltas - V1 2
1403868 | 1 a +-152.84 | 213 | 3772.3 | vanduo šaltas - V1 2
1403877 | 1 a +-152.84 | 805.158 | 3770 | vanduo šaltas - V1 2
1403903 | 1 a +-152.84 | 65 | 342.299 | vanduo šaltas - V1 2
1403912 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1403957 | 1 a +-152.84 | 218 | 3772.3 | vanduo šaltas - V1 2
1403968 | 1 a +-152.84 | 829.687 | 3770 | vanduo šaltas - V1 2
1403971 | 1 a +-152.84 | 50 | 342.3 | vanduo šaltas - V1 2
1404004 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1404026 | 1 a +-152.84 | 203 | 3772.3 | vanduo šaltas - V1 2
1404037 | 1 a +-152.84 | 239.378 | 3770 | vanduo šaltas - V1 2
1404040 | 1 a +-152.84 | 65 | 342.3 | vanduo šaltas - V1 2
1404081 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1404150 | 1 a +-152.84 | 2558 | 3770 | vanduo šaltas - V1 2
1404167 | 2 a | 7623.02 | 3750 | vanduo šaltas - V1 2
1404172 | 1 a +-152.84 | 869.722 | 3770 | vanduo šaltas - V1 2
1404186 | 1 a +-152.84 | 199 | 3772.3 | vanduo šaltas - V1 2
1404198 | 1 a +-152.84 | 89.5 | 842.3 | vanduo šaltas - V1 2
1404230 | 1 a +-152.84 | 2890 | 870 | vanduo šaltas - V1 2
1404252 | 1 a +-152.84 | 218 | 3772.3 | vanduo šaltas - V1 2
1404261 | 1 a +-152.84 | 852.443 | 3770 | vanduo šaltas - V1 2
1404264 | 1 a +-152.84 | 60 | 842.3 | vanduo šaltas - V1 2
1404290 | 1 a +-152.84 | 2890 | 870 | vanduo šaltas - V1 2
1404323 | 1 a +-152.84 | 218 | 3772.3 | vanduo šaltas - V1 2
1404332 | 1 a +-152.84 | 253.835 | 3770 | vanduo šaltas - V1 2
1404335 | 1 a +-152.84 | 75 | 842.3 | vanduo šaltas - V1 2
1404373 | 1 a +-152.84 | 2890 | 870 | vanduo šaltas - V1 2
1404446 | 1 a +-152.84 | 140 | 3764 | vanduo šaltas - V1 2
1404474 | 1 a +-152.84 | 6112.99 | 3750 | vanduo šaltas - V1 2
1404477 | 1 a +-152.84 | 420.039 | 3487 | vanduo šaltas - V1 2
1404724 | 1 a +-152.84 | 222 | 3529 | vanduo šaltas - V1 2
1404734 | 1 a +-152.84 | 846.039 | 3490 | vanduo šaltas - V1 2
1404774 | 1 a +-152.84 | 619 | 3492.3 | vanduo šaltas - V1 2
1404786 | 1 a +-152.84 | 100.412 | 642.3 | vanduo šaltas - V1 2
1404825 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1404967 | 1 a +-152.84 | 628 | 3492.3 | vanduo šaltas - V1 2
1404976 | 1 a +-152.84 | 862.907 | 3490 | vanduo šaltas - V1 2
1404979 | 1 a +-152.84 | 85 | 642.299 | vanduo šaltas - V1 2
1405011 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1405305 | 1 a +-152.84 | 638 | 3492.3 | vanduo šaltas - V1 2
1405316 | 1 a +-152.84 | 269.554 | 3490 | vanduo šaltas - V1 2
1405319 | 1 a +-152.84 | 100 | 842.3 | vanduo šaltas - V1 2
1405355 | 1 a +-152.84 | 2610 | 870 | vanduo šaltas - V1 2
1405377 | 1 a +-152.84 | 629.507 | 3492.3 | vanduo šaltas - V1 2
1405398 | 1 a +-152.84 | 290.212 | 3487 | vanduo šaltas - V1 2
1405401 | 1 a +-152.84 | 220 | 3492.3 | vanduo šaltas - V1 2
1405411 | 1 a +-152.84 | 80 | 442.299 | vanduo šaltas - V1 2
1405455 | 1 a +-152.84 | 3010 | 470 | vanduo šaltas - V1 2
1405477 | 1 a +-152.84 | 220 | 3492.3 | vanduo šaltas - V1 2
1405486 | 1 a +-152.84 | 1944.49 | 3492.3 | vanduo šaltas - V1 2
1405489 | 1 a +-152.84 | 80 | 442.3 | vanduo šaltas - V1 2
1405518 | 1 a +-152.84 | 3010 | 470 | vanduo šaltas - V1 2
1405542 | 1 a +-152.84 | 334 | 3492.3 | vanduo šaltas - V1 2
1405551 | 1 a +-152.84 | 805.998 | 3487 | vanduo šaltas - V1 2
1405554 | 1 a +-152.84 | 100 | 342.3 | vanduo šaltas - V1 2
1405594 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1405654 | 1 a +-152.84 | 314 | 3492.3 | vanduo šaltas - V1 2
1405665 | 1 a +-152.84 | 621.007 | 3487 | vanduo šaltas - V1 2
1405668 | 1 a +-152.84 | 120 | 342.3 | vanduo šaltas - V1 2
1405738 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1405773 | 1 a +-152.84 | 314 | 3492.3 | vanduo šaltas - V1 2
1405784 | 1 a +-152.84 | 677.305 | 3487 | vanduo šaltas - V1 2
1405787 | 1 a +-152.84 | 120 | 342.3 | vanduo šaltas - V1 2
1405820 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1405842 | 1 a +-152.84 | 2791 | 3490 | vanduo šaltas - V1 2
1405869 | 1 a +-152.84 | 1051.67 | 3487 | vanduo šaltas - V1 2
1405872 | 1 a +-152.84 | 392.291 | 3490 | vanduo šaltas - V1 2
1405882 | 1 a +-152.84 | 259 | 3492.3 | vanduo šaltas - V1 2
1405901 | 1 a +-152.84 | 60 | 842.3 | vanduo šaltas - V1 2
1405948 | 1 a +-152.84 | 2610 | 870 | vanduo šaltas - V1 2
1405995 | 1 a +-152.84 | 100 | 3492.3 | vanduo šaltas - V1 2
1406007 | 1 a +-152.84 | 80 | 642.3 | vanduo šaltas - V1 2
1406050 | 1 a +-152.84 | 2810 | 669.997 | vanduo šaltas - V1 2
1406073 | 1 a +-152.84 | 2874 | 3492.3 | vanduo šaltas - V1 2
1406086 | 1 a +-152.84 | 949.199 | 3487 | vanduo šaltas - V1 2
1406089 | 1 a +-152.84 | 130 | 3492.3 | vanduo šaltas - V1 2
1406099 | 1 a +-152.84 | 200 | 3492.3 | vanduo šaltas - V1 2
1406107 | 1 a +-152.84 | 90 | 842.3 | vanduo šaltas - V1 2
1406137 | 1 a +-152.84 | 2610 | 870 | vanduo šaltas - V1 2
1406159 | 1 a +-152.84 | 2774 | 3492.3 | vanduo šaltas - V1 2
1406170 | 1 a +-152.84 | 782.806 | 3487 | vanduo šaltas - V1 2
1406204 | 1 a +-152.84 | 20 | 3492.3 | vanduo šaltas - V1 2
1406214 | 1 a +-152.84 | 305 | 3492.3 | vanduo šaltas - V1 2
1406222 | 1 a +-152.84 | 70 | 842.299 | vanduo šaltas - V1 2
1406264 | 1 a +-152.84 | 2610 | 870 | vanduo šaltas - V1 2
1406288 | 1 a +-152.84 | 2746.27 | 3490 | vanduo šaltas - V1 2
1406303 | 1 a +-152.84 | 1724.07 | 3484 | vanduo šaltas - V1 2
1406306 | 1 a +-152.84 | 715.099 | 3490 | vanduo šaltas - V1 2
1406326 | 1 a +-152.84 | 930.977 | 3490 | vanduo šaltas - V1 2
1406360 | 1 a +-152.84 | 619 | 3492.3 | vanduo šaltas - V1 2
1406386 | 1 a +-152.84 | 220 | 642.3 | vanduo šaltas - V1 2
1406422 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1406444 | 1 a +-152.84 | 658 | 3492.3 | vanduo šaltas - V1 2
1406453 | 1 a +-152.84 | 864.571 | 3490 | vanduo šaltas - V1 2
1406456 | 1 a +-152.84 | 180 | 642.3 | vanduo šaltas - V1 2
1406507 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1406535 | 1 a +-152.84 | 638 | 3492.3 | vanduo šaltas - V1 2
1406544 | 1 a +-152.84 | 778.932 | 3490 | vanduo šaltas - V1 2
1406547 | 1 a +-152.84 | 160 | 642.299 | vanduo šaltas - V1 2
1406587 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1406609 | 1 a +-152.84 | 58 | 3492.3 | vanduo šaltas - V1 2
1406618 | 1 a +-152.84 | 361.521 | 3490 | vanduo šaltas - V1 2
1406621 | 1 a +-152.84 | 180 | 3492.3 | vanduo šaltas - V1 2
1406635 | 1 a +-152.84 | 100 | 442.299 | vanduo šaltas - V1 2
1406678 | 1 a +-152.84 | 3010 | 470 | vanduo šaltas - V1 2
1406700 | 1 a +-152.84 | 198 | 3492.3 | vanduo šaltas - V1 2
1406711 | 1 a +-152.84 | 810.326 | 3490 | vanduo šaltas - V1 2
1406714 | 1 a +-152.84 | 140 | 342.299 | vanduo šaltas - V1 2
1406749 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1406771 | 1 a +-152.84 | 188 | 3492.3 | vanduo šaltas - V1 2
1406784 | 1 a +-152.84 | 230.575 | 3490 | vanduo šaltas - V1 2
1406787 | 1 a +-152.84 | 137.518 | 342.299 | vanduo šaltas - V1 5
1406825 | 1 a +-152.84 | 3110 | 370 | vanduo šaltas - V1 2
1406871 | 1 a +-152.84 | 882.627 | 3490 | vanduo šaltas - V1 2
1406886 | 1 a +-152.84 | 425.191 | 3484 | vanduo šaltas - V1 2
1406889 | 1 a +-152.84 | 756 | 3490 | vanduo šaltas - V1 2
1406899 | 1 a +-152.84 | 158 | 639.999 | vanduo šaltas - V1 2
1406930 | 1 a +-152.84 | 2806 | 672 | vanduo šaltas - V1 2
1406952 | 1 a +-152.84 | 758 | 3492.3 | vanduo šaltas - V1 2
1406961 | 1 a +-152.84 | 841.316 | 3490 | vanduo šaltas - V1 2
1406964 | 1 a +-152.84 | 160 | 642.3 | vanduo šaltas - V1 2
1407005 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1407027 | 1 a +-152.84 | 758 | 3492.3 | vanduo šaltas - V1 2
1407036 | 1 a +-152.84 | 774.469 | 3490 | vanduo šaltas - V1 2
1407039 | 1 a +-152.84 | 160 | 642.3 | vanduo šaltas - V1 2
1407085 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1407145 | 1 a +-152.84 | 398 | 3492.3 | vanduo šaltas - V1 2
1407154 | 1 a +-152.84 | 88.3677 | 3490 | vanduo šaltas - V1 2
1407157 | 1 a +-152.84 | 80 | 3492.3 | vanduo šaltas - V1 2
1407165 | 1 a +-152.84 | 157.297 | 642.3 | vanduo šaltas - V1 2
1407215 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1407237 | 1 a +-152.84 | 278 | 3492.3 | vanduo šaltas - V1 2
1407248 | 1 a +-152.84 | 381.221 | 3490 | vanduo šaltas - V1 2
1407251 | 1 a +-152.84 | 200 | 3492.3 | vanduo šaltas - V1 2
1407259 | 1 a +-152.84 | 60 | 642.3 | vanduo šaltas - V1 2
1407286 | 1 a +-152.84 | 2810 | 670 | vanduo šaltas - V1 2
1407326 | 1 a +-152.84 | 2620 | 3472.3 | vanduo šaltas - V1 2
1407335 | 0 a | 3729.14 | 3450 | vanduo šaltas - V1 2
1407340 | 1 a +-152.84 | 255.397 | 3472.3 | vanduo šaltas - V1 2
1407348 | 1 a +-152.84 | 5520 | 3472.3 | vanduo šaltas - V1 2
1407360 | 1 a +-152.84 | 240 | 3472.3 | vanduo šaltas - V1 2
1407368 | 1 a +-152.84 | 200 | 642.3 | vanduo šaltas - V1 2
1407408 | 1 a +-152.84 | 2790 | 670 | vanduo šaltas - V1 2
1407434 | 1 a +-152.84 | 960 | 3472.3 | vanduo šaltas - V1 2
1407443 | 1 a +-152.84 | 3564.6 | 3472.3 | vanduo šaltas - V1 2
1407446 | 1 a +-152.84 | 443.657 | 3472.3 | vanduo šaltas - V1 2
1407454 | 1 a +-152.84 | 260 | 642.299 | vanduo šaltas - V1 2
1407510 | 1 a +-152.84 | 2790 | 670 | vanduo šaltas - V1 2
1407543 | 1 a +-152.84 | 230.437 | 3770 | vanduo šaltas - V1 2
1407569 | 1 a +-152.84 | 519 | 3772.3 | vanduo šaltas - V1 2
1407598 | 1 a +-152.84 | 440 | 3772.3 | vanduo šaltas - V1 2
1407606 | 1 a +-152.84 | 180 | 442.299 | vanduo šaltas - V1 2
1407638 | 1 a +-152.84 | 3290 | 470 | vanduo šaltas - V1 2
1407690 | 1 a +-152.84 | 718 | 3772.3 | vanduo šaltas - V1 2
1407699 | 1 a +-152.84 | 1259.8 | 3770 | vanduo šaltas - V1 2
1407702 | 1 a +-152.84 | 100 | 442.3 | vanduo šaltas - V1 2
1407731 | 1 a +-152.84 | 3290 | 470 | vanduo šaltas - V1 2
1407753 | 1 a +-152.84 | 738 | 3772.3 | vanduo šaltas - V1 2
1407762 | 1 a +-152.84 | 1040.86 | 3770 | vanduo šaltas - V1 2
1407765 | 1 a +-152.84 | 100 | 342.3 | vanduo šaltas - V1 2
1407794 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1407816 | 1 a +-152.84 | 718 | 3772.3 | vanduo šaltas - V1 2
1407825 | 1 a +-152.84 | 849.497 | 3770 | vanduo šaltas - V1 2
1408093 | 1 a +-152.84 | 180 | 342.3 | vanduo šaltas - V1 2
1408102 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1408126 | 1 a +-152.84 | 698 | 3772.3 | vanduo šaltas - V1 2
1408135 | 1 a +-152.84 | 4476.37 | 3770 | vanduo šaltas - V1 2
1408138 | 1 a +-152.84 | 60 | 342.299 | vanduo šaltas - V1 2
1408168 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1408190 | 1 a +-152.84 | 2493.61 | 3770 | vanduo šaltas - V1 2
1408207 | 2 a | 3743.51 | 3750 | vanduo šaltas - V1 2
1408248 | 2 a | 449.792 | 3750 | vanduo šaltas - V1 2
1408254 | 1 a +-152.84 | 1299 | 3772.3 | vanduo šaltas - V1 2
1408268 | 1 a +-152.84 | 240 | 3772.3 | vanduo šaltas - V1 2
1408276 | 1 a +-152.84 | 80 | 342.3 | vanduo šaltas - V1 2
1408314 | 1 a +-152.84 | 3390 | 370 | vanduo šaltas - V1 2
1408359 | 1 a +-152.84 | 156.009 | 3770 | vanduo šaltas - V1 2
1408368 | 1 a +-152.84 | 6408.88 | 3770 | vanduo šaltas - V1 2
1408371 | 1 a +-152.84 | 839 | 3772.3 | vanduo šaltas - V1 2
1408386 | 1 a +-152.84 | 400 | 3772.3 | vanduo šaltas - V1 2
1408402 | 1 a +-152.84 | 120 | 642.299 | vanduo šaltas - V1 2
1408433 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1408455 | 1 a +-152.84 | 438 | 3772.3 | vanduo šaltas - V1 2
1408466 | 1 a +-152.84 | 484.606 | 3770 | vanduo šaltas - V1 2
1408469 | 1 a +-152.84 | 80 | 642.3 | vanduo šaltas - V1 2
1408496 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1408520 | 1 a +-152.84 | 458 | 3772.3 | vanduo šaltas - V1 2
1408531 | 1 a +-152.84 | 534.386 | 3770 | vanduo šaltas - V1 2
1408534 | 1 a +-152.84 | 100 | 642.3 | vanduo šaltas - V1 2
1408559 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1408581 | 1 a +-152.84 | 918 | 3772.3 | vanduo šaltas - V1 2
1408590 | 1 a +-152.84 | 891.524 | 3770 | vanduo šaltas - V1 2
1408593 | 1 a +-152.84 | 440 | 3772.3 | vanduo šaltas - V1 2
1408601 | 1 a +-152.84 | 140 | 642.299 | vanduo šaltas - V1 2
1408642 | 1 a +-152.84 | 3090 | 670 | vanduo šaltas - V1 2
1409054 | 1 a +-152.84 | 2220 | 3472.3 | vanduo šaltas - V1 2
1409069 | 2 a | 142.829 | 3450 | vanduo šaltas - V1 2
1409074 | 1 a +-152.84 | 6065.59 | 3292.3 | vanduo šaltas - V1 2
1409179 | 1 a +-152.84 | 140 | 3320 | vanduo šaltas - V1 2
1409189 | 1 a +-152.84 | 360 | 3292.3 | vanduo šaltas - V1 2
1409199 | 1 a +-152.84 | 140 | 642.3 | vanduo šaltas - V1 2
1409227 | 1 a +-152.84 | 2610 | 670 | vanduo šaltas - V1 2
1409264 | 1 a +-152.84 | 340 | 3292.3 | vanduo šaltas - V1 2
