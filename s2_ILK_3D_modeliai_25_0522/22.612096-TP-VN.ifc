Properties of the parts of a building model (IFC2X3), part 52 of 57

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1352233 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1352258 | 4 a V1 | 40 | 17012.3 | vanduo šaltas - V1 2
1352267 | 4 a V1 | 3157.25 | 16999.5 | vanduo šaltas - V1 2
1352310 | 4 a V1 | 320 | 17012.3 | vanduo šaltas - V1 2
1352318 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1352351 | 4 a V1 | 2529.99 | 14470 | vanduo šaltas - V1 2
1352383 | 2 a | 1030 | 3459.5 | vanduo šaltas - V1 2
1352392 | 0 a | 2065.16 | 3450 | vanduo šaltas - V1 2
1352466 | 2 a | 92.2475 | 16940.8 | vanduo šaltas - V1 2
1352524 | 2 a | 424.983 | 17067 | vanduo šaltas - V1 2
1352583 | 4 a V1 | 951.321 | 17067 | vanduo šaltas - V1 2
1352635 | 4 a V1 | 3587 | 17070 | vanduo šaltas - V1 2
1352669 | 4 a V1 | 2499.24 | 17070 | vanduo šaltas - V1 2
1352677 | 4 a V1 | 2111.82 | 17072.3 | vanduo šaltas - V1 2
1352693 | 4 a V1 | 480 | 17072.3 | vanduo šaltas - V1 2
1352701 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1352743 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1352823 | 2 a | 4138.48 | 12734.3 | vanduo šaltas - V1 2
1352860 | 4 a V1 | 29.566 | 16896.8 | vanduo šaltas - V1 2
1352868 | 4 a V1 | 84.7392 | 16896.8 | vanduo šaltas - V1 2
1352876 | 4 a V1 | 1456 | 16896.8 | vanduo šaltas - V1 2
1352888 | 4 a V1 | 636 | 16896.8 | vanduo šaltas - V1 2
1352896 | 4 a V1 | 59.7482 | 16896.8 | vanduo šaltas - V1 2
1352914 | 4 a V1 | 128 | 14440 | vanduo šaltas - V1 2
1352961 | 4 a V1 | 2412.75 | 14472 | vanduo šaltas - V1 2
1352985 | 4 a V1 | 122.967 | 16899.1 | vanduo šaltas - V1 2
1352996 | 4 a V1 | 652.434 | 16896.8 | vanduo šaltas - V1 2
1352999 | 4 a V1 | 80 | 14142.3 | vanduo šaltas - V1 2
1353048 | 4 a V1 | 2716.75 | 14170 | vanduo šaltas - V1 2
1353084 | 4 a V1 | 780 | 16899.1 | vanduo šaltas - V1 2
1353093 | 4 a V1 | 1663.17 | 16899.1 | vanduo šaltas - V1 2
1353096 | 4 a V1 | 120 | 16899.1 | vanduo šaltas - V1 2
1353104 | 4 a V1 | 82.9673 | 14442.3 | vanduo šaltas - V1 2
1353134 | 4 a V1 | 2416.75 | 14470 | vanduo šaltas - V1 2
1353341 | 4 a V1 | 1000 | 16899.1 | vanduo šaltas - V1 2
1353351 | 4 a V1 | 120 | 16899.1 | vanduo šaltas - V1 2
1353365 | 4 a V1 | 61.4121 | 14442.3 | vanduo šaltas - V1 2
1353399 | 4 a V1 | 2416.75 | 14470 | vanduo šaltas - V1 2
1353421 | 4 a V1 | 253 | 17072.3 | vanduo šaltas - V1 2
1353432 | 2 a | 661.501 | 17067 | vanduo šaltas - V1 2
1353435 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1353505 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1353630 | 4 a V1 | 194.227 | 17072.3 | vanduo šaltas - V1 2
1353645 | 2 a | 141.516 | 17067 | vanduo šaltas - V1 2
1353648 | 4 a V1 | 87.6137 | 14442.3 | vanduo šaltas - V1 2
1353680 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1353726 | 4 a V1 | 245 | 16899.1 | vanduo šaltas - V1 2
1353735 | 4 a V1 | 131.86 | 16899.1 | vanduo šaltas - V1 2
1353738 | 4 a V1 | 145 | 16899.1 | vanduo šaltas - V1 2
1353746 | 4 a V1 | 110 | 14442.3 | vanduo šaltas - V1 2
1353774 | 4 a V1 | 2416.75 | 14470 | vanduo šaltas - V1 2
1353807 | 4 a V1 | 30 | 17072.3 | vanduo šaltas - V1 2
1353821 | 4 a V1 | 50 | 14442.3 | vanduo šaltas - V1 2
1353856 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1353898 | 4 a V1 | 110 | 14142.3 | vanduo šaltas - V1 2
1353907 | 4 a V1 | 2884 | 14170 | vanduo šaltas - V1 2
1353910 | 4 a V1 | 1054.33 | 17067 | vanduo šaltas - V1 2
1353924 | 4 a V1 | 120 | 14142.3 | vanduo šaltas - V1 2
1353933 | 4 a V1 | 2884 | 14170 | vanduo šaltas - V1 2
1353936 | 4 a V1 | 1182.33 | 17067 | vanduo šaltas - V1 2
1353952 | 4 a V1 | 163.817 | 14642.3 | vanduo šaltas - V1 2
1353965 | 4 a V1 | 2384 | 14670 | vanduo šaltas - V1 2
1353968 | 4 a V1 | 2607.02 | 17067 | vanduo šaltas - V1 2
1353992 | 4 a V1 | 55 | 16896.8 | vanduo šaltas - V1 2
1354001 | 4 a V1 | 4165.26 | 16896.8 | vanduo šaltas - V1 2
1354004 | 4 a V1 | 56 | 16896.8 | vanduo šaltas - V1 2
1354016 | 4 a V1 | 88.6203 | 16896.8 | vanduo šaltas - V1 2
1354026 | 4 a V1 | 98 | 14440 | vanduo šaltas - V1 2
1354050 | 4 a V1 | 2412.75 | 14472 | vanduo šaltas - V1 2
1354106 | 4 a V1 | 168 | 14440 | vanduo šaltas - V1 2
1354115 | 4 a V1 | 2411.75 | 14472 | vanduo šaltas - V1 2
1354118 | 4 a V1 | 41.3797 | 16896.8 | vanduo šaltas - V1 2
1354151 | 4 a V1 | 1342 | 17072.3 | vanduo šaltas - V1 2
1354165 | 4 a V1 | 340 | 17072.3 | vanduo šaltas - V1 2
1354178 | 4 a V1 | 80 | 14442.3 | vanduo šaltas - V1 2
1354208 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1354254 | 4 a V1 | 238 | 17072.3 | vanduo šaltas - V1 2
1354263 | 4 a V1 | 4298.52 | 17070 | vanduo šaltas - V1 2
1354266 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1354297 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1354317 | 4 a V1 | 218 | 17072.3 | vanduo šaltas - V1 2
1354326 | 4 a V1 | 3194.23 | 17070 | vanduo šaltas - V1 2
1354329 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1354352 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1354374 | 4 a V1 | 958 | 17072.3 | vanduo šaltas - V1 2
1354383 | 4 a V1 | 91.2093 | 17070 | vanduo šaltas - V1 2
1354386 | 4 a V1 | 100 | 17072.3 | vanduo šaltas - V1 2
1354394 | 4 a V1 | 180 | 14442.3 | vanduo šaltas - V1 2
1354432 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1354477 | 4 a V1 | 343 | 17072.3 | vanduo šaltas - V1 2
1354486 | 4 a V1 | 1791.8 | 17070 | vanduo šaltas - V1 2
1354489 | 4 a V1 | 90 | 14442.3 | vanduo šaltas - V1 2
1354515 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1354537 | 4 a V1 | 450 | 17072.3 | vanduo šaltas - V1 2
1354550 | 4 a V1 | 147.179 | 17072.3 | vanduo šaltas - V1 2
1354553 | 4 a V1 | 70 | 14442.3 | vanduo šaltas - V1 2
1354587 | 4 a V1 | 2590 | 14470 | vanduo šaltas - V1 2
1354734 | 2 a | 1008.29 | 3450 | vanduo šaltas - V1 2
1354809 | 1 a +-152.84 | 1635.7 | 17107 | vanduo šaltas - V1 2
1354851 | 4 a V1 | 308 | 17107 | vanduo šaltas - V1 2
1354861 | 4 a V1 | 242.251 | 17107 | vanduo šaltas - V1 2
1354869 | 4 a V1 | 980 | 17112.3 | vanduo šaltas - V1 2
1354883 | 4 a V1 | 900 | 17112.3 | vanduo šaltas - V1 2
1354891 | 4 a V1 | 280 | 14142.3 | vanduo šaltas - V1 2
1354926 | 4 a V1 | 2930 | 14170 | vanduo šaltas - V1 2
1354962 | 4 a V1 | 5566 | 17110 | vanduo šaltas - V1 2
1354974 | 4 a V1 | 6155 | 17110 | vanduo šaltas - V1 2
1354982 | 4 a V1 | 1319 | 17112.3 | vanduo šaltas - V1 2
1355002 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1355041 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1355078 | 4 a V1 | 2160 | 17110 | vanduo šaltas - V1 2
1355100 | 4 a V1 | 189.136 | 17112.3 | vanduo šaltas - V1 2
1355123 | 4 a V1 | 180 | 17112.3 | vanduo šaltas - V1 2
1355131 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1355171 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1355200 | 4 a V1 | 3600 | 17112.3 | vanduo šaltas - V1 2
1355217 | 4 a V1 | 668.864 | 17112.3 | vanduo šaltas - V1 2
1355220 | 4 a V1 | 120 | 17112.3 | vanduo šaltas - V1 2
1355230 | 4 a V1 | 120 | 17112.3 | vanduo šaltas - V1 2
1355238 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1355272 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1355318 | 4 a V1 | 280 | 17112.3 | vanduo šaltas - V1 2
1355353 | 4 a V1 | 460 | 17112.3 | vanduo šaltas - V1 2
1355363 | 4 a V1 | 100 | 17112.3 | vanduo šaltas - V1 2
1355371 | 4 a V1 | 86.0346 | 14442.3 | vanduo šaltas - V1 2
1355395 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1355417 | 4 a V1 | 614 | 17112.3 | vanduo šaltas - V1 2
1355426 | 4 a V1 | 2083.97 | 17107 | vanduo šaltas - V1 2
1355429 | 4 a V1 | 1380 | 17112.3 | vanduo šaltas - V1 2
1355437 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1355476 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1355500 | 4 a V1 | 989.219 | 17112.3 | vanduo šaltas - V1 2
1355509 | 4 a V1 | 86.194 | 17107 | vanduo šaltas - V1 2
1355512 | 4 a V1 | 380 | 17112.3 | vanduo šaltas - V1 2
1355520 | 4 a V1 | 120 | 14142.3 | vanduo šaltas - V1 2
1355558 | 4 a V1 | 2930 | 14170 | vanduo šaltas - V1 2
1355580 | 4 a V1 | 135.681 | 17112.3 | vanduo šaltas - V1 2
1355589 | 4 a V1 | 50.6856 | 17107 | vanduo šaltas - V1 2
1355592 | 4 a V1 | 380 | 17112.3 | vanduo šaltas - V1 2
1355790 | 4 a V1 | 51.4836 | 14242.3 | vanduo šaltas - V1 2
1355801 | 4 a V1 | 2830 | 14270 | vanduo šaltas - V1 2
1355839 | 4 a V1 | 494 | 17112.3 | vanduo šaltas - V1 2
1355850 | 4 a V1 | 592.282 | 17107 | vanduo šaltas - V1 2
1355853 | 4 a V1 | 320 | 17112.3 | vanduo šaltas - V1 2
1355861 | 4 a V1 | 60 | 14442.3 | vanduo šaltas - V1 2
1355899 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1355949 | 4 a V1 | 879.627 | 17112.3 | vanduo šaltas - V1 2
1355961 | 4 a V1 | 150 | 17112.3 | vanduo šaltas - V1 2
1355969 | 4 a V1 | 35 | 14442.3 | vanduo šaltas - V1 2
1356003 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1356031 | 4 a V1 | 934.597 | 17112.3 | vanduo šaltas - V1 2
1356042 | 4 a V1 | 159.131 | 17107 | vanduo šaltas - V1 2
1356110 | 4 a V1 | 946.028 | 17107 | vanduo šaltas - V1 2
1356114 | 4 a V1 | 120 | 14142.3 | vanduo šaltas - V1 2
1356123 | 4 a V1 | 2930 | 14170 | vanduo šaltas - V1 2
1356169 | 4 a V1 | 894 | 17112.3 | vanduo šaltas - V1 2
1356178 | 4 a V1 | 599.21 | 17107 | vanduo šaltas - V1 2
1356181 | 4 a V1 | 80 | 14642.3 | vanduo šaltas - V1 2
1356204 | 4 a V1 | 2430 | 14670 | vanduo šaltas - V1 2
1356235 | 4 a V1 | 474 | 17112.3 | vanduo šaltas - V1 2
1356244 | 4 a V1 | 1495.25 | 17107 | vanduo šaltas - V1 2
1356247 | 4 a V1 | 140 | 17112.3 | vanduo šaltas - V1 2
1356255 | 4 a V1 | 65.2368 | 14442.3 | vanduo šaltas - V1 2
1356292 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1356324 | 4 a V1 | 2492 | 17110 | vanduo šaltas - V1 2
1356333 | 1 a +-152.84 | 91.1488 | 17107 | vanduo šaltas - V1 2
1356336 | 4 a V1 | 332.745 | 17112.3 | vanduo šaltas - V1 2
1356378 | 4 a V1 | 460 | 17112.3 | vanduo šaltas - V1 2
1356388 | 4 a V1 | 120 | 17112.3 | vanduo šaltas - V1 2
1356402 | 4 a V1 | 122.16 | 14442.3 | vanduo šaltas - V1 2
1356434 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1356479 | 4 a V1 | 80 | 17112.3 | vanduo šaltas - V1 2
1356488 | 4 a V1 | 1788.79 | 17112.3 | vanduo šaltas - V1 2
1356491 | 4 a V1 | 163.572 | 14442.3 | vanduo šaltas - V1 2
1356523 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1356545 | 4 a V1 | 620 | 17112.3 | vanduo šaltas - V1 2
1356554 | 4 a V1 | 217.461 | 17112.3 | vanduo šaltas - V1 2
1356557 | 4 a V1 | 100 | 17112.3 | vanduo šaltas - V1 2
1356565 | 4 a V1 | 120 | 14442.3 | vanduo šaltas - V1 2
1356593 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1356647 | 4 a V1 | 68 | 17107 | vanduo šaltas - V1 2
1356656 | 1 a +-152.84 | 91.1488 | 17107 | vanduo šaltas - V1 2
1356659 | 4 a V1 | 31.1457 | 17107 | vanduo šaltas - V1 2
1356667 | 4 a V1 | 636 | 17110 | vanduo šaltas - V1 2
1356693 | 4 a V1 | 116 | 17110 | vanduo šaltas - V1 2
1356701 | 4 a V1 | 118 | 14440 | vanduo šaltas - V1 2
1356727 | 4 a V1 | 2626 | 14472 | vanduo šaltas - V1 2
1356757 | 4 a V1 | 892 | 17110 | vanduo šaltas - V1 2
1356766 | 4 a V1 | 1482 | 17107 | vanduo šaltas - V1 2
1356769 | 4 a V1 | 734.191 | 17110 | vanduo šaltas - V1 2
1356777 | 4 a V1 | 199 | 17112.3 | vanduo šaltas - V1 2
1356794 | 4 a V1 | 55 | 14642.3 | vanduo šaltas - V1 2
1356816 | 4 a V1 | 2430 | 14670 | vanduo šaltas - V1 2
1356838 | 4 a V1 | 218 | 17112.3 | vanduo šaltas - V1 2
1356847 | 4 a V1 | 601.809 | 17110 | vanduo šaltas - V1 2
1356850 | 4 a V1 | 60 | 14142.3 | vanduo šaltas - V1 2
1356876 | 4 a V1 | 2930 | 14170 | vanduo šaltas - V1 2
1356904 | 4 a V1 | 694 | 17112.3 | vanduo šaltas - V1 2
1356915 | 4 a V1 | 2592.91 | 17107 | vanduo šaltas - V1 2
1356918 | 4 a V1 | 80 | 17112.3 | vanduo šaltas - V1 2
1356929 | 4 a V1 | 100 | 14442.3 | vanduo šaltas - V1 2
1356963 | 4 a V1 | 2630 | 14470 | vanduo šaltas - V1 2
1356990 | 4 a V1 | 674 | 17112.3 | vanduo šaltas - V1 2
1356999 | 4 a V1 | 270.072 | 17107 | vanduo šaltas - V1 2
1357002 | 4 a V1 | 139.437 | 17112.3 | vanduo šaltas - V1 2
1357010 | 4 a V1 | 82.1309 | 14642.3 | vanduo šaltas - V1 2
1357039 | 4 a V1 | 2430 | 14670 | vanduo šaltas - V1 2
1357061 | 4 a V1 | 514 | 17112.3 | vanduo šaltas - V1 2
1357070 | 4 a V1 | 932.871 | 17107 | vanduo šaltas - V1 2
1357073 | 4 a V1 | 60 | 17112.3 | vanduo šaltas - V1 2
1357081 | 4 a V1 | 120 | 14642.3 | vanduo šaltas - V1 2
1357113 | 4 a V1 | 2430 | 14670 | vanduo šaltas - V1 2
1357235 | 1 a +-152.84 | 4511.96 | 7942 | vanduo šaltas - V1 2
1357374 | 1 a +-152.84 | 70.5257 | 12475 | vanduo šaltas - V1 2
1357377 | 3 a | 2132 | 12478 | vanduo šaltas - V1 2
1357427 | 3 a | 145.615 | 12478 | vanduo šaltas - V1 2
1357441 | 3 a | 7159 | 12480.3 | vanduo šaltas - V1 2
1357466 | 3 a | 1100 | 12480.3 | vanduo šaltas - V1 2
1357476 | 3 a | 160 | 9942.3 | vanduo šaltas - V1 2
1357514 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1357541 | 3 a | 155 | 12478 | vanduo šaltas - V1 2
1357554 | 3 a | 1264.38 | 12478 | vanduo šaltas - V1 2
1357557 | 3 a | 851.91 | 12480.3 | vanduo šaltas - V1 2
1357574 | 3 a | 420 | 12480.3 | vanduo šaltas - V1 2
1357582 | 3 a | 80 | 9642.3 | vanduo šaltas - V1 2
1357617 | 3 a | 2797.96 | 9670 | vanduo šaltas - V1 2
1357639 | 3 a | 400 | 12480.3 | vanduo šaltas - V1 2
1357650 | 3 a | 78.5624 | 12480.3 | vanduo šaltas - V1 2
1357653 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1357681 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1357705 | 3 a | 1440 | 12480.3 | vanduo šaltas - V1 2
1357716 | 3 a | 328.528 | 12480.3 | vanduo šaltas - V1 2
1357719 | 3 a | 240 | 12480.3 | vanduo šaltas - V1 2
1357729 | 3 a | 600 | 12480.3 | vanduo šaltas - V1 2
1357737 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1357770 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1357813 | 3 a | 3001.6 | 12478 | vanduo šaltas - V1 2
1357821 | 3 a | 379.579 | 12478 | vanduo šaltas - V1 2
1357829 | 3 a | 228.857 | 12480.3 | vanduo šaltas - V1 2
1357869 | 3 a | 160 | 12480.3 | vanduo šaltas - V1 2
1357877 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1357913 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1357943 | 3 a | 338 | 12480.3 | vanduo šaltas - V1 2
1357954 | 3 a | 5084.47 | 12478 | vanduo šaltas - V1 2
1357957 | 3 a | 100 | 12480.3 | vanduo šaltas - V1 2
1357965 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1358011 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1358037 | 3 a | 2878 | 12480.3 | vanduo šaltas - V1 2
1358046 | 3 a | 1390.95 | 12478 | vanduo šaltas - V1 2
1358049 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1358078 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1358177 | 3 a | 5231 | 12480.3 | vanduo šaltas - V1 2
1358199 | 3 a | 139.695 | 12480.3 | vanduo šaltas - V1 2
1358215 | 3 a | 121.486 | 9942.3 | vanduo šaltas - V1 2
1358241 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1358268 | 3 a | 74.2391 | 9942.3 | vanduo šaltas - V1 2
1358279 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1358282 | 3 a | 180.305 | 12480.3 | vanduo šaltas - V1 2
1358337 | 3 a | 578 | 12480.3 | vanduo šaltas - V1 2
1358348 | 3 a | 44.8703 | 12478 | vanduo šaltas - V1 2
1358351 | 3 a | 835 | 12480.3 | vanduo šaltas - V1 2
1358361 | 3 a | 694.709 | 12480.3 | vanduo šaltas - V1 2
1358369 | 3 a | 180 | 9942.3 | vanduo šaltas - V1 2
1358411 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1358624 | 3 a | 160 | 12480.3 | vanduo šaltas - V1 2
1358633 | 3 a | 3925.29 | 12480.3 | vanduo šaltas - V1 2
1358636 | 3 a | 671.713 | 12480.3 | vanduo šaltas - V1 2
1358644 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1358679 | 3 a | 2497.96 | 9970 | vanduo šaltas - V1 2
1358734 | 2 a | 966.561 | 12692.6 | vanduo šaltas - V1 2
1358780 | 2 a | 4883.87 | 7782.4 | vanduo šaltas - V1 2
1358788 | 3 a | 66.6103 | 12690.3 | vanduo šaltas - V1 2
1358817 | 2 a | 68.279 | 12687.3 | vanduo šaltas - V1 2
1358830 | 3 a | 466.842 | 12690.3 | vanduo šaltas - V1 2
1358840 | 3 a | 2190.5 | 12692.6 | vanduo šaltas - V1 2
1358871 | 3 a | 980 | 12692.6 | vanduo šaltas - V1 2
1358881 | 3 a | 300 | 12692.6 | vanduo šaltas - V1 2
1358889 | 3 a | 140 | 9942.3 | vanduo šaltas - V1 2
1358935 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1358957 | 3 a | 1058 | 12692.6 | vanduo šaltas - V1 2
1358966 | 3 a | 2229.1 | 12690.3 | vanduo šaltas - V1 2
1358969 | 3 a | 84.8451 | 9942.3 | vanduo šaltas - V1 2
1359017 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359044 | 3 a | 338 | 12692.6 | vanduo šaltas - V1 2
1359053 | 3 a | 6031.56 | 12690.3 | vanduo šaltas - V1 2
1359056 | 3 a | 155 | 12692.6 | vanduo šaltas - V1 2
1359064 | 3 a | 45 | 9942.3 | vanduo šaltas - V1 2
1359109 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359167 | 3 a | 180 | 12692.6 | vanduo šaltas - V1 2
1359177 | 3 a | 260 | 12692.6 | vanduo šaltas - V1 2
1359185 | 3 a | 40.3951 | 9942.3 | vanduo šaltas - V1 2
1359235 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359268 | 3 a | 398 | 12690.3 | vanduo šaltas - V1 2
1359278 | 3 a | 632 | 12692.6 | vanduo šaltas - V1 2
1359286 | 3 a | 63 | 9942.3 | vanduo šaltas - V1 2
1359333 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359411 | 3 a | 2858.44 | 12692.6 | vanduo šaltas - V1 2
1359426 | 3 a | 509.566 | 12690.3 | vanduo šaltas - V1 2
1359476 | 3 a | 4505.43 | 12690.3 | vanduo šaltas - V1 2
1359480 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1359489 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359523 | 3 a | 98 | 12692.6 | vanduo šaltas - V1 2
1359532 | 3 a | 2245.39 | 12690.3 | vanduo šaltas - V1 2
1359535 | 3 a | 5700 | 12692.6 | vanduo šaltas - V1 2
1359546 | 3 a | 580 | 12692.6 | vanduo šaltas - V1 2
1359559 | 3 a | 265 | 12692.6 | vanduo šaltas - V1 2
1359567 | 3 a | 50 | 9942.3 | vanduo šaltas - V1 2
1359610 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359678 | 3 a | 660 | 12692.6 | vanduo šaltas - V1 2
1359690 | 3 a | 130.675 | 9942.3 | vanduo šaltas - V1 2
1359720 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1359836 | 3 a | 114.014 | 12692.6 | vanduo šaltas - V1 2
1359853 | 2 a | 516.16 | 12687.3 | vanduo šaltas - V1 2
1359856 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1359931 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1360026 | 3 a | 125 | 12692.6 | vanduo šaltas - V1 2
1360035 | 3 a | 1239.99 | 12692.6 | vanduo šaltas - V1 2
1360038 | 3 a | 200 | 12692.6 | vanduo šaltas - V1 2
1360046 | 3 a | 90 | 9942.3 | vanduo šaltas - V1 2
1360088 | 3 a | 2710.27 | 9970 | vanduo šaltas - V1 2
1360127 | 2 a | 61.9126 | 12669.8 | vanduo šaltas - V1 7
1360318 | 2 a | 4713.97 | 7934.82 | vanduo šaltas - V1 2
1360326 | 3 a | 4158 | 12672.8 | vanduo šaltas - V1 2
1360340 | 3 a | 768 | 12675.1 | vanduo šaltas - V1 2
1360359 | 3 a | 100 | 12675.1 | vanduo šaltas - V1 2
1360369 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1360405 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1360557 | 3 a | 200 | 12675.1 | vanduo šaltas - V1 2
1360567 | 3 a | 760 | 12675.1 | vanduo šaltas - V1 2
1360592 | 3 a | 2470 | 12675.1 | vanduo šaltas - V1 2
1360602 | 3 a | 200.726 | 12675.1 | vanduo šaltas - V1 2
1360610 | 3 a | 95.8616 | 9942.3 | vanduo šaltas - V1 2
1360656 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1360709 | 3 a | 160 | 12675.1 | vanduo šaltas - V1 2
1360718 | 3 a | 759.274 | 12675.1 | vanduo šaltas - V1 2
1360721 | 3 a | 480 | 12675.1 | vanduo šaltas - V1 2
1360729 | 3 a | 140 | 12675.1 | vanduo šaltas - V1 2
1360739 | 3 a | 85 | 9942.3 | vanduo šaltas - V1 2
1360780 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1360850 | 3 a | 1674 | 12675.1 | vanduo šaltas - V1 2
1360859 | 2 a | 1395.37 | 12669.8 | vanduo šaltas - V1 2
1360862 | 3 a | 340 | 12675.1 | vanduo šaltas - V1 2
1360870 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1360905 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1360936 | 2 a | 4616.47 | 12669.8 | vanduo šaltas - V1 2
1360962 | 3 a | 355 | 12675.1 | vanduo šaltas - V1 8
1360971 | 3 a | 60 | 12675.1 | vanduo šaltas - V1 8
1360981 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 8
1361008 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 8
1361030 | 3 a | 226.189 | 12675.1 | vanduo šaltas - V1 2
1361039 | 2 a | 932.138 | 12669.8 | vanduo šaltas - V1 2
1361042 | 3 a | 600 | 12675.1 | vanduo šaltas - V1 2
1361050 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1361077 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1361099 | 3 a | 400 | 12675.1 | vanduo šaltas - V1 2
1361108 | 3 a | 534.944 | 12675.1 | vanduo šaltas - V1 2
1361111 | 3 a | 60 | 9642.3 | vanduo šaltas - V1 2
1361144 | 3 a | 2992.78 | 9670 | vanduo šaltas - V1 2
1361166 | 3 a | 564.766 | 12675.1 | vanduo šaltas - V1 2
1361175 | 2 a | 1049.03 | 12669.8 | vanduo šaltas - V1 2
1361178 | 3 a | 345 | 12675.1 | vanduo šaltas - V1 2
1361186 | 3 a | 50 | 9942.3 | vanduo šaltas - V1 2
1361218 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1361251 | 3 a | 330 | 12675.1 | vanduo šaltas - V1 2
1361262 | 3 a | 756.795 | 12675.1 | vanduo šaltas - V1 2
1361265 | 3 a | 40 | 9742.3 | vanduo šaltas - V1 2
1361293 | 3 a | 2892.78 | 9770 | vanduo šaltas - V1 2
1361355 | 3 a | 155 | 12675.1 | vanduo šaltas - V1 2
1361362 | 3 a | 332.438 | 12675.1 | vanduo šaltas - V1 2
1361365 | 3 a | 55 | 9642.3 | vanduo šaltas - V1 2
1361405 | 3 a | 2992.78 | 9670 | vanduo šaltas - V1 2
1361454 | 2 a | 389.331 | 12478.8 | vanduo šaltas - V1 2
1361465 | 2 a | 4606.69 | 7851.15 | vanduo šaltas - V1 2
1361556 | 3 a | 42.444 | 12481.8 | vanduo šaltas - V1 2
1361570 | 3 a | 339 | 12484.1 | vanduo šaltas - V1 2
1361630 | 3 a | 820 | 12484.1 | vanduo šaltas - V1 2
1361640 | 3 a | 140 | 9942.3 | vanduo šaltas - V1 2
1361689 | 3 a | 2501.84 | 9970 | vanduo šaltas - V1 2
1361731 | 3 a | 598 | 12484.1 | vanduo šaltas - V1 2
1361746 | 3 a | 862.789 | 12481.8 | vanduo šaltas - V1 2
1361749 | 3 a | 911.392 | 12484.1 | vanduo šaltas - V1 2
1361759 | 3 a | 129.512 | 9642.3 | vanduo šaltas - V1 2
1361794 | 3 a | 2801.84 | 9670 | vanduo šaltas - V1 2
1361846 | 3 a | 718 | 12484.1 | vanduo šaltas - V1 2
1361859 | 3 a | 179.998 | 12481.8 | vanduo šaltas - V1 2
1361862 | 3 a | 280 | 12484.1 | vanduo šaltas - V1 2
1361878 | 3 a | 77.0023 | 9942.3 | vanduo šaltas - V1 2
1361913 | 3 a | 2501.84 | 9970 | vanduo šaltas - V1 2
1361937 | 3 a | 4355 | 12481.8 | vanduo šaltas - V1 2
1361962 | 3 a | 5044.77 | 12481.8 | vanduo šaltas - V1 2
1361965 | 3 a | 1899 | 12484.1 | vanduo šaltas - V1 2
1361979 | 3 a | 540 | 12484.1 | vanduo šaltas - V1 2
1361987 | 3 a | 240 | 12484.1 | vanduo šaltas - V1 2
1361997 | 3 a | 81.3888 | 9942.3 | vanduo šaltas - V1 2
1362047 | 3 a | 2501.84 | 9970 | vanduo šaltas - V1 2
1362086 | 2 a | 8858.49 | 3831 | vanduo šaltas - V1 2
1362108 | 3 a | 68.5029 | 12710.5 | vanduo šaltas - V1 2
1362116 | 3 a | 147.067 | 12713.5 | vanduo šaltas - V1 2
1362130 | 3 a | 650.5 | 12715.8 | vanduo šaltas - V1 2
1362237 | 3 a | 714.137 | 12715.8 | vanduo šaltas - V1 2
1362245 | 3 a | 200 | 12715.8 | vanduo šaltas - V1 2
1362255 | 3 a | 90 | 9942.3 | vanduo šaltas - V1 2
1362301 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1362322 | 3 a | 200 | 12715.8 | vanduo šaltas - V1 2
1362331 | 3 a | 1705.86 | 12715.8 | vanduo šaltas - V1 2
1362334 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1362379 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1362400 | 3 a | 730.302 | 12715.8 | vanduo šaltas - V1 2
1362414 | 3 a | 547.592 | 12715.8 | vanduo šaltas - V1 2
1362424 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1362458 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1362479 | 3 a | 547.592 | 12715.8 | vanduo šaltas - V1 2
1362488 | 3 a | 1889.7 | 12715.8 | vanduo šaltas - V1 2
1362491 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1362533 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1362610 | 3 a | 5432.83 | 12713.5 | vanduo šaltas - V1 2
1362641 | 3 a | 160.953 | 12710.5 | vanduo šaltas - V1 2
1362703 | 3 a | 6711.48 | 12710.5 | vanduo šaltas - V1 2
1362707 | 3 a | 165.81 | 12713.5 | vanduo šaltas - V1 2
1362760 | 3 a | 219.501 | 12715.8 | vanduo šaltas - V1 2
1362776 | 3 a | 520 | 12715.8 | vanduo šaltas - V1 2
1362786 | 3 a | 120.535 | 9942.3 | vanduo šaltas - V1 2
1362816 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1362867 | 3 a | 460 | 12715.8 | vanduo šaltas - V1 2
1362876 | 3 a | 879.499 | 12715.8 | vanduo šaltas - V1 2
1362879 | 3 a | 140 | 9942.3 | vanduo šaltas - V1 2
1362913 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1362937 | 3 a | 78 | 12715.8 | vanduo šaltas - V1 2
1362948 | 3 a | 770.19 | 12713.5 | vanduo šaltas - V1 2
1362951 | 3 a | 3120 | 12715.8 | vanduo šaltas - V1 2
1362967 | 3 a | 1760 | 12715.8 | vanduo šaltas - V1 2
1362975 | 3 a | 160 | 12715.8 | vanduo šaltas - V1 2
1362988 | 3 a | 240 | 9942.3 | vanduo šaltas - V1 2
1363024 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1363045 | 3 a | 596.229 | 12713.5 | vanduo šaltas - V1 2
1363054 | 3 a | 3573.16 | 12710.5 | vanduo šaltas - V1 2
1363057 | 3 a | 219 | 12715.8 | vanduo šaltas - V1 2
1363079 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1363110 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1363132 | 3 a | 218 | 12715.8 | vanduo šaltas - V1 2
1363141 | 3 a | 1326.38 | 12713.5 | vanduo šaltas - V1 2
1363144 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1363177 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1363201 | 3 a | 3898 | 12715.8 | vanduo šaltas - V1 2
1363220 | 3 a | 129.394 | 12713.5 | vanduo šaltas - V1 2
1363223 | 3 a | 60 | 12715.8 | vanduo šaltas - V1 2
1363233 | 3 a | 160 | 9942.3 | vanduo šaltas - V1 2
1363290 | 3 a | 2733.49 | 9970 | vanduo šaltas - V1 2
1363316 | 3 a | 1098 | 12762 | vanduo šaltas - V1 2
1363357 | 3 a | 4362.01 | 8379 | vanduo šaltas - V1 2
1363568 | 3 a | 134.578 | 12762 | vanduo šaltas - V1 2
1363578 | 3 a | 1895 | 12765 | vanduo šaltas - V1 2
1363608 | 3 a | 1755 | 12765 | vanduo šaltas - V1 2
1363618 | 3 a | 644.25 | 12765 | vanduo šaltas - V1 2
1363626 | 3 a | 152.581 | 12767.3 | vanduo šaltas - V1 2
1363652 | 3 a | 240 | 12767.3 | vanduo šaltas - V1 2
1363665 | 3 a | 161.222 | 9942.3 | vanduo šaltas - V1 2
1363698 | 3 a | 2785.01 | 9970 | vanduo šaltas - V1 2
1363719 | 3 a | 303 | 12767.3 | vanduo šaltas - V1 2
1363728 | 3 a | 268.269 | 12765 | vanduo šaltas - V1 2
1363731 | 3 a | 96.2223 | 9942.3 | vanduo šaltas - V1 2
1363770 | 3 a | 2785.01 | 9970 | vanduo šaltas - V1 2
1363811 | 3 a | 50 | 12767.3 | vanduo šaltas - V1 2
1363820 | 3 a | 77.9187 | 12767.3 | vanduo šaltas - V1 2
1363823 | 3 a | 120 | 9642.3 | vanduo šaltas - V1 2
1363867 | 3 a | 3085.01 | 9670 | vanduo šaltas - V1 2
1363889 | 3 a | 218 | 12767.3 | vanduo šaltas - V1 2
1363898 | 3 a | 335.981 | 12765 | vanduo šaltas - V1 2
1363901 | 3 a | 80 | 10142.3 | vanduo šaltas - V1 2
1363931 | 3 a | 2585.01 | 10170 | vanduo šaltas - V1 2
1363977 | 3 a | 497.438 | 12767.3 | vanduo šaltas - V1 2
1363998 | 3 a | 60 | 12767.3 | vanduo šaltas - V1 2
1364008 | 3 a | 110 | 9942.3 | vanduo šaltas - V1 2
1364037 | 3 a | 2785.01 | 9970 | vanduo šaltas - V1 2
1364059 | 3 a | 380 | 12767.3 | vanduo šaltas - V1 2
1364068 | 3 a | 833.562 | 12767.3 | vanduo šaltas - V1 2
1364071 | 3 a | 180 | 12767.3 | vanduo šaltas - V1 2
1364079 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1364126 | 3 a | 2785.01 | 9970 | vanduo šaltas - V1 2
1364153 | 3 a | 32 | 12765 | vanduo šaltas - V1 2
1364162 | 3 a | 2714.42 | 12762 | vanduo šaltas - V1 2
1364165 | 3 a | 195 | 12765 | vanduo šaltas - V1 2
1364175 | 3 a | 1215 | 12765 | vanduo šaltas - V1 2
1364183 | 3 a | 39 | 12767.3 | vanduo šaltas - V1 2
1364200 | 3 a | 100 | 10142.3 | vanduo šaltas - V1 2
1364253 | 3 a | 2585.01 | 10170 | vanduo šaltas - V1 2
1364308 | 3 a | 70 | 12767.3 | vanduo šaltas - V1 2
1364318 | 3 a | 65 | 10142.3 | vanduo šaltas - V1 2
1364360 | 3 a | 2585.01 | 10170 | vanduo šaltas - V1 2
1364401 | 2 a | 144.796 | 7767.64 | vanduo šaltas - V1 2
1364459 | 3 a | 2161.47 | 7933.44 | vanduo šaltas - V1 2
1364467 | 3 a | 89.6243 | 7936.44 | vanduo šaltas - V1 2
1364485 | 3 a | 1999 | 7938.74 | vanduo šaltas - V1 2
1364519 | 3 a | 193.492 | 7938.74 | vanduo šaltas - V1 2
1364529 | 3 a | 260 | 7938.74 | vanduo šaltas - V1 2
1364537 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1364581 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1364610 | 3 a | 305 | 7938.74 | vanduo šaltas - V1 2
1364621 | 3 a | 326.508 | 7938.74 | vanduo šaltas - V1 2
1364624 | 3 a | 55 | 9942.3 | vanduo šaltas - V1 2
1364672 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1364696 | 3 a | 278 | 7938.74 | vanduo šaltas - V1 2
1364711 | 3 a | 3937.31 | 7936.44 | vanduo šaltas - V1 2
1364714 | 3 a | 680 | 7938.74 | vanduo šaltas - V1 2
1364724 | 3 a | 260 | 7938.74 | vanduo šaltas - V1 2
1364732 | 3 a | 140 | 9942.3 | vanduo šaltas - V1 2
1364770 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1364815 | 3 a | 78 | 7936.44 | vanduo šaltas - V1 2
1364853 | 3 a | 1776 | 7936.44 | vanduo šaltas - V1 2
1364863 | 3 a | 3636 | 7936.44 | vanduo šaltas - V1 2
1364871 | 3 a | 622.478 | 7936.44 | vanduo šaltas - V1 2
1364881 | 3 a | 839 | 7938.74 | vanduo šaltas - V1 2
1364904 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1364952 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1365028 | 3 a | 858 | 7938.74 | vanduo šaltas - V1 2
1365041 | 3 a | 353.522 | 7936.44 | vanduo šaltas - V1 2
1365110 | 3 a | 308 | 7938.74 | vanduo šaltas - V1 2
1365125 | 3 a | 2345.06 | 7936.44 | vanduo šaltas - V1 2
1365128 | 3 a | 60 | 9942.3 | vanduo šaltas - V1 2
1365190 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1365216 | 3 a | 80 | 9642.3 | vanduo šaltas - V1 2
1365229 | 3 a | 1663.56 | 7966.44 | vanduo šaltas - V1 2
1365255 | 3 a | 1340.94 | 7938.74 | vanduo šaltas - V1 2
1365272 | 3 a | 761.285 | 7933.44 | vanduo šaltas - V1 2
1365275 | 3 a | 260 | 7938.74 | vanduo šaltas - V1 2
1365283 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1365317 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1365339 | 3 a | 200 | 7938.74 | vanduo šaltas - V1 2
1365356 | 3 a | 802.547 | 7938.74 | vanduo šaltas - V1 2
1365359 | 3 a | 65 | 9942.3 | vanduo šaltas - V1 2
1365391 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1365438 | 3 a | 210 | 7938.74 | vanduo šaltas - V1 2
1365449 | 3 a | 370.518 | 7938.74 | vanduo šaltas - V1 2
1365452 | 3 a | 70 | 9942.3 | vanduo šaltas - V1 2
1365499 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1365528 | 3 a | 85 | 10142.3 | vanduo šaltas - V1 2
1365537 | 3 a | 2157.56 | 7972.44 | vanduo šaltas - V1 2
1365540 | 3 a | 106.375 | 7933.44 | vanduo šaltas - V1 2
1365580 | 3 a | 291.48 | 7936.44 | vanduo šaltas - V1 2
1365597 | 3 a | 188.873 | 7933.44 | vanduo šaltas - V1 2
1365600 | 3 a | 448.205 | 7936.44 | vanduo šaltas - V1 2
1365610 | 3 a | 720.001 | 7936.44 | vanduo šaltas - V1 2
1365620 | 3 a | 750.5 | 7938.74 | vanduo šaltas - V1 2
1365688 | 3 a | 40 | 7938.74 | vanduo šaltas - V1 2
1365704 | 3 a | 120 | 7938.74 | vanduo šaltas - V1 2
1365714 | 3 a | 85 | 9642.3 | vanduo šaltas - V1 2
1365787 | 3 a | 1663.56 | 7966.44 | vanduo šaltas - V1 2
1365823 | 3 a | 740 | 7938.74 | vanduo šaltas - V1 2
1365833 | 3 a | 70 | 7938.74 | vanduo šaltas - V1 2
1365843 | 3 a | 55 | 9642.3 | vanduo šaltas - V1 2
1365880 | 3 a | 1663.56 | 7966.44 | vanduo šaltas - V1 2
1365902 | 3 a | 278 | 7938.74 | vanduo šaltas - V1 2
1365917 | 3 a | 928.499 | 7936.44 | vanduo šaltas - V1 2
1365920 | 3 a | 65 | 9642.3 | vanduo šaltas - V1 2
1366007 | 3 a | 1663.56 | 7966.44 | vanduo šaltas - V1 2
1366031 | 3 a | 358 | 7938.74 | vanduo šaltas - V1 2
1366040 | 3 a | 1816.84 | 7936.44 | vanduo šaltas - V1 2
1366043 | 3 a | 180 | 7938.74 | vanduo šaltas - V1 2
1366051 | 3 a | 60 | 9942.3 | vanduo šaltas - V1 2
1366091 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1366146 | 3 a | 203 | 7938.74 | vanduo šaltas - V1 2
1366155 | 3 a | 63.0163 | 7936.44 | vanduo šaltas - V1 2
1366158 | 3 a | 170 | 7938.74 | vanduo šaltas - V1 2
1366166 | 3 a | 65.3124 | 9942.3 | vanduo šaltas - V1 2
1366195 | 3 a | 1963.56 | 7966.44 | vanduo šaltas - V1 2
1366217 | 3 a | 318 | 7938.74 | vanduo šaltas - V1 2
1366228 | 3 a | 1067.93 | 7936.44 | vanduo šaltas - V1 2
1366231 | 3 a | 60 | 9642.3 | vanduo šaltas - V1 2
1366260 | 3 a | 1663.56 | 7966.44 | vanduo šaltas - V1 2
1366282 | 2 a | 503 | 12384 | vanduo šaltas - V1 2
1366309 | 2 a | 4382.61 | 7980.44 | vanduo šaltas - V1 2
1366336 | 3 a | 2995 | 12387 | vanduo šaltas - V1 2
1366354 | 3 a | 3075 | 12387 | vanduo šaltas - V1 2
1366364 | 3 a | 181.053 | 12387 | vanduo šaltas - V1 2
1366374 | 3 a | 319 | 12387 | vanduo šaltas - V1 2
1366382 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1366439 | 3 a | 2407.05 | 9970 | vanduo šaltas - V1 2
1366464 | 3 a | 263 | 12389.3 | vanduo šaltas - V1 2
1366475 | 3 a | 274.947 | 12387 | vanduo šaltas - V1 2
1366478 | 3 a | 60 | 9942.3 | vanduo šaltas - V1 2
1366522 | 3 a | 2407.05 | 9970 | vanduo šaltas - V1 2
1366556 | 3 a | 4081 | 12389.3 | vanduo šaltas - V1 2
1366572 | 3 a | 121.339 | 12389.3 | vanduo šaltas - V1 2
1366582 | 3 a | 180 | 12389.3 | vanduo šaltas - V1 2
1366590 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1366675 | 3 a | 2407.05 | 9970 | vanduo šaltas - V1 2
1366720 | 3 a | 135 | 12389.3 | vanduo šaltas - V1 2
1366729 | 3 a | 268.661 | 12389.3 | vanduo šaltas - V1 2
1366732 | 3 a | 65 | 9942.3 | vanduo šaltas - V1 2
1366770 | 3 a | 2407.05 | 9970 | vanduo šaltas - V1 2
1366844 | 2 a | 2052.05 | 12651.6 | vanduo šaltas - V1 2
1366857 | 2 a | 4787.3 | 7843.33 | vanduo šaltas - V1 2
1366884 | 3 a | 3648 | 12651.6 | vanduo šaltas - V1 2
1366895 | 2 a | 70.4749 | 12651.6 | vanduo šaltas - V1 2
1366898 | 3 a | 2393.41 | 12651.6 | vanduo šaltas - V1 2
1366906 | 3 a | 381.186 | 12654.6 | vanduo šaltas - V1 2
1366950 | 3 a | 3550.5 | 12654.6 | vanduo šaltas - V1 2
1366968 | 3 a | 6778 | 12654.6 | vanduo šaltas - V1 2
1366984 | 3 a | 978 | 12656.9 | vanduo šaltas - V1 2
1367006 | 3 a | 160 | 9942.3 | vanduo šaltas - V1 2
1367045 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1367115 | 3 a | 252.132 | 12656.9 | vanduo šaltas - V1 2
1367125 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1367154 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1367183 | 3 a | 140 | 12656.9 | vanduo šaltas - V1 2
1367192 | 3 a | 687.868 | 12656.9 | vanduo šaltas - V1 2
1367195 | 3 a | 280 | 12656.9 | vanduo šaltas - V1 2
1367203 | 3 a | 65.2729 | 9942.3 | vanduo šaltas - V1 2
1367233 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1367278 | 3 a | 129.353 | 12654.6 | vanduo šaltas - V1 2
1367289 | 3 a | 1670.5 | 12654.6 | vanduo šaltas - V1 2
1367292 | 3 a | 139 | 12656.9 | vanduo šaltas - V1 2
1367539 | 3 a | 67.5001 | 12656.9 | vanduo šaltas - V1 2
1367559 | 3 a | 80 | 12656.9 | vanduo šaltas - V1 2
1367569 | 3 a | 660 | 12656.9 | vanduo šaltas - V1 2
1367577 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1367650 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1367671 | 3 a | 40 | 12656.9 | vanduo šaltas - V1 2
1367680 | 3 a | 108.059 | 12656.9 | vanduo šaltas - V1 2
1367683 | 3 a | 680 | 12656.9 | vanduo šaltas - V1 2
1367691 | 3 a | 70 | 9942.3 | vanduo šaltas - V1 2
1367721 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1367745 | 3 a | 160 | 12656.9 | vanduo šaltas - V1 2
1367754 | 3 a | 723.441 | 12656.9 | vanduo šaltas - V1 2
1367757 | 3 a | 2880 | 12656.9 | vanduo šaltas - V1 2
1367780 | 3 a | 80 | 12656.9 | vanduo šaltas - V1 2
1367815 | 3 a | 160 | 12656.9 | vanduo šaltas - V1 2
1367823 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1367888 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1367909 | 3 a | 5018 | 12656.9 | vanduo šaltas - V1 2
1367922 | 3 a | 6244.11 | 12654.6 | vanduo šaltas - V1 2
1367925 | 3 a | 460 | 12656.9 | vanduo šaltas - V1 2
1367935 | 3 a | 380 | 12656.9 | vanduo šaltas - V1 2
1367943 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1367984 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1368021 | 3 a | 100 | 12656.9 | vanduo šaltas - V1 2
1368035 | 3 a | 1020 | 12656.9 | vanduo šaltas - V1 2
1368043 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1368095 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1368123 | 3 a | 9 | 12656.9 | vanduo šaltas - V1 2
1368132 | 2 a | 70.4749 | 12651.6 | vanduo šaltas - V1 2
1368149 | 3 a | 30 | 12656.9 | vanduo šaltas - V1 2
1368166 | 3 a | 85 | 9942.3 | vanduo šaltas - V1 2
1368211 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1368346 | 3 a | 940.596 | 12654.6 | vanduo šaltas - V1 2
1368368 | 3 a | 349.818 | 12654.6 | vanduo šaltas - V1 2
1368378 | 3 a | 1419 | 12656.9 | vanduo šaltas - V1 2
1368397 | 3 a | 80 | 9642.3 | vanduo šaltas - V1 2
1368443 | 3 a | 2974.63 | 9670 | vanduo šaltas - V1 2
1368483 | 3 a | 1118 | 12656.9 | vanduo šaltas - V1 2
1368496 | 3 a | 522.229 | 12654.6 | vanduo šaltas - V1 2
1368499 | 3 a | 140 | 9642.3 | vanduo šaltas - V1 2
1368533 | 3 a | 2974.63 | 9670 | vanduo šaltas - V1 2
1368554 | 3 a | 1238 | 12656.9 | vanduo šaltas - V1 2
1368569 | 3 a | 753.383 | 12654.6 | vanduo šaltas - V1 2
1368572 | 3 a | 100 | 9642.3 | vanduo šaltas - V1 2
1368613 | 3 a | 2974.63 | 9670 | vanduo šaltas - V1 2
1368654 | 3 a | 418 | 12656.9 | vanduo šaltas - V1 2
1368665 | 3 a | 130.569 | 12654.6 | vanduo šaltas - V1 2
1368668 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1368713 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1368735 | 3 a | 118 | 12656.9 | vanduo šaltas - V1 2
1368744 | 3 a | 1697.4 | 12654.6 | vanduo šaltas - V1 2
1368747 | 3 a | 300 | 12656.9 | vanduo šaltas - V1 2
1368758 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1368801 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1368824 | 3 a | 387.023 | 12656.9 | vanduo šaltas - V1 2
1368833 | 3 a | 6258.59 | 12651.6 | vanduo šaltas - V1 2
1368836 | 3 a | 160 | 12656.9 | vanduo šaltas - V1 2
1368844 | 3 a | 100 | 9942.3 | vanduo šaltas - V1 2
1368890 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1368923 | 3 a | 220 | 12656.9 | vanduo šaltas - V1 2
1368932 | 3 a | 1406.98 | 12656.9 | vanduo šaltas - V1 2
1368935 | 3 a | 80 | 9942.3 | vanduo šaltas - V1 2
1368990 | 3 a | 2674.63 | 9970 | vanduo šaltas - V1 2
1369044 | 2 a | 3956.33 | 3819 | vanduo šaltas - V1 2
1369089 | 2 a | 2558 | 7796.33 | vanduo šaltas - V1 2
1369127 | 2 a | 36.0982 | 7796.33 | vanduo šaltas - V1 2
1369137 | 2 a | 5955.56 | 7799.33 | vanduo šaltas - V1 2
1369157 | 2 a | 795 | 7799.33 | vanduo šaltas - V1 2
1369169 | 2 a | 962.606 | 7799.33 | vanduo šaltas - V1 2
1369177 | 2 a | 79 | 7799.33 | vanduo šaltas - V1 2
1369187 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1369252 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1369287 | 2 a | 781 | 7801.63 | vanduo šaltas - V1 2
1369297 | 2 a | 820 | 7801.63 | vanduo šaltas - V1 2
1369323 | 2 a | 360 | 7801.63 | vanduo šaltas - V1 2
1369333 | 2 a | 140 | 4842.3 | vanduo šaltas - V1 2
1369375 | 2 a | 2919.33 | 4870 | vanduo šaltas - V1 2
1369437 | 2 a | 278 | 7801.63 | vanduo šaltas - V1 2
1369446 | 2 a | 213.394 | 7799.33 | vanduo šaltas - V1 2
1369449 | 2 a | 31.4118 | 7801.63 | vanduo šaltas - V1 2
1369457 | 2 a | 62.9837 | 5142.3 | vanduo šaltas - V1 2
1369507 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1369606 | 2 a | 55 | 7801.63 | vanduo šaltas - V1 2
1369615 | 2 a | 118.588 | 7801.63 | vanduo šaltas - V1 2
1369618 | 2 a | 50 | 5142.3 | vanduo šaltas - V1 2
1369649 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1369707 | 2 a | 298 | 7801.63 | vanduo šaltas - V1 2
1369716 | 2 a | 1178.28 | 7799.33 | vanduo šaltas - V1 2
1369719 | 2 a | 220 | 7801.63 | vanduo šaltas - V1 2
1369727 | 2 a | 94.7516 | 4842.3 | vanduo šaltas - V1 2
1369769 | 2 a | 2919.33 | 4870 | vanduo šaltas - V1 2
1369790 | 2 a | 20 | 7799.33 | vanduo šaltas - V1 2
1369799 | 2 a | 76.1226 | 7799.33 | vanduo šaltas - V1 2
1369802 | 2 a | 79 | 7801.63 | vanduo šaltas - V1 2
1369831 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1369870 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1370037 | 2 a | 938 | 7801.63 | vanduo šaltas - V1 2
1370046 | 2 a | 1312.07 | 7799.33 | vanduo šaltas - V1 2
1370049 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1370094 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1370192 | 2 a | 718 | 7801.63 | vanduo šaltas - V1 2
1370201 | 2 a | 131.879 | 7799.33 | vanduo šaltas - V1 2
1370204 | 2 a | 115.47 | 7801.63 | vanduo šaltas - V1 2
1370218 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1370262 | 2 a | 2919.33 | 4870 | vanduo šaltas - V1 2
1370295 | 2 a | 738 | 7801.63 | vanduo šaltas - V1 2
1370304 | 2 a | 222.631 | 7799.33 | vanduo šaltas - V1 2
1370307 | 2 a | 97.3823 | 5342.3 | vanduo šaltas - V1 2
1370341 | 2 a | 2419.33 | 5370 | vanduo šaltas - V1 2
1370361 | 2 a | 1318 | 7801.63 | vanduo šaltas - V1 2
1370370 | 2 a | 72.4509 | 7799.33 | vanduo šaltas - V1 2
1370373 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1370404 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1370477 | 2 a | 109 | 7801.63 | vanduo šaltas - V1 2
1370488 | 2 a | 3164.3 | 7796.33 | vanduo šaltas - V1 2
1370491 | 2 a | 130.573 | 5142.3 | vanduo šaltas - V1 2
1370525 | 2 a | 2619.33 | 5170 | vanduo šaltas - V1 2
1370565 | 2 a | 57.4243 | 3772.3 | vanduo šaltas - V1 2
1370621 | 1 a +-152.84 | 1401.71 | 3750 | vanduo šaltas - V1 2
1370741 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1370750 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1370777 | 2 a | 4472.48 | 3770 | vanduo šaltas - V1 2
1370823 | 1 a +-152.84 | 1240.49 | 3750 | vanduo šaltas - V1 2
1370828 | 2 a | 2319 | 3772.3 | vanduo šaltas - V1 2
1370842 | 2 a | 220 | 3772.3 | vanduo šaltas - V1 2
1370852 | 2 a | 180 | 5142.3 | vanduo šaltas - V1 2
1370888 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1370909 | 2 a | 747.32 | 3772.3 | vanduo šaltas - V1 2
1370922 | 2 a | 110.411 | 3770 | vanduo šaltas - V1 2
1370925 | 2 a | 100 | 3772.3 | vanduo šaltas - V1 2
1370935 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1370975 | 2 a | 1030 | 3800 | vanduo šaltas - V1 2
1371003 | 2 a | 100 | 3772.3 | vanduo šaltas - V1 2
1371014 | 2 a | 1630.68 | 3772.3 | vanduo šaltas - V1 2
1371017 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1371067 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1371107 | 2 a | 980 | 3772.3 | vanduo šaltas - V1 2
1371148 | 2 a | 78.2771 | 3759.5 | vanduo šaltas - V1 2
1371155 | 2 a | 100 | 3772.3 | vanduo šaltas - V1 2
1371165 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1371238 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1371260 | 2 a | 1840 | 3772.3 | vanduo šaltas - V1 2
1371281 | 2 a | 78.2771 | 3759.5 | vanduo šaltas - V1 2
1371465 | 2 a | 260 | 3772.3 | vanduo šaltas - V1 2
1371475 | 2 a | 175 | 5142.3 | vanduo šaltas - V1 2
1371506 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1371528 | 2 a | 6558 | 3772.3 | vanduo šaltas - V1 2
1371543 | 2 a | 3255.11 | 3770 | vanduo šaltas - V1 2
1371546 | 2 a | 200 | 3772.3 | vanduo šaltas - V1 2
1371559 | 2 a | 90 | 5142.3 | vanduo šaltas - V1 2
1371596 | 2 a | 1330 | 3800 | vanduo šaltas - V1 2
1371935 | 0 a | 8077.75 | 3450 | vanduo šaltas - V1 2
1371987 | 2 a | 378 | 3531 | vanduo šaltas - V1 2
1371997 | 2 a | 10106.4 | 3930 | vanduo šaltas - V1 2
1372007 | 2 a | 378 | 3531 | vanduo šaltas - V1 2
1372222 | 2 a | 2783.68 | 3952.3 | vanduo šaltas - V1 2
1372233 | 2 a | 1344.03 | 3930 | vanduo šaltas - V1 2
1372238 | 2 a | 110 | 4492.3 | vanduo šaltas - V1 2
1372335 | 2 a | 500 | 3980 | vanduo šaltas - V1 2
1372464 | 2 a | 2115.92 | 3450 | vanduo šaltas - V1 2
1372535 | 2 a | 893.355 | 3470 | vanduo šaltas - V1 2
1372549 | 2 a | 559 | 3472.3 | vanduo šaltas - V1 2
1372602 | 2 a | 140 | 5342.3 | vanduo šaltas - V1 2
1372642 | 2 a | 1830 | 3500 | vanduo šaltas - V1 2
1372762 | 2 a | 578 | 3472.3 | vanduo šaltas - V1 2
1372773 | 2 a | 268.975 | 3470 | vanduo šaltas - V1 2
1372776 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1372804 | 2 a | 1330 | 3500 | vanduo šaltas - V1 2
1372830 | 2 a | 184.635 | 3470 | vanduo šaltas - V1 2
1372845 | 2 a | 502.67 | 3470 | vanduo šaltas - V1 2
1372848 | 2 a | 119 | 3472.3 | vanduo šaltas - V1 2
1372883 | 2 a | 180 | 3472.3 | vanduo šaltas - V1 2
1372891 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1372920 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1372950 | 2 a | 98 | 3472.3 | vanduo šaltas - V1 2
1372961 | 2 a | 1349.89 | 3470 | vanduo šaltas - V1 2
1372964 | 2 a | 180 | 5142.3 | vanduo šaltas - V1 2
1372991 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1373078 | 2 a | 118 | 3472.3 | vanduo šaltas - V1 2
1373087 | 2 a | 1000.48 | 3470 | vanduo šaltas - V1 2
1373090 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1373150 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1373180 | 2 a | 3981.39 | 3467 | vanduo šaltas - V1 2
1373230 | 2 a | 5784.61 | 3467 | vanduo šaltas - V1 2
1373234 | 2 a | 979 | 3472.3 | vanduo šaltas - V1 2
1373252 | 2 a | 100 | 5342.3 | vanduo šaltas - V1 2
1373283 | 2 a | 1830 | 3500 | vanduo šaltas - V1 2
1373304 | 2 a | 2578.4 | 3472.3 | vanduo šaltas - V1 2
1373317 | 2 a | 160.255 | 3470 | vanduo šaltas - V1 2
1373376 | 2 a | 421.723 | 3470 | vanduo šaltas - V1 2
1373380 | 2 a | 760 | 3472.3 | vanduo šaltas - V1 2
1373390 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1373417 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1373439 | 2 a | 998 | 3472.3 | vanduo šaltas - V1 2
1373450 | 2 a | 269.278 | 3470 | vanduo šaltas - V1 2
1373453 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1373531 | 2 a | 1330 | 3500 | vanduo šaltas - V1 2
1373555 | 2 a | 378 | 3472.3 | vanduo šaltas - V1 2
1373566 | 2 a | 422.626 | 3470 | vanduo šaltas - V1 2
1373569 | 2 a | 330 | 3472.3 | vanduo šaltas - V1 2
1373579 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1373611 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1373632 | 2 a | 498 | 3472.3 | vanduo šaltas - V1 2
1373645 | 2 a | 479.312 | 3470 | vanduo šaltas - V1 2
1373648 | 2 a | 155 | 3472.3 | vanduo šaltas - V1 2
1373658 | 2 a | 65 | 5142.3 | vanduo šaltas - V1 2
1373687 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1373724 | 2 a | 389.972 | 3450 | vanduo šaltas - V1 2
1373807 | 2 a | 2885 | 3472.3 | vanduo šaltas - V1 2
1373815 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1373854 | 2 a | 1630 | 3500 | vanduo šaltas - V1 2
1373876 | 2 a | 10420 | 3464 | vanduo šaltas - V1 2
1373891 | 2 a | 220.737 | 3450 | vanduo šaltas - V1 2
1373936 | 2 a | 1563.64 | 3450 | vanduo šaltas - V1 2
1373940 | 2 a | 582 | 3464 | vanduo šaltas - V1 2
1373975 | 2 a | 4162 | 3509 | vanduo šaltas - V1 2
1374016 | 2 a | 201.855 | 7684 | vanduo šaltas - V1 2
1374032 | 2 a | 717.797 | 7684 | vanduo šaltas - V1 2
1374048 | 2 a | 993.665 | 7684 | vanduo šaltas - V1 2
1374598 | 2 a | 12.103 | 7687 | vanduo šaltas - V1 2
1374601 | 1 a +-152.84 | 17.78 | 7648.22 | vanduo šaltas - V1 2
1374796 | 2 a | 252 | 7684 | vanduo šaltas - V1 2
1374805 | 2 a | 136.566 | 7684 | vanduo šaltas - V1 2
1375335 | 2 a | 1330.09 | 7690 | vanduo šaltas - V1 2
1375389 | 2 a | 259.77 | 7684 | vanduo šaltas - V1 2
1375392 | 2 a | 95.0976 | 7692.3 | vanduo šaltas - V1 2
1375436 | 2 a | 188.53 | 7692.3 | vanduo šaltas - V1 2
1375446 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1375487 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1375517 | 2 a | 135 | 7692.3 | vanduo šaltas - V1 2
1375528 | 2 a | 295.402 | 7692.3 | vanduo šaltas - V1 2
1375531 | 2 a | 57.5 | 5142.3 | vanduo šaltas - V1 2
1375576 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1375597 | 2 a | 634.472 | 7692.3 | vanduo šaltas - V1 2
1375606 | 2 a | 156.397 | 7690 | vanduo šaltas - V1 2
1375609 | 2 a | 540 | 7692.3 | vanduo šaltas - V1 2
1375617 | 2 a | 120 | 5342.3 | vanduo šaltas - V1 2
1375661 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1375710 | 2 a | 500 | 7692.3 | vanduo šaltas - V1 2
1375723 | 2 a | 363.528 | 7692.3 | vanduo šaltas - V1 2
1375726 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1375757 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1375779 | 2 a | 133 | 7692.3 | vanduo šaltas - V1 2
1375788 | 2 a | 1016.51 | 7690 | vanduo šaltas - V1 2
1375791 | 2 a | 70 | 5142.3 | vanduo šaltas - V1 2
1375828 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1375849 | 2 a | 195 | 7690 | vanduo šaltas - V1 2
1375858 | 2 a | 95.3359 | 7690 | vanduo šaltas - V1 2
1375861 | 2 a | 98 | 5140 | vanduo šaltas - V1 2
1375886 | 2 a | 2506 | 5172 | vanduo šaltas - V1 2
1375907 | 2 a | 561.267 | 7692.3 | vanduo šaltas - V1 2
1375916 | 2 a | 4196.18 | 7690 | vanduo šaltas - V1 2
1375919 | 2 a | 47.8805 | 7692.3 | vanduo šaltas - V1 2
1375927 | 2 a | 150.028 | 7692.3 | vanduo šaltas - V1 2
1375937 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1375993 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1376066 | 2 a | 320 | 7692.3 | vanduo šaltas - V1 2
1376075 | 2 a | 653.841 | 7692.3 | vanduo šaltas - V1 2
1376078 | 2 a | 75 | 5342.3 | vanduo šaltas - V1 2
1376101 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1376125 | 2 a | 320 | 7692.3 | vanduo šaltas - V1 2
1376134 | 2 a | 602.892 | 7692.3 | vanduo šaltas - V1 2
1376137 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1376165 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1376219 | 2 a | 359.663 | 7692.3 | vanduo šaltas - V1 2
1376240 | 2 a | 496.446 | 7684 | vanduo šaltas - V1 2
1376243 | 2 a | 180 | 7692.3 | vanduo šaltas - V1 2
1376256 | 2 a | 160 | 7692.3 | vanduo šaltas - V1 2
1376264 | 2 a | 120 | 5142.3 | vanduo šaltas - V1 2
1376295 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1376321 | 2 a | 660 | 7692.3 | vanduo šaltas - V1 2
1376330 | 2 a | 1310.34 | 7692.3 | vanduo šaltas - V1 2
1376333 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1376358 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1376379 | 2 a | 290 | 7692.3 | vanduo šaltas - V1 2
1376392 | 2 a | 93.3957 | 7684 | vanduo šaltas - V1 2
1376395 | 2 a | 100 | 4842.3 | vanduo šaltas - V1 2
1376422 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1376444 | 2 a | 250 | 7692.3 | vanduo šaltas - V1 2
1376455 | 2 a | 1230.62 | 7684 | vanduo šaltas - V1 2
1376458 | 2 a | 60 | 5342.3 | vanduo šaltas - V1 2
1376492 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1376515 | 2 a | 223.397 | 7690 | vanduo šaltas - V1 2
1376530 | 2 a | 3125.65 | 7684 | vanduo šaltas - V1 2
1376533 | 2 a | 56 | 7690 | vanduo šaltas - V1 2
1376543 | 2 a | 136 | 7690 | vanduo šaltas - V1 2
1376551 | 2 a | 122.497 | 5140 | vanduo šaltas - V1 2
1376594 | 2 a | 2506 | 5172 | vanduo šaltas - V1 2
1376617 | 2 a | 238 | 7692.3 | vanduo šaltas - V1 2
1376626 | 2 a | 1323.8 | 7690 | vanduo šaltas - V1 2
1376629 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1376659 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1376687 | 2 a | 278 | 7692.3 | vanduo šaltas - V1 2
1376698 | 2 a | 100.804 | 7690 | vanduo šaltas - V1 2
1376701 | 2 a | 64.1897 | 5142.3 | vanduo šaltas - V1 2
1376741 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1376763 | 2 a | 210 | 7692.3 | vanduo šaltas - V1 2
1376772 | 2 a | 299.674 | 7684 | vanduo šaltas - V1 2
1376775 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1376809 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1376831 | 2 a | 190 | 7692.3 | vanduo šaltas - V1 2
1376840 | 2 a | 804.25 | 7684 | vanduo šaltas - V1 2
1376843 | 2 a | 60 | 5342.3 | vanduo šaltas - V1 2
1376877 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1377076 | 2 a | 230 | 7692.3 | vanduo šaltas - V1 2
1377091 | 2 a | 1058.51 | 7684 | vanduo šaltas - V1 2
1377094 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1377117 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1377139 | 2 a | 200 | 7692.3 | vanduo šaltas - V1 2
1377154 | 2 a | 4670.89 | 7684 | vanduo šaltas - V1 2
1377157 | 2 a | 60 | 5342.3 | vanduo šaltas - V1 2
1377195 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1377222 | 2 a | 345.058 | 7690 | vanduo šaltas - V1 2
1377247 | 2 a | 117.976 | 7684 | vanduo šaltas - V1 2
1377250 | 2 a | 1466.14 | 7690 | vanduo šaltas - V1 2
1377260 | 2 a | 1556.19 | 7692.3 | vanduo šaltas - V1 2
1377292 | 2 a | 130 | 7692.3 | vanduo šaltas - V1 2
1377302 | 2 a | 105 | 5142.3 | vanduo šaltas - V1 2
1377329 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1377370 | 2 a | 120 | 7692.3 | vanduo šaltas - V1 2
1377379 | 2 a | 162.81 | 7692.3 | vanduo šaltas - V1 2
1377382 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1377433 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1377454 | 2 a | 158 | 7690 | vanduo šaltas - V1 2
1377465 | 2 a | 203.861 | 7690 | vanduo šaltas - V1 2
1377468 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1377509 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1377535 | 2 a | 213 | 7692.3 | vanduo šaltas - V1 2
1377544 | 2 a | 1322.94 | 7690 | vanduo šaltas - V1 2
1377547 | 2 a | 65 | 5142.3 | vanduo šaltas - V1 2
1377592 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1377613 | 2 a | 1070 | 7690 | vanduo šaltas - V1 2
1377655 | 2 a | 359.34 | 7684 | vanduo šaltas - V1 2
1377658 | 2 a | 578 | 7690 | vanduo šaltas - V1 2
1377666 | 2 a | 2996 | 7690 | vanduo šaltas - V1 2
1377709 | 2 a | 412.962 | 7690 | vanduo šaltas - V1 2
1377721 | 2 a | 159 | 7692.3 | vanduo šaltas - V1 2
1377751 | 2 a | 280 | 7692.3 | vanduo šaltas - V1 2
1377761 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1377791 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1377850 | 2 a | 203 | 7692.3 | vanduo šaltas - V1 2
1377861 | 2 a | 150.885 | 7690 | vanduo šaltas - V1 2
1377864 | 2 a | 75 | 5342.3 | vanduo šaltas - V1 2
1377901 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1377924 | 2 a | 203 | 7692.3 | vanduo šaltas - V1 2
1377933 | 2 a | 790.003 | 7690 | vanduo šaltas - V1 2
1377936 | 2 a | 55 | 4842.3 | vanduo šaltas - V1 2
1377967 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1377997 | 2 a | 102.352 | 7692.3 | vanduo šaltas - V1 2
1378008 | 2 a | 148.188 | 7690 | vanduo šaltas - V1 2
1378011 | 2 a | 305 | 7692.3 | vanduo šaltas - V1 2
1378021 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1378061 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1378190 | 2 a | 215 | 7692.3 | vanduo šaltas - V1 2
1378199 | 2 a | 1285.65 | 7692.3 | vanduo šaltas - V1 2
1378202 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1378232 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1378254 | 2 a | 193 | 7692.3 | vanduo šaltas - V1 2
1378265 | 2 a | 98.1803 | 7690 | vanduo šaltas - V1 2
1378268 | 2 a | 30 | 4842.3 | vanduo šaltas - V1 2
1378295 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1378319 | 2 a | 193 | 7692.3 | vanduo šaltas - V1 2
1378332 | 2 a | 678.657 | 7690 | vanduo šaltas - V1 2
1378335 | 2 a | 55 | 5342.3 | vanduo šaltas - V1 2
1378361 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1378385 | 2 a | 135.183 | 7692.3 | vanduo šaltas - V1 2
1378406 | 2 a | 517.125 | 7690 | vanduo šaltas - V1 2
1378409 | 2 a | 220 | 7692.3 | vanduo šaltas - V1 2
1378448 | 2 a | 77.1488 | 5142.3 | vanduo šaltas - V1 2
1378502 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1378528 | 2 a | 280 | 7692.3 | vanduo šaltas - V1 2
1378537 | 2 a | 3082.82 | 7692.3 | vanduo šaltas - V1 2
1378540 | 2 a | 95 | 5142.3 | vanduo šaltas - V1 2
1378563 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1378584 | 2 a | 270.019 | 7692.3 | vanduo šaltas - V1 2
1378595 | 2 a | 3587.5 | 7684 | vanduo šaltas - V1 2
1378598 | 2 a | 130 | 7692.3 | vanduo šaltas - V1 2
1378608 | 2 a | 120 | 7692.3 | vanduo šaltas - V1 2
1378616 | 2 a | 85 | 5142.3 | vanduo šaltas - V1 2
1378641 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1378664 | 2 a | 110 | 7692.3 | vanduo šaltas - V1 2
1378673 | 2 a | 1454.98 | 7692.3 | vanduo šaltas - V1 2
1378676 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1378706 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1378728 | 2 a | 210 | 7692.3 | vanduo šaltas - V1 2
1378739 | 2 a | 382.902 | 7684 | vanduo šaltas - V1 2
1378742 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1378771 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1378793 | 2 a | 170 | 7692.3 | vanduo šaltas - V1 2
1378804 | 2 a | 718.56 | 7684 | vanduo šaltas - V1 2
1378807 | 2 a | 95 | 5342.3 | vanduo šaltas - V1 2
1378842 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1378868 | 2 a | 142.171 | 7690 | vanduo šaltas - V1 2
1378881 | 2 a | 1109.75 | 7684 | vanduo šaltas - V1 2
1378884 | 2 a | 699.359 | 7690 | vanduo šaltas - V1 2
1378894 | 2 a | 180 | 5142.3 | vanduo šaltas - V1 2
1378936 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1379199 | 2 a | 443 | 7692.3 | vanduo šaltas - V1 2
1379210 | 2 a | 662.268 | 7690 | vanduo šaltas - V1 2
1379213 | 2 a | 50 | 5342.3 | vanduo šaltas - V1 2
1379236 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1379290 | 2 a | 453 | 7692.3 | vanduo šaltas - V1 2
1379299 | 2 a | 73.2267 | 7690 | vanduo šaltas - V1 2
1379302 | 2 a | 60 | 4842.3 | vanduo šaltas - V1 2
1379331 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1379355 | 2 a | 92.1307 | 7692.3 | vanduo šaltas - V1 2
1379368 | 2 a | 487.824 | 7690 | vanduo šaltas - V1 2
1379371 | 2 a | 240 | 7692.3 | vanduo šaltas - V1 2
1379384 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1379428 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1379509 | 2 a | 320 | 7692.3 | vanduo šaltas - V1 2
1379518 | 2 a | 1040.87 | 7692.3 | vanduo šaltas - V1 2
1379521 | 2 a | 60 | 5142.3 | vanduo šaltas - V1 2
1379550 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1379572 | 2 a | 138.56 | 7690 | vanduo šaltas - V1 2
1379585 | 2 a | 372.581 | 7690 | vanduo šaltas - V1 2
1379588 | 2 a | 199 | 7692.3 | vanduo šaltas - V1 2
1379602 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1379639 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1379660 | 2 a | 138 | 7692.3 | vanduo šaltas - V1 2
1379671 | 2 a | 2856.44 | 7690 | vanduo šaltas - V1 2
1379674 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1379714 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1379736 | 2 a | 458 | 7692.3 | vanduo šaltas - V1 2
1379749 | 2 a | 418.884 | 7690 | vanduo šaltas - V1 2
1379752 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1379784 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1379808 | 2 a | 178 | 7692.3 | vanduo šaltas - V1 2
1379817 | 2 a | 4170.83 | 7690 | vanduo šaltas - V1 2
1379820 | 2 a | 240 | 7692.3 | vanduo šaltas - V1 2
1379828 | 2 a | 80 | 5342.3 | vanduo šaltas - V1 2
1379858 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1379881 | 2 a | 190 | 7692.3 | vanduo šaltas - V1 2
1379892 | 2 a | 141.45 | 7684 | vanduo šaltas - V1 2
1379895 | 2 a | 85 | 4842.3 | vanduo šaltas - V1 2
1379924 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1379946 | 2 a | 180 | 7692.3 | vanduo šaltas - V1 2
1379957 | 2 a | 430.929 | 7684 | vanduo šaltas - V1 2
1379960 | 2 a | 65 | 5342.3 | vanduo šaltas - V1 2
1379985 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1380012 | 2 a | 1110.85 | 7692.3 | vanduo šaltas - V1 2
1380021 | 2 a | 884.365 | 7684 | vanduo šaltas - V1 2
1380024 | 2 a | 417.848 | 7692.3 | vanduo šaltas - V1 2
1380034 | 2 a | 100 | 5142.3 | vanduo šaltas - V1 2
1380070 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1380115 | 2 a | 620 | 7692.3 | vanduo šaltas - V1 2
1380124 | 2 a | 169.15 | 7692.3 | vanduo šaltas - V1 2
1380127 | 2 a | 80 | 5142.3 | vanduo šaltas - V1 2
1380167 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1380230 | 2 a | 4987 | 7690 | vanduo šaltas - V1 2
1380249 | 2 a | 4749.78 | 7684 | vanduo šaltas - V1 2
1380252 | 2 a | 497.631 | 7690 | vanduo šaltas - V1 2
1380262 | 2 a | 439 | 7692.3 | vanduo šaltas - V1 2
1380292 | 2 a | 120 | 7692.3 | vanduo šaltas - V1 2
1380302 | 2 a | 600 | 7692.3 | vanduo šaltas - V1 2
1380310 | 2 a | 80 | 5342.3 | vanduo šaltas - V1 2
1380346 | 2 a | 2310 | 5370 | vanduo šaltas - V1 2
1380382 | 2 a | 1098 | 7692.3 | vanduo šaltas - V1 2
1380393 | 2 a | 417.369 | 7690 | vanduo šaltas - V1 2
1380396 | 2 a | 80 | 4842.3 | vanduo šaltas - V1 2
1380426 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1380460 | 2 a | 1823.68 | 7692.3 | vanduo šaltas - V1 2
1380476 | 2 a | 80 | 7692.3 | vanduo šaltas - V1 2
1380486 | 2 a | 140 | 5142.3 | vanduo šaltas - V1 2
1380521 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1380543 | 2 a | 100 | 7692.3 | vanduo šaltas - V1 2
1380552 | 2 a | 417.316 | 7692.3 | vanduo šaltas - V1 2
1380555 | 2 a | 160 | 5142.3 | vanduo šaltas - V1 2
1380583 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1380610 | 2 a | 987.508 | 7690 | vanduo šaltas - V1 2
1380625 | 2 a | 105.495 | 7684 | vanduo šaltas - V1 2
1380628 | 2 a | 599 | 7692.3 | vanduo šaltas - V1 2
1380648 | 2 a | 160 | 4842.3 | vanduo šaltas - V1 2
1380676 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1380698 | 2 a | 1135 | 7690 | vanduo šaltas - V1 2
1380707 | 2 a | 2908.78 | 7690 | vanduo šaltas - V1 2
1380710 | 2 a | 277 | 7690 | vanduo šaltas - V1 2
1380730 | 2 a | 756 | 7690 | vanduo šaltas - V1 2
1380740 | 2 a | 70.0043 | 7692.3 | vanduo šaltas - V1 2
1380748 | 2 a | 30.2384 | 7692.3 | vanduo šaltas - V1 2
1380758 | 2 a | 116.534 | 5142.3 | vanduo šaltas - V1 2
1380787 | 2 a | 2510 | 5170 | vanduo šaltas - V1 2
1380809 | 2 a | 140 | 7692.3 | vanduo šaltas - V1 2
1380818 | 2 a | 57.7651 | 7690 | vanduo šaltas - V1 2
1380821 | 2 a | 1000 | 7692.3 | vanduo šaltas - V1 2
1380829 | 2 a | 220 | 7692.3 | vanduo šaltas - V1 2
1380839 | 2 a | 60 | 4842.3 | vanduo šaltas - V1 2
1380881 | 2 a | 2810 | 4870 | vanduo šaltas - V1 2
1380964 | 2 a | 2938 | 7692.3 | vanduo šaltas - V1 2
1380975 | 2 a | 352.231 | 7690 | vanduo šaltas - V1 2
1380978 | 2 a | 2280 | 7692.3 | vanduo šaltas - V1 2
