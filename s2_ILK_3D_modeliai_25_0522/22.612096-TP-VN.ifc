Properties of the parts of a building model (IFC2X3), part 4 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1180750_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180767_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180794_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180802_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180803_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180802_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194580_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180840_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180882_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180840_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180901_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180909_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180947_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180909_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180910_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180910_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180919_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180955_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180919_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180945_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180947_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180945_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1180955_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1181157_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 36
Port_1181159_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 36
Port_1181157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 36
Port_1181159_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 36
Port_1181206_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1856419_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181271_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181215_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181215_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182333_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181263_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181271_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181263_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181285_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181279_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181285_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181382_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183225_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181496_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181707_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181715_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181707_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181828_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181812_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181828_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182049_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181902_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182049_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1181902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182177_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182177_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1220572_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182333_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197470_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1182356_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182364_3 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182356_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182421_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182364_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183030_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182364_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182365_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182365_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182413_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182421_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182413_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182631_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182631_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182672_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182672_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182727_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182719_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182727_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182719_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183023_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182814_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183023_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1182814_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183029_3 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183029_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1219966_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183029_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183030_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1183216_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183224_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183216_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183305_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183224_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183225_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183296_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183481_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183296_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183401_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183304_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183305_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183304_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184057_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183393_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183401_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183393_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183427_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183467_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194722_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183467_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183481_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183481_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194723_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183775_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183491_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183497_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183491_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183551_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183559_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183549_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183551_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183549_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183575_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 37
Port_1183577_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 37
Port_1183575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 37
Port_1183577_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 37
Port_1183773_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183775_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183773_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183785_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183776_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183776_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183920_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183785_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183910_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183920_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183910_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184008_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183920_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1183921_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184308_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184006_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184008_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184006_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184046_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184056_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184046_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184072_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184056_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184056_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184309_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184066_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194858_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184066_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194859_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184080_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184151_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184080_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184143_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184151_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184166_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 38
Port_1184168_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 38
Port_1184166_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 38
Port_1184168_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 38
Port_1184294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184308_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184383_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184385_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1184383_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
OutPort_1184456_1 | SOURCE
OutPort_1184472_1 | SOURCE
OutPort_1184482_1 | SOURCE
Port_1185427_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186143_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185427_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185439_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186144_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185449_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185455_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185502_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185496_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187614_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185516_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187615_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185516_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185712_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185712_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185753_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185751_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185753_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185751_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1185761_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186144_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186143_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186151_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186151_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186157_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186163_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186163_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186252_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186254_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186252_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186293_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186400_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186408_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186416_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186422_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186416_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186500_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186430_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186506_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186498_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186500_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186498_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186506_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186551_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186561_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186551_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186575_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186562_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186589_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186583_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186589_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186583_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186597_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186630_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186597_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186624_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186630_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186651_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186667_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186679_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186659_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186660_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186659_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186673_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186679_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186755_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186720_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186761_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186753_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186755_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186753_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186761_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186884_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186883_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186893_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186893_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186905_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186899_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186905_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186899_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186956_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186913_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186962_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186913_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186954_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186956_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186954_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1186962_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187114_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187132_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187114_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187144_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187124_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187125_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187124_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187132_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187138_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187144_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187138_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187185_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187226_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187185_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187216_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187218_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187216_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187226_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187248_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187264_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187276_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187256_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187257_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187256_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187264_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187270_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187347_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187345_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187347_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187345_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187353_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187460_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187474_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187474_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187475_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187484_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187531_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187537_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187545_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187585_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187545_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187577_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187577_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187585_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187606_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187614_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187615_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187628_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187666_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187664_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187666_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187672_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187708_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189643_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187708_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187722_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187959_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187722_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187723_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187722_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190022_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187850_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187885_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187958_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187970_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187958_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187959_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1187970_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188064_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188845_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188064_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188140_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188187_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188196_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188408_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188266_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188267_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188266_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188846_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188266_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188707_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188267_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188276_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188282_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188352_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188290_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188360_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188350_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188352_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188350_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188360_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188400_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188408_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188422_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188409_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188706_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188541_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188541_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188619_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188621_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188619_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188627_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188696_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188706_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188696_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188720_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188706_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188707_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188714_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188714_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188728_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188808_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188728_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188800_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188802_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188800_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188829_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189175_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188829_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188861_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188846_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188845_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189473_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188855_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188861_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188855_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188875_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188926_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188928_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1188934_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189176_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189175_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189267_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189176_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189472_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189267_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189275_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189324_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189316_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189318_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189423_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 39
Port_1189423_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 39
Port_1189440_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 40
Port_1189442_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 40
Port_1189440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 40
Port_1189442_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 40
Port_1189448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 42
Port_1189448_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 42
Port_1189464_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189480_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189464_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189492_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189472_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189473_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189472_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189480_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189486_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189492_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189486_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189557_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189533_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189563_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189533_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189555_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189557_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189555_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189563_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189643_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189643_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189651_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189644_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189840_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189738_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189740_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189738_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189748_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189830_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189840_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189939_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189840_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189841_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189841_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190021_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189937_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189939_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1189937_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190013_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190021_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190013_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190105_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190021_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190022_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190031_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190113_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190103_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190105_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190103_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190323_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190331_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190323_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190343_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190331_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190337_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190343_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190357_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190351_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191161_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190351_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190565_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190795_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190563_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190565_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190563_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190605_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190629_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190637_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190687_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190638_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190637_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190935_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190638_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190794_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190645_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190693_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190645_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190685_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190687_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190780_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190794_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190880_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190795_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190878_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190880_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190878_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190922_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190934_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190922_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190950_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190935_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190934_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191162_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190944_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190950_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191033_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190958_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191041_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191031_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191033_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191041_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191149_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191161_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191213_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191161_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191185_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191219_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191185_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191211_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191213_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191211_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191219_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1191312_0 | SOURCEANDSINK | K1 2
Port_1191320_3 | SOURCEANDSINK | K1 2
Port_1191312_1 | SOURCEANDSINK | K1 2
Port_1191336_2 | SOURCEANDSINK | K1 2
Port_1191320_2 | SOURCEANDSINK | K1 2
Port_1191321_1 | SOURCEANDSINK | K1 2
Port_1191330_0 | SOURCEANDSINK | K1 2
Port_1191336_1 | SOURCEANDSINK | K1 2
Port_1191330_1 | SOURCEANDSINK | K1 2
Port_1191381_2 | SOURCEANDSINK | K1 2
Port_1191375_0 | SOURCEANDSINK | K1 2
Port_1191497_2 | SOURCEANDSINK | K1 2
Port_1191375_1 | SOURCEANDSINK | K1 2
Port_1191450_1 | SOURCEANDSINK | K1 2
Port_1191381_1 | SOURCEANDSINK | K1 2
Port_1191498_0 | SOURCEANDSINK | K1 2
Port_1191387_0 | SOURCEANDSINK | K1 2
Port_1191456_2 | SOURCEANDSINK | K1 2
Port_1191387_1 | SOURCEANDSINK | K1 2
Port_1191448_0 | SOURCEANDSINK | K1 2
Port_1191450_2 | SOURCEANDSINK | K1 2
Port_1191448_1 | SOURCEANDSINK | K1 2
Port_1191456_1 | SOURCEANDSINK | K1 2
Port_1191489_0 | SOURCEANDSINK | K1 2
Port_1191497_3 | SOURCEANDSINK | K1 2
Port_1191489_1 | SOURCEANDSINK | K1 2
Port_1191511_1 | SOURCEANDSINK | K1 2
Port_1191497_1 | SOURCEANDSINK | K1 2
Port_1191498_1 | SOURCEANDSINK | K1 2
Port_1191505_0 | SOURCEANDSINK | K1 2
Port_1191511_2 | SOURCEANDSINK | K1 2
Port_1191505_1 | SOURCEANDSINK | K1 2
Port_1191553_1 | SOURCEANDSINK | K1 2
Port_1191519_0 | SOURCEANDSINK | K1 2
Port_1191559_2 | SOURCEANDSINK | K1 2
Port_1191519_1 | SOURCEANDSINK | K1 2
Port_1191551_0 | SOURCEANDSINK | K1 2
Port_1191553_2 | SOURCEANDSINK | K1 2
Port_1191551_1 | SOURCEANDSINK | K1 2
Port_1191559_1 | SOURCEANDSINK | K1 2
Port_1191676_0 | SOURCEANDSINK | K1 2
Port_1191686_3 | SOURCEANDSINK | K1 2
Port_1191676_1 | SOURCEANDSINK | K1 2
Port_1191700_2 | SOURCEANDSINK | K1 2
Port_1191686_1 | SOURCEANDSINK | K1 2
Port_1191687_1 | SOURCEANDSINK | K1 2
Port_1191694_0 | SOURCEANDSINK | K1 2
Port_1191700_1 | SOURCEANDSINK | K1 2
Port_1191694_1 | SOURCEANDSINK | K1 2
Port_1191740_1 | SOURCEANDSINK | K1 2
Port_1191708_0 | SOURCEANDSINK | K1 2
Port_1191746_2 | SOURCEANDSINK | K1 2
Port_1191708_1 | SOURCEANDSINK | K1 2
Port_1191738_0 | SOURCEANDSINK | K1 2
Port_1191740_2 | SOURCEANDSINK | K1 2
Port_1191738_1 | SOURCEANDSINK | K1 2
Port_1191746_1 | SOURCEANDSINK | K1 2
Port_1191784_0 | SOURCEANDSINK | K1 2
Port_1192005_2 | SOURCEANDSINK | K1 2
Port_1191784_1 | SOURCEANDSINK | K1 2
Port_1191822_2 | SOURCEANDSINK | K1 2
Port_1191806_1 | SOURCEANDSINK | K1 2
Port_1191807_1 | SOURCEANDSINK | K1 2
Port_1191806_3 | SOURCEANDSINK | K1 2
Port_1192006_0 | SOURCEANDSINK | K1 2
Port_1191816_0 | SOURCEANDSINK | K1 2
Port_1191822_1 | SOURCEANDSINK | K1 2
Port_1191816_1 | SOURCEANDSINK | K1 2
Port_1191957_1 | SOURCEANDSINK | K1 2
Port_1191946_0 | SOURCEANDSINK | K1 2
Port_1191965_2 | SOURCEANDSINK | K1 2
Port_1191946_1 | SOURCEANDSINK | K1 2
Port_1191955_0 | SOURCEANDSINK | K1 2
Port_1191957_2 | SOURCEANDSINK | K1 2
Port_1191955_1 | SOURCEANDSINK | K1 2
Port_1191965_1 | SOURCEANDSINK | K1 2
Port_1191997_0 | SOURCEANDSINK | K1 2
Port_1192005_3 | SOURCEANDSINK | K1 2
Port_1191997_1 | SOURCEANDSINK | K1 2
Port_1192073_1 | SOURCEANDSINK | K1 2
Port_1192005_1 | SOURCEANDSINK | K1 2
Port_1192006_1 | SOURCEANDSINK | K1 2
Port_1192062_0 | SOURCEANDSINK | K1 2
Port_1192081_2 | SOURCEANDSINK | K1 2
Port_1192062_1 | SOURCEANDSINK | K1 2
Port_1192071_0 | SOURCEANDSINK | K1 2
Port_1192073_2 | SOURCEANDSINK | K1 2
Port_1192071_1 | SOURCEANDSINK | K1 2
Port_1192081_1 | SOURCEANDSINK | K1 2
Port_1192102_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192110_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192102_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192110_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192111_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192118_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192157_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192118_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192169_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192163_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192264_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192163_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192169_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192400_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192175_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192181_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192226_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192189_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192232_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192189_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192224_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192226_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192253_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192296_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192262_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192264_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192296_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192264_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192265_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192265_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192399_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192389_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192399_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192389_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192399_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192452_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192444_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192446_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192444_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192452_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192473_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192489_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192473_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192560_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192481_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192481_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192489_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192599_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192558_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192560_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192558_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192680_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192688_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192680_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192688_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192764_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192766_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192764_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192772_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192772_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1192835_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192879_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193081_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192847_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192847_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192879_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192885_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193120_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1192885_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193079_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193081_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193213_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193223_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193213_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193239_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193223_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193233_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193239_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193286_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193247_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193286_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193247_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193778_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193292_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193396_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193310_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193304_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193310_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193358_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193318_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193364_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193356_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193358_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193364_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193385_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193404_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193394_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193396_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193404_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193396_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193811_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193397_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193810_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193397_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193810_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193810_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193816_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193859_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193851_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193853_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193851_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193859_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193880_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193890_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193880_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193904_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193891_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193898_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193904_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193898_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193987_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193993_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193985_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193987_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1193993_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1194061_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194061_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194071_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194071_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194116_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194110_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194116_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194110_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194130_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194130_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194138_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194138_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194212_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194214_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194212_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194220_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194398_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194410_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194398_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194486_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194484_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194486_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194492_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194492_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1194569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194579_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194595_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194580_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194589_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194595_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194589_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194679_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194677_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194679_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194677_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194685_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1194712_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194722_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194712_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194722_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194723_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194730_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194736_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194730_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194744_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194750_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194744_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194815_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194813_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194815_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194813_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194821_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194858_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194930_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194858_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194859_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194928_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194930_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1194936_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1195069_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195168_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195069_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195095_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195080_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195079_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195169_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195089_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195095_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195089_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195133_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195103_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195139_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195103_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195131_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195133_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195139_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195160_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195292_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195160_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
