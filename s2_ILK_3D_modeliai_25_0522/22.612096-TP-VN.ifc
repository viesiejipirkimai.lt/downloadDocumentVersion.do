Properties of the parts of a building model (IFC2X3), part 27 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1441540_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441548_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441540_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441558_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441550_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441558_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441550_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441604_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441560_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441608_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441560_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441602_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441604_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441602_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441608_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441624_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441632_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441647_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441632_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441633_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441636_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441647_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441636_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441686_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441649_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441690_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441649_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441684_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441686_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441684_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441690_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441709_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441719_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441719_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441720_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441723_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441788_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441723_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441761_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441763_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441761_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441767_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441788_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441797_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441805_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441797_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441855_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441805_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441811_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441859_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441811_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441853_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441855_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441853_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441859_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441883_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441891_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441883_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441936_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441891_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441892_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441895_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441938_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441895_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441934_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441936_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441934_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441938_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442028_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485331_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442028_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442088_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485356_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442088_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442112_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442096_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443809_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442096_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442097_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442096_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442730_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442100_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442112_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442100_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442153_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442167_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442167_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442168_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442167_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442205_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442168_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443773_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442176_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443462_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442176_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442266_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442204_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442205_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442204_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485332_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442204_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443463_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442254_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442528_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442254_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442280_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442266_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442838_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442268_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442278_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442290_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442278_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442280_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442284_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442290_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442306_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442292_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442306_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442292_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442314_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442308_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442314_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442308_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442316_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442369_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442316_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442365_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442434_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442444_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442434_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442500_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442444_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442529_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442444_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442445_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443339_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442448_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442504_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442448_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442496_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442498_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442496_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442504_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442498_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442500_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442520_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442528_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442520_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442538_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442528_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442529_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442532_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442532_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442550_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442540_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442550_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442540_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442560_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442552_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442560_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442552_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442587_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442562_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442587_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442562_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442595_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442589_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442595_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442589_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442597_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 6
Port_1442597_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 6
Port_1442625_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442627_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442709_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442729_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442709_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442769_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442729_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442730_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442729_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485357_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442751_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442769_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442751_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442779_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442771_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442779_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442771_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442829_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442837_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442829_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442837_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442944_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442837_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442838_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442841_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442850_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442841_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442913_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442852_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442917_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442852_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442911_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442913_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442911_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442917_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442935_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442943_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442935_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442959_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443105_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442943_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442944_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442947_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442959_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442947_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443033_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442961_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443037_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442961_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443031_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443033_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443031_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443037_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443096_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443104_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443096_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443171_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443104_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443340_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443104_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443105_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443108_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443175_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443108_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443169_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443171_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443169_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443175_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443331_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443339_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443331_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443349_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443339_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443343_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443349_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443343_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443381_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443351_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443385_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443351_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443379_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443381_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443379_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443385_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443452_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443462_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443452_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443482_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443462_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443463_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443466_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443482_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443466_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443502_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443484_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444602_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443484_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443512_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443502_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444603_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443504_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443512_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443504_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443533_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443514_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443620_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443514_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443547_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443533_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443535_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443535_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443621_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443539_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443547_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443539_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443592_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443549_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443596_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443549_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443590_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443592_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443590_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443596_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443612_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443620_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443612_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443620_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443621_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443624_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443701_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443695_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443697_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443695_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443765_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483397_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1494372_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443773_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443773_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443858_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443800_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1494760_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443800_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443818_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443808_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445048_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443808_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443809_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443808_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1470808_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443812_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443818_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443812_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1443843_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444494_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443843_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443913_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443857_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443858_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443857_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1469924_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443857_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444495_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443901_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444072_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443901_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443933_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443911_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443913_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443911_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444073_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443917_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443933_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443917_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443941_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443935_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443941_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443935_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443951_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443943_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443951_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443959_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443953_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443959_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443953_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443973_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443961_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443973_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443961_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443997_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443975_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443999_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443975_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444042_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443999_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444003_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444046_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444003_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444040_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444042_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444040_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444046_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444064_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444072_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444064_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444082_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444072_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444073_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444076_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444082_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444076_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444095_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444084_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444097_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444084_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444122_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444095_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444097_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444101_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444310_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444101_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444135_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444122_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444394_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444124_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444231_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444124_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444146_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444135_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444232_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444137_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444146_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444137_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444192_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444148_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444196_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444148_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444190_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444192_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444190_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444223_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444231_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444223_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444231_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444232_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444235_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444243_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444235_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444280_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444245_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444282_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444245_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444278_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444280_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444278_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444282_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444302_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444310_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444302_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444310_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444311_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444311_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444393_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444314_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444369_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444314_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444365_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444385_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444393_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444385_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444403_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444393_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444394_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444397_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444403_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444397_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444435_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444405_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444437_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444405_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444433_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444435_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444437_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444468_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444494_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444468_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444494_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444506_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444863_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444508_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444514_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444524_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444514_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444818_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444516_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444524_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444516_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444566_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444526_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444570_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444526_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444564_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444566_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444564_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444570_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444592_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444602_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444592_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444612_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444602_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444603_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444606_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444612_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444606_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444622_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444622_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444696_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444624_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444700_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444694_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444696_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444694_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444700_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444716_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444728_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444716_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444775_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444728_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444732_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444798_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444732_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444773_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444775_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444773_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444777_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444777_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444798_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444807_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444862_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444807_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444905_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444818_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444862_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444862_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444863_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444897_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444905_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444897_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444947_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444951_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444945_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444947_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444945_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1444951_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445001_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445009_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445001_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471257_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445009_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445039_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445047_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445039_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472389_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445047_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445048_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445075_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445151_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445124_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445151_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445124_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445151_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446084_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445162_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445162_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445634_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445624_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445791_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445674_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445632_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445634_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445632_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445982_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445638_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445674_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445638_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445686_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445678_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445686_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445678_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445702_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445688_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445702_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445688_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445754_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445704_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445758_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445704_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445752_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445754_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445752_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445775_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445775_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445812_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445791_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445792_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445791_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445899_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445792_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445981_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445795_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445812_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445795_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445862_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445814_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445866_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445860_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445862_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445860_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445866_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445888_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445898_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445888_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445945_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445898_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445899_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445902_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445949_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445902_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445943_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445945_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445949_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445971_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445981_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445971_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445981_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445982_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445985_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446060_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445985_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446044_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445997_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446060_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445999_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446048_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1445999_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446042_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446044_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446042_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446048_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446075_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446083_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446093_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446083_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446084_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446087_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446221_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446087_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446103_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446093_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446222_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446095_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446103_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446095_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446190_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446179_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446194_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446179_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446188_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446190_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446188_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446213_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446221_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446231_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446221_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446222_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446225_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446231_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446225_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446241_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446233_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446241_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446233_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446249_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446243_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446249_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446297_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446251_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446299_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446251_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446295_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446297_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446295_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446299_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446343_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446343_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446377_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446365_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446484_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446369_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446377_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446449_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446379_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446453_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446379_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446447_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446449_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446447_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446453_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446475_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446483_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446475_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446542_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446483_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446484_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446487_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446546_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446540_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446542_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446540_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446546_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 7
Port_1446566_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446574_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446566_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446584_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446574_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446575_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446578_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446888_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446578_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446615_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446584_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446889_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446607_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446615_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446607_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446617_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446623_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446617_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446654_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446623_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446625_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446646_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448156_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446646_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447610_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446654_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446999_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446880_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446888_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446880_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446956_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446888_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446889_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446892_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446960_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446892_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446954_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446956_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446954_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446960_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446978_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446998_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446978_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447010_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446998_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447108_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446998_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446999_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447002_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447002_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447012_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447012_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447059_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447061_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447059_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447083_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447231_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447119_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447107_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447413_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447107_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447108_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447107_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447309_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447119_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447121_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447121_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447125_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447125_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447201_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447137_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1853395_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447137_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447199_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447201_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447199_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1853395_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447223_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447231_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447223_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447280_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447231_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447232_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447232_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447308_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447235_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447284_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447235_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447276_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447278_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447276_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447278_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447280_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447300_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447308_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447300_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447361_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447308_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447309_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447365_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447357_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447359_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447359_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447361_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447394_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447412_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447394_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447459_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447412_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448157_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447412_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447413_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447416_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447463_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447416_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447457_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447459_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447457_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447463_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447487_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447497_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447487_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447510_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447497_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447498_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447501_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447510_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447501_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447512_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447520_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447512_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447568_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447522_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447572_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447522_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447566_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447568_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447566_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447572_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447596_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447612_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447596_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
