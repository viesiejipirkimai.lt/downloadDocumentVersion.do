Properties of the parts of a building model (IFC2X3), part 10 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1269263_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269262_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269301_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269298_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269300_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269298_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269301_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269491_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269308_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269491_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269499_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269543_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269499_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269535_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269537_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269535_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269543_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269593_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270062_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269593_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269705_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269608_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269607_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269790_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269697_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269705_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269697_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269751_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269789_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269751_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269789_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1269789_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270063_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
OutPort_1269982_1 | SOURCE
Port_1270002_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270062_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270078_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270063_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270072_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270092_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270086_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270092_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270086_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270137_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270100_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270145_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270100_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270135_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270137_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270135_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270145_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270221_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270237_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270221_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270322_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270237_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270986_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270237_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270238_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270320_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270322_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270320_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
OutPort_1270416_1 | SOURCE
Port_1270436_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270448_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270436_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270688_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270448_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270449_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270454_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270502_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270454_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270494_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270496_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270494_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270547_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270559_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273449_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270559_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270560_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270560_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270687_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270575_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270641_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270583_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270649_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270583_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270639_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270641_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270639_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270649_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270671_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270687_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270671_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270687_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270688_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270740_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270742_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270748_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270971_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270985_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271001_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270985_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270986_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270995_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271001_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1270995_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271041_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271009_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271047_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271009_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271039_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271041_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271039_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271047_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271156_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272557_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271156_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272098_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271166_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271166_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274100_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271167_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271627_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271915_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271825_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271827_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271864_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271897_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271915_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271897_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271979_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271915_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272133_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271916_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271916_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272098_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271971_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271979_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1271971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272119_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272138_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272130_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272132_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272130_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272138_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272132_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272233_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272132_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272133_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272220_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272943_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272449_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272232_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272232_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272944_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272273_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272275_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272273_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272314_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272314_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272355_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 73
Port_1272355_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 73
Port_1272435_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272454_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272435_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272446_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272448_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272454_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272448_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272547_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272557_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272573_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272557_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272558_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272558_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274099_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272567_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273196_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272877_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272573_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273197_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272877_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
OutPort_1272899_1 | SOURCE
OutPort_1272913_1 | SOURCE
Port_1272935_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272943_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272935_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272981_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272975_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272975_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272995_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272989_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272995_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1272989_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273042_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273040_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273042_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273040_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273050_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273050_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273151_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 74
Port_1273151_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 74
Port_1273184_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273196_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273184_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273212_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273206_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273212_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273226_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273220_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273226_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273277_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273275_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273277_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273285_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273285_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273333_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273349_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273333_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273349_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273903_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273349_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273350_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273350_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273355_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273417_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273355_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273409_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273438_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273727_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273438_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273448_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273448_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273458_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273728_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273464_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273470_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273464_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273566_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273511_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273572_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273511_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273564_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273566_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273564_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273572_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273717_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273727_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273717_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273859_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273728_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273759_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273867_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273759_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273857_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273859_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273857_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273888_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273902_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273888_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274019_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275045_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273902_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1273903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274017_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274019_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274017_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
OutPort_1274063_1 | SOURCE
Port_1274085_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274099_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274258_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274099_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274100_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274256_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274258_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274256_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
OutPort_1274302_1 | SOURCE
Port_1274332_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274342_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274342_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274343_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274371_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274379_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274391_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274385_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274391_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274790_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274595_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274595_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274930_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274790_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275015_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274915_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274936_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274915_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274928_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274930_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1274936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275044_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275045_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275044_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275140_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275050_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275139_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275050_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275104_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275131_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275139_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275217_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275139_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275209_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275217_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275209_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275223_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275402_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275223_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275323_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275229_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275315_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275323_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275329_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275335_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275329_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275386_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275402_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275386_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275402_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275403_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275620_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275410_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275484_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275608_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275620_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275608_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275667_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275628_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275681_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275675_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275681_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275675_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275695_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275734_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275703_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275742_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275732_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275734_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 72
Port_1275966_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1275999_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1275966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276076_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1275999_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276068_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276076_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276068_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276138_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276140_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276138_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276735_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276727_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276735_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276749_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276749_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1412462_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276755_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1411742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1276755_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1415033_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277095_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278398_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277095_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277999_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277103_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277103_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277104_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277103_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283853_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277104_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277180_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277172_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277620_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277172_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277571_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277180_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277180_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277412_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277181_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277401_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277411_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277401_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277463_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277412_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277882_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277461_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277463_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277571_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277594_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277620_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277881_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277693_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277695_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277703_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277881_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277897_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277881_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277891_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283672_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277891_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277897_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283673_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277905_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277946_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277905_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277938_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277938_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277946_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277991_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277999_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1277991_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278026_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278044_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278181_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278124_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278055_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278054_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278839_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278054_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278758_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278055_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279368_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278122_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278124_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278122_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278165_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278181_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278165_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278197_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278757_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278191_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278277_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278275_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278277_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
OutPort_1278324_1 | SOURCE
OutPort_1278338_1 | SOURCE
OutPort_1278366_1 | SOURCE
Port_1278388_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278398_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278388_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278414_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278398_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278399_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278399_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279174_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278408_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278538_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278414_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278539_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278468_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278470_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278476_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278499_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 76
Port_1278499_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 76
Port_1278525_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278546_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278525_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278536_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278538_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278536_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278539_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 77
Port_1278657_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 77
Port_1278743_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278757_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278743_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278757_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278758_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278830_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278838_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278838_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278839_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1278838_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279175_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279166_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279174_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279166_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279297_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279174_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279289_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279297_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279356_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279368_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279384_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279368_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283852_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279378_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279384_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279378_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279392_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279452_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279392_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279444_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279446_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279444_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279452_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1279645_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279657_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279645_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279667_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279673_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279747_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279681_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279753_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279681_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279745_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279747_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279745_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1279753_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1281143_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282142_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281150_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281559_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281150_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281250_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281242_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281250_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281242_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282276_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281362_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282276_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281362_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282282_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282134_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282142_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282134_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282239_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282229_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282239_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282229_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282282_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1282321_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415256_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282321_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415105_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282442_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282520_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282442_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282464_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282453_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282453_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282520_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282458_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282464_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282458_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282490_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282470_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282484_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282470_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282490_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282484_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282552_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282484_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282536_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282543_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282700_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282543_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282563_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282552_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282700_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282563_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282967_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282569_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282673_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282569_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282679_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282673_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415257_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282673_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282679_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282958_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283277_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282958_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283227_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282966_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282966_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282967_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1282966_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283390_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283219_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283227_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283219_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283243_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283267_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284140_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283267_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283297_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283277_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283278_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283277_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283285_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283278_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283389_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283285_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284570_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283291_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283297_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283291_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283350_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283313_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283356_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283313_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283348_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283350_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283348_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283356_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283377_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283389_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283377_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283403_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283389_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283390_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283403_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283571_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283431_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283570_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283431_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283504_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283502_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283504_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283502_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283551_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283560_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284815_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283560_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283618_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283570_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283571_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283570_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285450_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283616_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283618_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283616_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283655_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1283664_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283680_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283692_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283672_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283680_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283808_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283769_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283692_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283809_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283733_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283775_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283767_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283769_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283767_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283797_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283816_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283797_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283806_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283808_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283806_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283809_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283844_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283860_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283872_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283852_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283860_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283866_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283872_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283866_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283888_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284085_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1283888_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284077_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284079_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284077_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1284132_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284140_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284132_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284156_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284140_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284141_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284141_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284569_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284150_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284376_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284150_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284170_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284156_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284377_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284164_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284170_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284164_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284239_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284211_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284278_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284211_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284237_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284239_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284237_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284278_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284365_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284384_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284365_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284374_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284376_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284374_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284384_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284376_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284377_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284553_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284569_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284553_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284675_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284569_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284570_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284673_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284675_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284673_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
OutPort_1284718_1 | SOURCE
OutPort_1284745_1 | SOURCE
OutPort_1284755_1 | SOURCE
OutPort_1284771_1 | SOURCE
Port_1284781_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1287004_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1284803_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284815_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284803_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284831_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284815_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284816_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284816_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285255_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284825_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284831_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284825_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284883_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284881_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284883_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284881_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284891_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1284891_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285239_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285255_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285239_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285292_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285255_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285256_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285256_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285409_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285290_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285292_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285290_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285398_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285417_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285398_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285407_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285409_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285407_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285417_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285409_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285410_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285410_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285573_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285438_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285457_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285438_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285447_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285449_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285447_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285457_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285449_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285450_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285449_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285574_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285573_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285574_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285573_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285831_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285635_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285830_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285635_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285679_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285641_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285718_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285641_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285677_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285679_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285677_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285718_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285799_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 2
Port_1285799_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 2
Port_1285819_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285862_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285819_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285828_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285830_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285828_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285862_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285830_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285831_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1285887_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 3
Port_1285887_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 3
Port_1286019_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286085_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286019_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286039_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286028_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286028_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286085_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286033_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286039_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286033_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286065_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1286045_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
