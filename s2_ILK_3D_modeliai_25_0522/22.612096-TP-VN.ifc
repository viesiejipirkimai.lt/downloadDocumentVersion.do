Properties of the parts of a building model (IFC2X3), part 12 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1301691_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301384_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301393_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301399_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301393_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301456_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301448_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301450_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301456_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301477_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301487_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301477_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301501_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301783_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301540_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301509_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301548_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301509_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301538_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301540_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301548_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301678_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301725_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301689_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301691_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301689_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301725_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301691_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301692_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1301751_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 82
Port_1301751_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 82
Port_1301783_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301899_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301901_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301899_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301947_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301939_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301947_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301939_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302105_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301972_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302064_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1301972_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302105_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302028_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302030_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302028_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302064_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1302614_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302624_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302625_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302634_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302673_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302665_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302667_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302665_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
OutPort_1302703_1 | SOURCE
Port_1302723_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302733_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302723_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302749_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302734_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302743_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302749_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302743_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302757_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302796_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302757_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302788_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302790_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302788_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302853_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302854_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302853_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303113_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302970_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303112_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302970_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302986_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302980_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302986_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1302980_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303066_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303027_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303072_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303027_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303064_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303066_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303064_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303104_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303112_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303104_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303171_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303112_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303169_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303171_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303169_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303177_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303177_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 81
Port_1303770_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303794_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303770_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303808_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303820_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303814_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303820_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303814_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303828_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303845_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303828_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303978_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303978_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305597_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304147_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304157_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304147_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304282_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304157_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304158_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304236_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304236_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304320_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304288_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304320_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304288_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304738_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304719_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304744_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304719_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304736_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304738_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304744_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304770_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304846_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304770_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305349_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304838_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305196_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304838_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304926_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304846_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305197_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305028_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 83
Port_1305030_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 83
Port_1305028_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 83
Port_1305038_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 83
Port_1305030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 83
Port_1305038_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 83
Port_1305156_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305196_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305156_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305210_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305204_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305210_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305204_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305218_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305224_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305232_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305317_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305232_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305307_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305309_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305307_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305341_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305349_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305341_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305534_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305546_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305534_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305554_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305606_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305554_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305596_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1411619_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305596_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305597_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305596_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1305754_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306442_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305754_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305762_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305763_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305762_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307367_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305763_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305819_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305900_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305819_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1305929_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306426_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306604_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306426_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306482_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306442_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306443_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306442_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306605_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306443_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306889_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306476_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306490_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306575_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306565_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306567_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306565_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306596_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306604_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306596_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306717_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306604_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306605_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306612_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306725_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306612_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306715_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306717_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306725_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306843_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306889_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306843_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306889_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1306890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307271_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307003_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307005_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307003_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307259_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307271_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307271_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307272_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307272_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307366_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307316_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307318_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307358_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307374_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307358_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307366_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307367_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307366_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307374_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307495_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307497_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
Port_1307495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 71
OutPort_1307638_1 | SOURCE
OutPort_1307656_1 | SOURCE
OutPort_1307668_1 | SOURCE
Port_1307683_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307683_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1419153_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307808_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308942_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307861_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307816_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307817_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307816_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308166_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307817_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307849_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307861_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307849_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307873_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307867_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307997_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307955_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307873_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308063_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307942_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307961_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307942_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307953_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307955_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307953_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307961_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307982_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308005_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307982_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307995_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307997_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307995_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307997_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307998_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1307998_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308062_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308049_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308070_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308049_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308060_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308062_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308070_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308063_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308155_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309474_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308155_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308185_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308165_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308166_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308165_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308943_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308165_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308173_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308173_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308517_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308179_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308185_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308179_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308235_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308201_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308241_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308233_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308235_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308241_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308429_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308437_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308429_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308478_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308437_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308438_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308437_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309475_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308438_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308516_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308484_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308476_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308478_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308506_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308516_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308506_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308586_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308516_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308517_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308524_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308592_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308524_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308584_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308586_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308584_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308592_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308930_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309065_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308930_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308942_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308942_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309242_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308952_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310973_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308952_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309015_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1308958_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310974_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309013_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309015_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309013_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309055_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309065_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309055_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309189_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309065_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309066_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309066_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309241_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309187_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309189_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309187_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309229_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309241_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309321_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309241_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309242_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309319_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309321_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309319_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
OutPort_1309416_1 | SOURCE
OutPort_1309428_1 | SOURCE
OutPort_1309440_1 | SOURCE
Port_1309474_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309475_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309474_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310502_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309498_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309701_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309498_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309576_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309570_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309576_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309570_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309584_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309665_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309584_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309655_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309657_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309665_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309687_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309715_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309687_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309823_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309697_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309701_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309697_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309709_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309698_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309709_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309698_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309701_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309702_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309702_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309898_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309721_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309831_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309721_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309821_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309823_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309831_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309898_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309898_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309899_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309899_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310146_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309906_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309951_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309941_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309943_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309941_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309951_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309994_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310002_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1309994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310016_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310003_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310002_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310147_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310003_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310501_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310010_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310010_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310087_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310024_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310093_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310024_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310085_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310087_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310093_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310138_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310154_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310138_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310166_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310146_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310147_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310146_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310166_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310360_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310312_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310366_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310312_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310358_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310360_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310358_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310366_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310493_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310501_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310493_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310515_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310509_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310692_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310509_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310562_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310515_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310841_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310556_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310562_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310556_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310654_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310570_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310662_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310570_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310652_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310654_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310652_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310662_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310684_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310692_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310692_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310693_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310840_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310724_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310810_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310724_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310800_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310802_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310800_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310810_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310832_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310840_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310832_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310932_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310840_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310841_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310930_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310932_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310930_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310961_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310973_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310961_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310989_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310973_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310974_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310983_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310989_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310983_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311059_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310997_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311065_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1310997_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311057_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311059_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311065_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1311307_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311315_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311307_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311337_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311430_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311343_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311429_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311343_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1419052_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311429_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311429_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312414_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311642_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312048_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311642_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311672_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311680_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311763_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311680_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311755_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311757_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311755_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311763_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311757_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312049_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312048_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312049_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312413_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312056_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312056_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312136_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312136_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 85
Port_1312233_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 85
Port_1312413_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312414_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312413_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312456_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312458_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312456_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312464_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312464_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312694_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313200_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312694_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313002_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312702_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312702_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313201_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312994_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313152_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313153_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313010_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313054_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313010_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313046_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313048_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313046_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313160_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313150_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313152_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313150_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313160_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313152_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313153_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313184_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313200_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313184_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313200_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313268_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313276_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1313315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 86
Port_1313315_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 86
Port_1313366_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313370_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313366_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313368_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313388_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313368_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313378_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313370_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313477_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313371_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1419240_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313376_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313378_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313376_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313384_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313386_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313420_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313386_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313396_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313388_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313389_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313388_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313421_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313389_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313444_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313394_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313396_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313406_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313402_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313412_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313402_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313404_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313406_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313404_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313412_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313418_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313420_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313418_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313420_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313421_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313426_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313436_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313426_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313428_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313430_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313428_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313436_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313442_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313444_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313442_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313452_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313444_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313445_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313445_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313460_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313450_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313452_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313458_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313460_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313461_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313476_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313466_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313468_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313466_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313474_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313482_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313474_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313477_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313476_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313488_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1313488_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
OutPort_1313496_1 | SOURCE
OutPort_1313499_1 | SOURCE
OutPort_1313502_1 | SOURCE
Port_1313505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313509_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1497554_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313507_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313663_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313507_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313517_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313509_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313510_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313509_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313578_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313510_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313515_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313517_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313515_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313523_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313521_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313547_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313521_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313523_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313564_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313527_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313537_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313527_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313529_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313531_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313529_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313543_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313553_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313543_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313545_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313547_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313545_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313548_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313548_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313563_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313559_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313569_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313561_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313563_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313563_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313564_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313575_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313726_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313591_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313577_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313578_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313577_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313664_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313577_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313583_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313583_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313640_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313589_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313591_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313589_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313601_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313597_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313607_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313597_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313599_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313601_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313607_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313613_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313615_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313625_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313615_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313616_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313615_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313727_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313616_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313639_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313631_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313623_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313625_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313623_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313631_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313637_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313639_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313649_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313639_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313640_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313645_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313655_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313645_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313647_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313649_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313647_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313661_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313687_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313661_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313671_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313663_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313663_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313704_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313669_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313978_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313669_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313679_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313671_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313979_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313677_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313679_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313677_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313685_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313687_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313687_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313688_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313688_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313703_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313693_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313695_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313701_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313703_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313701_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313711_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313704_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313709_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313711_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313709_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
OutPort_1313717_1 | SOURCE
OutPort_1313720_1 | SOURCE
OutPort_1313723_1 | SOURCE
Port_1313726_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313726_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313891_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313732_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313764_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313736_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313734_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313734_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313746_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313742_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313752_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313744_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313746_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313744_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313752_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313758_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313774_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313758_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313782_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313760_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313764_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313760_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313770_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1313761_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
