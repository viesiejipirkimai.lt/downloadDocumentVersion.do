Properties of the parts of a building model (IFC2X3), part 56 of 57

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1469571 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469595 | 3 a | 3449.07 | 12915.2 | vanduo karštas apytakinis - T4 1
1469603 | 3 a | 1196 | 12915.2 | vanduo karštas apytakinis - T4 1
1469613 | 3 a | 96 | 12915.2 | vanduo karštas apytakinis - T4 1
1469621 | 3 a | 5618 | 12915.2 | vanduo karštas apytakinis - T4 1
1469645 | 3 a | 5438 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469656 | 3 a | 5462.98 | 12802.3 | vanduo karštas tiekiamasis - T3 11
1469659 | 3 a | 2573.5 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469674 | 3 a | 1660 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469685 | 3 a | 80 | 9942.3 | vanduo karštas tiekiamasis - T3 11
1469721 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469741 | 3 a | 67.6721 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469754 | 3 a | 1386.5 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469757 | 3 a | 80 | 9942.3 | vanduo karštas tiekiamasis - T3 11
1469804 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469824 | 3 a | 165.254 | 9942.3 | vanduo karštas tiekiamasis - T3 11
1469833 | 3 a | 2822.29 | 9970 | vanduo karštas tiekiamasis - T3 11
1469836 | 3 a | 992.328 | 12804.6 | vanduo karštas tiekiamasis - T3 11
1469924 | 1 a +-152.84 | 4561.11 | 7806.61 | vanduo karštas tiekiamasis - T3 1
1469959 | 3 a | 355.326 | 12388.7 | vanduo karštas tiekiamasis - T3 1
1469977 | 3 a | 63.9314 | 12391.7 | vanduo karštas tiekiamasis - T3 1
1469999 | 3 a | 559 | 12394 | vanduo karštas tiekiamasis - T3 1
1470027 | 3 a | 940 | 12394 | vanduo karštas tiekiamasis - T3 1
1470037 | 3 a | 80 | 9592.3 | vanduo karštas tiekiamasis - T3 1
1470083 | 3 a | 2761.72 | 9620 | vanduo karštas tiekiamasis - T3 1
1470105 | 3 a | 258 | 12394 | vanduo karštas tiekiamasis - T3 1
1470120 | 3 a | 779.289 | 12391.7 | vanduo karštas tiekiamasis - T3 1
1470123 | 3 a | 1060 | 12394 | vanduo karštas tiekiamasis - T3 1
1470139 | 3 a | 94.0686 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1470181 | 3 a | 2411.72 | 9970 | vanduo karštas tiekiamasis - T3 1
1470203 | 3 a | 498 | 12394 | vanduo karštas tiekiamasis - T3 1
1470214 | 3 a | 45.0481 | 12391.7 | vanduo karštas tiekiamasis - T3 1
1470217 | 3 a | 235.15 | 12394 | vanduo karštas tiekiamasis - T3 1
1470227 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1470263 | 3 a | 2411.72 | 9970 | vanduo karštas tiekiamasis - T3 1
1470285 | 3 a | 4518 | 12394 | vanduo karštas tiekiamasis - T3 1
1470304 | 3 a | 5027.73 | 12391.7 | vanduo karštas tiekiamasis - T3 1
1470307 | 3 a | 1780 | 12394 | vanduo karštas tiekiamasis - T3 1
1470317 | 3 a | 220 | 12394 | vanduo karštas tiekiamasis - T3 1
1470325 | 3 a | 340 | 12394 | vanduo karštas tiekiamasis - T3 1
1470335 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1470382 | 3 a | 2411.72 | 9970 | vanduo karštas tiekiamasis - T3 1
1470404 | 3 a | 414 | 12484.1 | vanduo šaltas - V1 2
1470421 | 2 a | 177.993 | 12478.8 | vanduo šaltas - V1 2
1470424 | 3 a | 140 | 9942.3 | vanduo šaltas - V1 2
1470473 | 3 a | 2501.84 | 9970 | vanduo šaltas - V1 2
1470495 | 3 a | 454 | 12484.1 | vanduo šaltas - V1 2
1470504 | 2 a | 2095.68 | 12478.8 | vanduo šaltas - V1 2
1470507 | 3 a | 120 | 9942.3 | vanduo šaltas - V1 2
1470559 | 3 a | 2501.84 | 9970 | vanduo šaltas - V1 2
1470591 | 3 a | 354 | 12394 | vanduo karštas tiekiamasis - T3 1
1470600 | 3 a | 2271.56 | 12388.7 | vanduo karštas tiekiamasis - T3 1
1470603 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1470641 | 3 a | 2411.72 | 9970 | vanduo karštas tiekiamasis - T3 1
1470663 | 3 a | 359 | 12394 | vanduo karštas tiekiamasis - T3 1
1470672 | 3 a | 76.1182 | 12388.7 | vanduo karštas tiekiamasis - T3 1
1470675 | 3 a | 115 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1470771 | 3 a | 2411.72 | 9970 | vanduo karštas tiekiamasis - T3 1
1470808 | 1 a +-152.84 | 8888.08 | 3534 | vanduo karštas apytakinis - T4 1
1471048 | 3 a | 2971 | 12435.4 | vanduo karštas apytakinis - T4 1
1471058 | 3 a | 5010 | 12435.4 | vanduo karštas apytakinis - T4 1
1471076 | 3 a | 4570 | 12435.4 | vanduo karštas apytakinis - T4 1
1471118 | 3 a | 402 | 13044.5 | vanduo karštas tiekiamasis - T3 1
1471128 | 3 a | 442 | 13044.5 | vanduo karštas tiekiamasis - T3 1
1471156 | 3 a | 432 | 12994 | vanduo karštas apytakinis - T4 1
1471164 | 3 a | 535.066 | 12994 | vanduo karštas apytakinis - T4 1
1471190 | 3 a | 4082 | 13039 | vanduo karštas apytakinis - T4 1
1471228 | 3 a | 4102 | 13104 | vanduo karštas tiekiamasis - T3 1
1471268 | 3 a | 94 | 13052 | vanduo karštas tiekiamasis - T3 1
1471312 | 3 a | 53 | 13052 | vanduo karštas tiekiamasis - T3 1
1471324 | 3 a | 118 | 13052 | vanduo karštas tiekiamasis - T3 1
1471334 | 3 a | 47.8081 | 13052 | vanduo karštas tiekiamasis - T3 1
1471342 | 3 a | 300.815 | 13055 | vanduo karštas tiekiamasis - T3 1
1471366 | 3 a | 679 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471410 | 3 a | 2380 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471428 | 3 a | 171.961 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471436 | 3 a | 141.981 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1471494 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1471526 | 3 a | 80 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1471541 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1471544 | 3 a | 1043.04 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471563 | 3 a | 655 | 13055 | vanduo karštas tiekiamasis - T3 1
1471574 | 3 a | 4149.19 | 13055 | vanduo karštas tiekiamasis - T3 1
1471577 | 3 a | 159 | 13055 | vanduo karštas tiekiamasis - T3 1
1471587 | 3 a | 101.934 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1471655 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1471800 | 3 a | 1479 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471809 | 3 a | 6453.64 | 13052 | vanduo karštas tiekiamasis - T3 1
1471812 | 3 a | 505 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471820 | 3 a | 140 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1471830 | 3 a | 95 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1471879 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1472021 | 3 a | 1597.27 | 12675.1 | vanduo šaltas - V1 8
1472065 | 3 a | 71.2759 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1472074 | 3 a | 1622.12 | 13052 | vanduo karštas tiekiamasis - T3 1
1472077 | 3 a | 102.656 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1472112 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1472132 | 3 a | 70 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1472145 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1472148 | 3 a | 1652.72 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1472179 | 3 a | 1380 | 12675.1 | vanduo šaltas - V1 2
1472188 | 3 a | 1012.87 | 12675.1 | vanduo šaltas - V1 2
1472191 | 3 a | 160 | 12675.1 | vanduo šaltas - V1 2
1472201 | 3 a | 160 | 12675.1 | vanduo šaltas - V1 2
1472209 | 3 a | 140 | 9942.3 | vanduo šaltas - V1 2
1472248 | 3 a | 2692.78 | 9970 | vanduo šaltas - V1 2
1472270 | 3 a | 1234 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1472281 | 3 a | 79.4323 | 13052 | vanduo karštas tiekiamasis - T3 1
1472284 | 3 a | 560 | 13057.3 | vanduo karštas tiekiamasis - T3 1
1472292 | 3 a | 154.255 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1472359 | 3 a | 3075 | 9970 | vanduo karštas tiekiamasis - T3 1
1472400 | 3 a | 94 | 13002.3 | vanduo karštas apytakinis - T4 1
1472450 | 3 a | 185 | 13002.3 | vanduo karštas apytakinis - T4 1
1472458 | 3 a | 120 | 13002.3 | vanduo karštas apytakinis - T4 1
1472470 | 3 a | 8360 | 13002.3 | vanduo karštas apytakinis - T4 1
1472481 | 3 a | 4580 | 13002.3 | vanduo karštas apytakinis - T4 1
1472501 | 3 a | 605 | 13002.3 | vanduo karštas apytakinis - T4 1
1472509 | 3 a | 2360 | 13002.3 | vanduo karštas apytakinis - T4 1
1472540 | 2 a | 490 | 12651.7 | vanduo karštas apytakinis - T4 1
1472561 | 2 a | 9109.42 | 3529 | vanduo karštas apytakinis - T4 1
1472685 | 2 a | 503 | 12612.4 | vanduo karštas tiekiamasis - T3 1
1472704 | 2 a | 4693.22 | 7898.23 | vanduo karštas tiekiamasis - T3 1
1472866 | 3 a | 77.25 | 12612.4 | vanduo karštas tiekiamasis - T3 1
1473179 | 3 a | 111.009 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473197 | 3 a | 100.266 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473209 | 3 a | 2738.15 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473248 | 3 a | 1200 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473261 | 3 a | 385 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473271 | 3 a | 125 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473324 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473372 | 3 a | 1010 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473381 | 3 a | 2534.43 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473384 | 3 a | 90 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473426 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473448 | 3 a | 157.282 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473457 | 3 a | 5626.42 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473460 | 3 a | 200 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473468 | 3 a | 120 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473499 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473521 | 3 a | 135 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473528 | 3 a | 382.718 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473531 | 3 a | 70 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473571 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473595 | 3 a | 75 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473602 | 3 a | 421.648 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473605 | 3 a | 756 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473615 | 3 a | 479 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473627 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473672 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473694 | 3 a | 2813 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473705 | 3 a | 4348.09 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473708 | 3 a | 100.441 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473750 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473776 | 3 a | 218 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473785 | 3 a | 1937.49 | 12615.4 | vanduo karštas tiekiamasis - T3 1
1473788 | 3 a | 5840 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473796 | 3 a | 660 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473806 | 3 a | 240 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473814 | 3 a | 76.5815 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473863 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473887 | 3 a | 841.847 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473896 | 3 a | 77.25 | 12612.4 | vanduo karštas tiekiamasis - T3 1
1473899 | 3 a | 480 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1473907 | 3 a | 182.425 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1473968 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1473990 | 3 a | 1600 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1474003 | 3 a | 112.153 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1474006 | 3 a | 141.399 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1474019 | 3 a | 95 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1474061 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1474085 | 3 a | 15 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1474092 | 3 a | 63.6014 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1474095 | 3 a | 175 | 12617.7 | vanduo karštas tiekiamasis - T3 1
1474113 | 3 a | 75 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1474163 | 3 a | 2635.44 | 9970 | vanduo karštas tiekiamasis - T3 1
1474221 | 1 a +-152.84 | 4680.77 | 7888 | vanduo karštas tiekiamasis - T3 1
1474240 | 1 a +-152.84 | 123 | 12677.8 | vanduo karštas apytakinis - T4 1
1474274 | 1 a +-152.84 | 4836.79 | 7828 | vanduo karštas apytakinis - T4 1
1474296 | 3 a | 58 | 12677.8 | vanduo karštas apytakinis - T4 1
1474740 | 3 a | 1549.73 | 12589.8 | vanduo karštas tiekiamasis - T3 1
1474752 | 3 a | 1155 | 12592.8 | vanduo karštas tiekiamasis - T3 1
1474770 | 3 a | 6915 | 12592.8 | vanduo karštas tiekiamasis - T3 1
1474784 | 3 a | 1079 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1474802 | 3 a | 140 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1474850 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1474890 | 3 a | 696.151 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1474900 | 3 a | 160 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1474908 | 3 a | 40 | 9592.3 | vanduo karštas tiekiamasis - T3 1
1474938 | 3 a | 2962.77 | 9620 | vanduo karštas tiekiamasis - T3 1
1474984 | 3 a | 160 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1474993 | 3 a | 431.604 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1474996 | 3 a | 85 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475031 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475053 | 3 a | 1740 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475062 | 3 a | 73.2449 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475065 | 3 a | 195.842 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475075 | 3 a | 540 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475085 | 3 a | 103.375 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475118 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475151 | 3 a | 174 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475160 | 3 a | 157.807 | 12589.8 | vanduo karštas tiekiamasis - T3 1
1475163 | 3 a | 5720 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475171 | 3 a | 81.9321 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475181 | 3 a | 140 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475214 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475243 | 3 a | 90.8071 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475252 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475255 | 3 a | 298.068 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475314 | 3 a | 272 | 12592.8 | vanduo karštas tiekiamasis - T3 1
1475327 | 3 a | 111.459 | 12589.8 | vanduo karštas tiekiamasis - T3 1
1475330 | 3 a | 516 | 12592.8 | vanduo karštas tiekiamasis - T3 1
1475338 | 3 a | 68.3751 | 12592.8 | vanduo karštas tiekiamasis - T3 1
1475362 | 3 a | 275.461 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475382 | 3 a | 360 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475401 | 3 a | 240 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475412 | 3 a | 100 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475459 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475510 | 3 a | 2740 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475523 | 3 a | 1585.24 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475526 | 3 a | 65 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475534 | 3 a | 115 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475544 | 3 a | 65 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475588 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475610 | 3 a | 260 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475619 | 3 a | 4858.3 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475622 | 3 a | 115.724 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475713 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475737 | 3 a | 288 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475760 | 3 a | 2867.62 | 12592.8 | vanduo karštas tiekiamasis - T3 1
1475763 | 3 a | 90 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475776 | 3 a | 5010 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475784 | 3 a | 96.4328 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475794 | 3 a | 117.348 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475845 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475867 | 3 a | 78.3771 | 9942.3 | vanduo karštas tiekiamasis - T3 1
1475878 | 3 a | 2612.77 | 9970 | vanduo karštas tiekiamasis - T3 1
1475881 | 3 a | 228.567 | 12595.1 | vanduo karštas tiekiamasis - T3 1
1475906 | 3 a | 5644 | 12680.1 | vanduo karštas apytakinis - T4 1
1475944 | 3 a | 1574.78 | 12680.1 | vanduo karštas apytakinis - T4 1
1475961 | 3 a | 58 | 12677.8 | vanduo karštas apytakinis - T4 1
1475964 | 3 a | 1025 | 12680.1 | vanduo karštas apytakinis - T4 1
1475980 | 3 a | 6900 | 12680.1 | vanduo karštas apytakinis - T4 1
1476011 | 3 a | 410 | 12680.1 | vanduo karštas apytakinis - T4 1
1476024 | 3 a | 243.217 | 12680.1 | vanduo karštas apytakinis - T4 1
1476027 | 3 a | 530 | 12680.1 | vanduo karštas apytakinis - T4 1
1476035 | 3 a | 71.8429 | 12680.1 | vanduo karštas apytakinis - T4 1
1476049 | 3 a | 6815 | 12680.1 | vanduo karštas apytakinis - T4 1
1476077 | 3 a | 365 | 12680.1 | vanduo karštas apytakinis - T4 1
1476088 | 3 a | 2783.16 | 12680.1 | vanduo karštas apytakinis - T4 1
1476091 | 3 a | 95 | 12680.1 | vanduo karštas apytakinis - T4 1
1476103 | 3 a | 4995 | 12680.1 | vanduo karštas apytakinis - T4 1
1476269 | 4 a V1 | 64.5 | 17064 | vanduo karštas tiekiamasis - T3 1
1476598 | 1 a +-152.84 | 112 | 17038.3 | vanduo karštas apytakinis - T4 1
1476870 | 4 a V1 | 191 | 17038.3 | vanduo karštas apytakinis - T4 1
1477009 | 4 a V1 | 70.0177 | 17067 | vanduo karštas tiekiamasis - T3 1
1477027 | 4 a V1 | 836 | 17067 | vanduo karštas tiekiamasis - T3 1
1477047 | 4 a V1 | 1576 | 17067 | vanduo karštas tiekiamasis - T3 1
1477055 | 4 a V1 | 159 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477073 | 4 a V1 | 100 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1477124 | 4 a V1 | 2437 | 14620 | vanduo karštas tiekiamasis - T3 1
1477152 | 4 a V1 | 938 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477164 | 4 a V1 | 420 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477172 | 4 a V1 | 60 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477238 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477262 | 4 a V1 | 418.631 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477271 | 4 a V1 | 1425.17 | 17067 | vanduo karštas tiekiamasis - T3 1
1477321 | 4 a V1 | 2646.15 | 17067 | vanduo karštas tiekiamasis - T3 1
1477325 | 4 a V1 | 220 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477337 | 4 a V1 | 78.5248 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477398 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477420 | 4 a V1 | 438 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477429 | 4 a V1 | 160.8 | 17067 | vanduo karštas tiekiamasis - T3 1
1477432 | 4 a V1 | 74.4503 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477470 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477490 | 4 a V1 | 555.862 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477501 | 4 a V1 | 1073.86 | 17067 | vanduo karštas tiekiamasis - T3 1
1477504 | 4 a V1 | 120 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477514 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477572 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477602 | 4 a V1 | 22 | 17067 | vanduo karštas tiekiamasis - T3 1
1477613 | 4 a V1 | 64.5 | 17064 | vanduo karštas tiekiamasis - T3 1
1477626 | 4 a V1 | 2488.69 | 17067 | vanduo karštas tiekiamasis - T3 1
1477648 | 4 a V1 | 520.979 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477679 | 4 a V1 | 570 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477689 | 4 a V1 | 190 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477697 | 4 a V1 | 105 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477756 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477783 | 4 a V1 | 75 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477792 | 4 a V1 | 1672.85 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477795 | 4 a V1 | 125 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477825 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477847 | 4 a V1 | 480 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477856 | 4 a V1 | 225.175 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1477859 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1477916 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1477951 | 4 a V1 | 126.308 | 17067 | vanduo karštas tiekiamasis - T3 1
1477954 | 4 a V1 | 1595 | 17067 | vanduo karštas tiekiamasis - T3 1
1477982 | 4 a V1 | 316 | 17067 | vanduo karštas tiekiamasis - T3 1
1477992 | 4 a V1 | 2925.24 | 17067 | vanduo karštas tiekiamasis - T3 1
1478000 | 4 a V1 | 616 | 17067 | vanduo karštas tiekiamasis - T3 1
1478016 | 4 a V1 | 1119 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478028 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478100 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1478128 | 4 a V1 | 695 | 17067 | vanduo karštas tiekiamasis - T3 1
1478137 | 4 a V1 | 97.8497 | 17067 | vanduo karštas tiekiamasis - T3 1
1478140 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478181 | 4 a V1 | 2566 | 14470 | vanduo karštas tiekiamasis - T3 1
1478214 | 4 a V1 | 1158.57 | 17067 | vanduo karštas tiekiamasis - T3 1
1478217 | 4 a V1 | 1038 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478223 | 4 a V1 | 60 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478231 | 4 a V1 | 125 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478284 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1478308 | 4 a V1 | 987.5 | 17067 | vanduo karštas tiekiamasis - T3 1
1478317 | 4 a V1 | 837.365 | 17067 | vanduo karštas tiekiamasis - T3 1
1478320 | 4 a V1 | 100 | 17069.3 | vanduo karštas tiekiamasis - T3 12
1478358 | 4 a V1 | 355 | 17067 | vanduo karštas tiekiamasis - T3 1
1478367 | 4 a V1 | 1144.63 | 17067 | vanduo karštas tiekiamasis - T3 1
1478370 | 4 a V1 | 118 | 14440 | vanduo karštas tiekiamasis - T3 1
1478399 | 4 a V1 | 2583 | 14472 | vanduo karštas tiekiamasis - T3 1
1478421 | 4 a V1 | 78 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478430 | 4 a V1 | 79.3444 | 17067 | vanduo karštas tiekiamasis - T3 1
1478433 | 4 a V1 | 100 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478444 | 4 a V1 | 46.6972 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478456 | 4 a V1 | 5920 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478469 | 4 a V1 | 1280 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478479 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478516 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1478538 | 4 a V1 | 44.0857 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478549 | 4 a V1 | 5493.3 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478552 | 4 a V1 | 368.637 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478565 | 4 a V1 | 240 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478573 | 4 a V1 | 100.458 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478625 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1478668 | 4 a V1 | 140 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478677 | 4 a V1 | 2095.91 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478680 | 4 a V1 | 368.414 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478691 | 4 a V1 | 600 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478701 | 4 a V1 | 40 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478709 | 4 a V1 | 180 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478765 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1478787 | 4 a V1 | 3620 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478804 | 4 a V1 | 491.363 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478807 | 4 a V1 | 360 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478817 | 4 a V1 | 160 | 17069.3 | vanduo karštas tiekiamasis - T3 1
1478825 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1478854 | 4 a V1 | 2587 | 14470 | vanduo karštas tiekiamasis - T3 1
1478885 | 4 a V1 | 60 | 17038.3 | vanduo karštas apytakinis - T4 1
1478897 | 4 a V1 | 310 | 17038.3 | vanduo karštas apytakinis - T4 1
1478909 | 4 a V1 | 1540 | 17038.3 | vanduo karštas apytakinis - T4 1
1478922 | 4 a V1 | 300 | 17038.3 | vanduo karštas apytakinis - T4 1
1478932 | 4 a V1 | 6286.65 | 17038.3 | vanduo karštas apytakinis - T4 1
1478946 | 4 a V1 | 30 | 17038.3 | vanduo karštas apytakinis - T4 1
1478968 | 4 a V1 | 200 | 17038.3 | vanduo karštas apytakinis - T4 1
1478977 | 4 a V1 | 53.3503 | 17038.3 | vanduo karštas apytakinis - T4 1
1478980 | 4 a V1 | 110 | 17038.3 | vanduo karštas apytakinis - T4 1
1478988 | 4 a V1 | 57.5226 | 17038.3 | vanduo karštas apytakinis - T4 1
1479033 | 4 a V1 | 5875 | 17038.3 | vanduo karštas apytakinis - T4 1
1479068 | 4 a V1 | 2180 | 17038.3 | vanduo karštas apytakinis - T4 1
1479077 | 4 a V1 | 5382.48 | 17038.3 | vanduo karštas apytakinis - T4 1
1479080 | 4 a V1 | 400 | 17038.3 | vanduo karštas apytakinis - T4 1
1479090 | 4 a V1 | 3705 | 17038.3 | vanduo karštas apytakinis - T4 1
1479124 | 4 a V1 | 45 | 17038.3 | vanduo karštas apytakinis - T4 1
1479134 | 4 a V1 | 5640 | 17038.3 | vanduo karštas apytakinis - T4 1
1479165 | 2 a | 527.54 | 17132.3 | vanduo karštas apytakinis - T4 1
1479210 | 2 a | 13 | 17114.1 | vanduo karštas tiekiamasis - T3 1
1479312 | 4 a V1 | 34.0839 | 17114.1 | vanduo karštas tiekiamasis - T3 1
1479482 | 4 a V1 | 20 | 17132.3 | vanduo karštas apytakinis - T4 1
1479489 | 2 a | 32.46 | 17132.3 | vanduo karštas apytakinis - T4 1
1479492 | 4 a V1 | 5340 | 17132.3 | vanduo karštas apytakinis - T4 1
1479505 | 4 a V1 | 12120 | 17132.3 | vanduo karštas apytakinis - T4 1
1479515 | 4 a V1 | 2410 | 17132.3 | vanduo karštas apytakinis - T4 1
1479562 | 4 a V1 | 120 | 17132.3 | vanduo karštas apytakinis - T4 1
1479574 | 4 a V1 | 60 | 17132.3 | vanduo karštas apytakinis - T4 1
1479587 | 4 a V1 | 2212.78 | 17132.3 | vanduo karštas apytakinis - T4 1
1479613 | 4 a V1 | 75.0062 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1479629 | 4 a V1 | 2531.02 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1479637 | 4 a V1 | 2315 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1479649 | 4 a V1 | 579 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1479663 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1479717 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1479776 | 4 a V1 | 540 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1479788 | 4 a V1 | 100 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1479831 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1479857 | 4 a V1 | 518 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1479866 | 4 a V1 | 1827.4 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1479869 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1479909 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1479931 | 4 a V1 | 995 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1479940 | 4 a V1 | 7730.59 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1479943 | 4 a V1 | 203.373 | 14440 | vanduo karštas tiekiamasis - T3 1
1479975 | 4 a V1 | 2633.09 | 14472 | vanduo karštas tiekiamasis - T3 1
1479997 | 4 a V1 | 1278 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480010 | 4 a V1 | 5100.99 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480013 | 4 a V1 | 380 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480023 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480063 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480097 | 4 a V1 | 40.3067 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480106 | 4 a V1 | 94.9161 | 17114.1 | vanduo karštas tiekiamasis - T3 1
1480109 | 4 a V1 | 54.9307 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480117 | 4 a V1 | 979.521 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480127 | 4 a V1 | 119 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480148 | 4 a V1 | 81.5524 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480201 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480227 | 4 a V1 | 173 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480238 | 4 a V1 | 576.479 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480241 | 4 a V1 | 68.0836 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480284 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480306 | 4 a V1 | 68 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480315 | 4 a V1 | 1454.85 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480318 | 4 a V1 | 270 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480326 | 4 a V1 | 70.0143 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480366 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480390 | 4 a V1 | 258 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480399 | 4 a V1 | 66.2196 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480402 | 4 a V1 | 380 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480410 | 4 a V1 | 148.278 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480440 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480460 | 4 a V1 | 228 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480471 | 4 a V1 | 671.693 | 17117.1 | vanduo karštas tiekiamasis - T3 1
1480474 | 4 a V1 | 80 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480487 | 4 a V1 | 140.162 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480498 | 4 a V1 | 62.9982 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480508 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480545 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480569 | 4 a V1 | 45 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480578 | 4 a V1 | 82.0018 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480581 | 4 a V1 | 45 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480641 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480683 | 4 a V1 | 1505 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480694 | 4 a V1 | 62.0346 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480697 | 4 a V1 | 310 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480705 | 4 a V1 | 80 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480715 | 4 a V1 | 150 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480772 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480800 | 4 a V1 | 2200 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480809 | 4 a V1 | 1902.27 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480812 | 4 a V1 | 640 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480820 | 4 a V1 | 167.15 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1480860 | 4 a V1 | 2487.09 | 14620 | vanduo karštas tiekiamasis - T3 1
1480886 | 4 a V1 | 2100 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480895 | 4 a V1 | 1960.53 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480898 | 4 a V1 | 2020 | 17119.4 | vanduo karštas tiekiamasis - T3 1
1480906 | 4 a V1 | 67.1503 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1480946 | 4 a V1 | 2637.09 | 14470 | vanduo karštas tiekiamasis - T3 1
1480968 | 4 a V1 | 2240 | 17132.3 | vanduo karštas apytakinis - T4 1
1480977 | 4 a V1 | 2007.22 | 17132.3 | vanduo karštas apytakinis - T4 1
1480994 | 4 a V1 | 2105 | 17132.3 | vanduo karštas apytakinis - T4 1
1481004 | 4 a V1 | 1695 | 17132.3 | vanduo karštas apytakinis - T4 1
1481030 | 3 a | 887 | 17134 | vanduo karštas apytakinis - T4 1
1481058 | 3 a | 367 | 17224.5 | vanduo karštas tiekiamasis - T3 1
1481084 | 4 a V1 | 80 | 17142.3 | vanduo karštas apytakinis - T4 1
1481106 | 4 a V1 | 1569.44 | 17142.3 | vanduo karštas apytakinis - T4 1
1481116 | 4 a V1 | 9420 | 17142.3 | vanduo karštas apytakinis - T4 1
1481196 | 4 a V1 | 5325 | 17142.3 | vanduo karštas apytakinis - T4 1
1481206 | 4 a V1 | 65 | 17142.3 | vanduo karštas apytakinis - T4 1
1481261 | 4 a V1 | 160 | 17142.3 | vanduo karštas apytakinis - T4 1
1481270 | 4 a V1 | 70.5582 | 17142.3 | vanduo karštas apytakinis - T4 1
1481273 | 4 a V1 | 500 | 17142.3 | vanduo karštas apytakinis - T4 1
1481289 | 4 a V1 | 2580 | 17142.3 | vanduo karštas apytakinis - T4 1
1481297 | 4 a V1 | 4765 | 17142.3 | vanduo karštas apytakinis - T4 1
1481314 | 4 a V1 | 45 | 17142.3 | vanduo karštas apytakinis - T4 1
1481357 | 4 a V1 | 136 | 17235 | vanduo karštas tiekiamasis - T3 1
1481390 | 4 a V1 | 2012.15 | 17235 | vanduo karštas tiekiamasis - T3 1
1481400 | 4 a V1 | 4026.59 | 17235 | vanduo karštas tiekiamasis - T3 1
1481408 | 4 a V1 | 816.791 | 17235 | vanduo karštas tiekiamasis - T3 1
1481418 | 4 a V1 | 1776 | 17235 | vanduo karštas tiekiamasis - T3 1
1481428 | 4 a V1 | 138.107 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481442 | 4 a V1 | 85 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1481529 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1481555 | 4 a V1 | 485 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481568 | 4 a V1 | 90.8928 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481571 | 4 a V1 | 155 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1481620 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1481726 | 4 a V1 | 43 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481735 | 4 a V1 | 1344.76 | 17235 | vanduo karštas tiekiamasis - T3 1
1481738 | 4 a V1 | 90 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1481816 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1481840 | 4 a V1 | 53 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481849 | 4 a V1 | 1438.17 | 17235 | vanduo karštas tiekiamasis - T3 1
1481852 | 4 a V1 | 115 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1481907 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1481931 | 4 a V1 | 341.823 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481940 | 4 a V1 | 1615.28 | 17235 | vanduo karštas tiekiamasis - T3 1
1481943 | 4 a V1 | 400 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481953 | 4 a V1 | 160 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1481961 | 4 a V1 | 127.975 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482006 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1482028 | 4 a V1 | 240 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482037 | 4 a V1 | 1736.18 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482040 | 4 a V1 | 60 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482085 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1482121 | 4 a V1 | 1207.76 | 17235 | vanduo karštas tiekiamasis - T3 1
1482131 | 4 a V1 | 49 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482158 | 4 a V1 | 170 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482222 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1482252 | 4 a V1 | 1770 | 17235 | vanduo karštas tiekiamasis - T3 1
1482265 | 4 a V1 | 1799.24 | 17235 | vanduo karštas tiekiamasis - T3 1
1482268 | 4 a V1 | 45 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482310 | 4 a V1 | 2734 | 14470 | vanduo karštas tiekiamasis - T3 1
1482345 | 4 a V1 | 465 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482360 | 4 a V1 | 45 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482363 | 4 a V1 | 25 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482373 | 4 a V1 | 161.776 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482427 | 4 a V1 | 499.296 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482436 | 4 a V1 | 5228.41 | 17235 | vanduo karštas tiekiamasis - T3 1
1482439 | 4 a V1 | 1440 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482447 | 4 a V1 | 720 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482457 | 4 a V1 | 80 | 14251.5 | vanduo karštas tiekiamasis - T3 1
1482500 | 4 a V1 | 2945.8 | 14279.2 | vanduo karštas tiekiamasis - T3 1
1482522 | 4 a V1 | 335 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482535 | 4 a V1 | 2618.7 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482538 | 4 a V1 | 85 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1482580 | 4 a V1 | 2605 | 14620 | vanduo karštas tiekiamasis - T3 1
1482604 | 4 a V1 | 2888 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482629 | 4 a V1 | 123.849 | 17235 | vanduo karštas tiekiamasis - T3 1
1482632 | 4 a V1 | 362.071 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482642 | 4 a V1 | 660 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482650 | 4 a V1 | 125 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482660 | 4 a V1 | 190.82 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482702 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1482732 | 4 a V1 | 1220 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482745 | 4 a V1 | 2222.21 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482748 | 4 a V1 | 122.025 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482806 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1482830 | 4 a V1 | 719.914 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482845 | 4 a V1 | 2175.72 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482848 | 4 a V1 | 170 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482858 | 4 a V1 | 119.475 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1482935 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1482976 | 4 a V1 | 185 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482985 | 4 a V1 | 810.043 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1482988 | 4 a V1 | 64.4746 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483023 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1483047 | 4 a V1 | 140 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483056 | 4 a V1 | 810.043 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483059 | 4 a V1 | 220 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483111 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1483145 | 4 a V1 | 1820 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483171 | 4 a V1 | 1294.77 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483192 | 4 a V1 | 320 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483200 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483263 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1483294 | 4 a V1 | 660 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483301 | 4 a V1 | 1025.23 | 17237.3 | vanduo karštas tiekiamasis - T3 1
1483304 | 4 a V1 | 160 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483337 | 4 a V1 | 2755 | 14470 | vanduo karštas tiekiamasis - T3 1
1483387 | 1 a +-152.84 | 1003 | 17120.1 | vanduo karštas tiekiamasis - T3 1
1483398 | 1 a +-152.84 | 4663.35 | 12435.7 | vanduo karštas tiekiamasis - T3 1
1483419 | 1 a +-152.84 | 1170 | 16976 | vanduo karštas apytakinis - T4 1
1483434 | 1 a +-152.84 | 4498.6 | 12464.1 | vanduo karštas apytakinis - T4 1
1483455 | 4 a V1 | 88.5235 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1483473 | 4 a V1 | 720.202 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1483483 | 4 a V1 | 327.673 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483495 | 4 a V1 | 300 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483508 | 4 a V1 | 160 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483550 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1483584 | 4 a V1 | 400 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483593 | 4 a V1 | 1358.45 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483596 | 4 a V1 | 102.254 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483667 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1483689 | 4 a V1 | 400 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483698 | 4 a V1 | 112.878 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483701 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483741 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1483763 | 4 a V1 | 438 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1483774 | 4 a V1 | 1361.68 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1483777 | 4 a V1 | 116.513 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1483816 | 4 a V1 | 2493.07 | 14620 | vanduo karštas tiekiamasis - T3 1
1483851 | 4 a V1 | 428 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483860 | 4 a V1 | 669.548 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1483863 | 4 a V1 | 75 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1483892 | 4 a V1 | 2493.07 | 14620 | vanduo karštas tiekiamasis - T3 1
1483916 | 4 a V1 | 418 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483925 | 4 a V1 | 87.3845 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1483928 | 4 a V1 | 350.832 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483936 | 4 a V1 | 240 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1483946 | 4 a V1 | 158.563 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1483993 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484015 | 4 a V1 | 82.1338 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484024 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484027 | 4 a V1 | 1504.79 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484046 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484059 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484062 | 4 a V1 | 104.38 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484081 | 4 a V1 | 981.994 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484090 | 4 a V1 | 5711.48 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484093 | 4 a V1 | 448.82 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484167 | 4 a V1 | 100 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484209 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484242 | 4 a V1 | 150 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484251 | 4 a V1 | 53.8799 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484254 | 4 a V1 | 75 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484301 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484323 | 4 a V1 | 115 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484332 | 4 a V1 | 1616.3 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484335 | 4 a V1 | 185 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484372 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484396 | 4 a V1 | 163 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484405 | 4 a V1 | 3033.01 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484408 | 4 a V1 | 71.5 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484450 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484488 | 4 a V1 | 904.535 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484497 | 4 a V1 | 402.629 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484500 | 4 a V1 | 156 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484508 | 4 a V1 | 279 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484528 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484567 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484589 | 4 a V1 | 1918 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484600 | 4 a V1 | 1444.06 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484603 | 4 a V1 | 94.8382 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1484699 | 4 a V1 | 2493.07 | 14620 | vanduo karštas tiekiamasis - T3 1
1484726 | 4 a V1 | 1913 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484735 | 4 a V1 | 1180.32 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484738 | 4 a V1 | 89.8382 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1484772 | 4 a V1 | 2493.07 | 14620 | vanduo karštas tiekiamasis - T3 1
1484796 | 4 a V1 | 188 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484805 | 4 a V1 | 266.084 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484808 | 4 a V1 | 115 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484847 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484867 | 4 a V1 | 583.327 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484878 | 4 a V1 | 3893.98 | 17123.1 | vanduo karštas tiekiamasis - T3 1
1484881 | 4 a V1 | 320 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484889 | 4 a V1 | 160 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1484933 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1484953 | 4 a V1 | 125 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484960 | 4 a V1 | 427.13 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1484963 | 4 a V1 | 185 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485045 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1485069 | 4 a V1 | 90 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1485076 | 4 a V1 | 1747.54 | 17125.4 | vanduo karštas tiekiamasis - T3 1
1485079 | 4 a V1 | 159.201 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485109 | 4 a V1 | 2643.07 | 14470 | vanduo karštas tiekiamasis - T3 1
1485131 | 4 a V1 | 10260 | 16976 | vanduo karštas apytakinis - T4 1
1485145 | 4 a V1 | 3980 | 16976 | vanduo karštas apytakinis - T4 1
1485179 | 1 a +-152.84 | 263 | 17759.1 | vanduo karštas tiekiamasis - T3 1
1485215 | 1 a +-152.84 | 550 | 17798.8 | vanduo karštas apytakinis - T4 1
1485332 | 1 a +-152.84 | 9828.78 | 7909.36 | vanduo karštas tiekiamasis - T3 1
1485357 | 1 a +-152.84 | 9823.55 | 7961.94 | vanduo karštas apytakinis - T4 1
1485369 | 4 a V1 | 1573.4 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485397 | 4 a V1 | 894.35 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485411 | 4 a V1 | 560.821 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485435 | 4 a V1 | 826.577 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485447 | 4 a V1 | 1399 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485474 | 4 a V1 | 149.044 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485484 | 4 a V1 | 60 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485531 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1485553 | 4 a V1 | 300 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485562 | 4 a V1 | 90.9556 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485565 | 4 a V1 | 85 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485575 | 4 a V1 | 129.108 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485608 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1485657 | 4 a V1 | 598 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485670 | 4 a V1 | 1406.26 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485673 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485714 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1485753 | 4 a V1 | 578 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485764 | 4 a V1 | 931.52 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485767 | 4 a V1 | 87.9749 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1485799 | 4 a V1 | 3132.14 | 14620 | vanduo karštas tiekiamasis - T3 1
1485821 | 4 a V1 | 491.614 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485834 | 4 a V1 | 111.641 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1485837 | 4 a V1 | 35 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485847 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485900 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1485936 | 4 a V1 | 200 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485945 | 4 a V1 | 1236.39 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1485948 | 4 a V1 | 59.9402 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1485979 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486001 | 4 a V1 | 1200.67 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486010 | 4 a V1 | 3552.95 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486013 | 4 a V1 | 120 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1486049 | 4 a V1 | 3111.14 | 14620 | vanduo karštas tiekiamasis - T3 1
1486086 | 4 a V1 | 3809.33 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486089 | 4 a V1 | 499.2 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486114 | 4 a V1 | 380 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486124 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1486163 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486185 | 4 a V1 | 110 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1486194 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486197 | 4 a V1 | 1813.8 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486216 | 4 a V1 | 1166.73 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486225 | 4 a V1 | 50.228 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486228 | 4 a V1 | 1836 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486236 | 4 a V1 | 116 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486246 | 4 a V1 | 78 | 14440 | vanduo karštas tiekiamasis - T3 1
1486293 | 4 a V1 | 3278.14 | 14472 | vanduo karštas tiekiamasis - T3 1
1486315 | 4 a V1 | 105 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1486326 | 4 a V1 | 3130.14 | 14620 | vanduo karštas tiekiamasis - T3 1
1486329 | 4 a V1 | 308.267 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486350 | 4 a V1 | 624.554 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486359 | 4 a V1 | 3818.25 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486362 | 4 a V1 | 245 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486370 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1486410 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486457 | 4 a V1 | 200 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486466 | 4 a V1 | 455.546 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486469 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1486511 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486541 | 4 a V1 | 90 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486548 | 4 a V1 | 2122.9 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486551 | 4 a V1 | 94.0774 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1486593 | 4 a V1 | 3282.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486618 | 4 a V1 | 85 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1486627 | 4 a V1 | 3280.14 | 14470 | vanduo karštas tiekiamasis - T3 1
1486630 | 4 a V1 | 744.347 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486652 | 4 a V1 | 98 | 17764.4 | vanduo karštas tiekiamasis - T3 1
1486663 | 4 a V1 | 1221.65 | 17762.1 | vanduo karštas tiekiamasis - T3 1
1486666 | 4 a V1 | 155 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1486707 | 4 a V1 | 3132.14 | 14620 | vanduo karštas tiekiamasis - T3 1
1486733 | 4 a V1 | 6355 | 17798.8 | vanduo karštas apytakinis - T4 1
1486745 | 4 a V1 | 2155 | 17798.8 | vanduo karštas apytakinis - T4 1
1486767 | 4 a V1 | 3680 | 17798.8 | vanduo karštas apytakinis - T4 1
1486779 | 4 a V1 | 3757.45 | 17798.8 | vanduo karštas apytakinis - T4 1
1486815 | 1 a +-152.84 | 418 | 17674.6 | vanduo karštas tiekiamasis - T3 1
1486826 | 1 a +-152.84 | 4807.29 | 12846.3 | vanduo karštas tiekiamasis - T3 1
1486845 | 1 a +-152.84 | 790 | 17715.9 | vanduo karštas apytakinis - T4 1
1486858 | 1 a +-152.84 | 4754.42 | 12948.2 | vanduo karštas apytakinis - T4 1
1486960 | 4 a V1 | 48 | 17674.6 | vanduo karštas tiekiamasis - T3 1
1486970 | 4 a V1 | 3241.86 | 17674.6 | vanduo karštas tiekiamasis - T3 1
1486978 | 4 a V1 | 90.5 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487011 | 4 a V1 | 920 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487021 | 4 a V1 | 1240 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487029 | 4 a V1 | 160 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487112 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487157 | 4 a V1 | 94 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487166 | 4 a V1 | 535.486 | 17674.6 | vanduo karštas tiekiamasis - T3 1
1487169 | 4 a V1 | 100 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487263 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487285 | 4 a V1 | 819.771 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487294 | 4 a V1 | 7749.95 | 17674.6 | vanduo karštas tiekiamasis - T3 1
1487297 | 4 a V1 | 355.148 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487309 | 4 a V1 | 150 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487319 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487361 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487383 | 4 a V1 | 340 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487392 | 4 a V1 | 1855.33 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487395 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487436 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487458 | 4 a V1 | 295 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487467 | 4 a V1 | 108.521 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487470 | 4 a V1 | 75 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487506 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487549 | 4 a V1 | 2452.23 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487608 | 4 a V1 | 28 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487614 | 4 a V1 | 55 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1487656 | 4 a V1 | 3047.58 | 14620 | vanduo karštas tiekiamasis - T3 1
1487678 | 4 a V1 | 512.419 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487687 | 4 a V1 | 1429.2 | 17674.6 | vanduo karštas tiekiamasis - T3 1
1487690 | 4 a V1 | 1776 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487698 | 4 a V1 | 592.326 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487708 | 4 a V1 | 356 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487716 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487806 | 4 a V1 | 3176.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487830 | 4 a V1 | 133 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1487841 | 4 a V1 | 469.78 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487844 | 4 a V1 | 230 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487883 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487907 | 4 a V1 | 140 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487916 | 4 a V1 | 2023.44 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1487919 | 4 a V1 | 101.437 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1487972 | 4 a V1 | 3176.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1487999 | 4 a V1 | 1706.52 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1488014 | 4 a V1 | 1383.45 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1488017 | 4 a V1 | 1256 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1488027 | 4 a V1 | 138.005 | 14590 | vanduo karštas tiekiamasis - T3 1
1488089 | 4 a V1 | 3043.58 | 14622 | vanduo karštas tiekiamasis - T3 1
1488111 | 4 a V1 | 124.822 | 14440 | vanduo karštas tiekiamasis - T3 1
1488120 | 4 a V1 | 3192.58 | 14472 | vanduo karštas tiekiamasis - T3 1
1488123 | 4 a V1 | 682.482 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1488142 | 4 a V1 | 593 | 17629.1 | vanduo šaltas - V1 2
1488155 | 4 a V1 | 2225.75 | 17626.8 | vanduo šaltas - V1 2
1488158 | 4 a V1 | 140 | 14442.3 | vanduo šaltas - V1 2
1488196 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1488216 | 4 a V1 | 245 | 17629.1 | vanduo šaltas - V1 2
1488227 | 4 a V1 | 2225.88 | 17629.1 | vanduo šaltas - V1 2
1488230 | 4 a V1 | 160 | 14442.3 | vanduo šaltas - V1 2
1488271 | 4 a V1 | 3146.82 | 14470 | vanduo šaltas - V1 2
1488291 | 4 a V1 | 978 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1488302 | 4 a V1 | 51.809 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1488305 | 4 a V1 | 172.197 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1488353 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1488380 | 4 a V1 | 43 | 17679.9 | vanduo karštas tiekiamasis - T3 1
1488389 | 4 a V1 | 2067.77 | 17677.6 | vanduo karštas tiekiamasis - T3 1
1488392 | 4 a V1 | 100.263 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1488442 | 4 a V1 | 3197.58 | 14470 | vanduo karštas tiekiamasis - T3 1
1488573 | 4 a V1 | 115 | 17715.9 | vanduo karštas apytakinis - T4 1
1488583 | 4 a V1 | 7645.99 | 17715.9 | vanduo karštas apytakinis - T4 1
1488599 | 4 a V1 | 3270 | 17715.9 | vanduo karštas apytakinis - T4 1
1488633 | 4 a V1 | 2740 | 17715.9 | vanduo karštas apytakinis - T4 1
1488642 | 4 a V1 | 1474.01 | 17715.9 | vanduo karštas apytakinis - T4 1
1488645 | 4 a V1 | 1540 | 17715.9 | vanduo karštas apytakinis - T4 1
1488656 | 4 a V1 | 4515 | 17715.9 | vanduo karštas apytakinis - T4 1
1488701 | 3 a | 1314 | 7907 | vanduo karštas tiekiamasis - T3 1
1488737 | 3 a | 1369.49 | 7885 | vanduo karštas apytakinis - T4 1
1488771 | 3 a | 9158 | 7946 | vanduo karštas tiekiamasis - T3 1
1488794 | 3 a | 9241 | 7917 | vanduo karštas apytakinis - T4 1
1488806 | 3 a | 396 | 17170 | vanduo karštas apytakinis - T4 1
1488830 | 3 a | 233 | 17117 | vanduo karštas tiekiamasis - T3 1
1489198 | 4 a V1 | 52.6325 | 17120 | vanduo karštas tiekiamasis - T3 1
1489214 | 4 a V1 | 176 | 17120 | vanduo karštas tiekiamasis - T3 1
1489222 | 4 a V1 | 5032.8 | 17120 | vanduo karštas tiekiamasis - T3 1
1489236 | 4 a V1 | 979.096 | 17120 | vanduo karštas tiekiamasis - T3 1
1489244 | 4 a V1 | 320.508 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489268 | 4 a V1 | 60 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489279 | 4 a V1 | 180 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1489315 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1489343 | 4 a V1 | 100 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489352 | 4 a V1 | 398.492 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489355 | 4 a V1 | 90 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1489402 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1489434 | 4 a V1 | 1358 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489443 | 4 a V1 | 1881.92 | 17120 | vanduo karštas tiekiamasis - T3 1
1489446 | 4 a V1 | 140 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1489481 | 4 a V1 | 2490 | 14620 | vanduo karštas tiekiamasis - T3 1
1489512 | 4 a V1 | 978 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489523 | 4 a V1 | 399.839 | 17120 | vanduo karštas tiekiamasis - T3 1
1489526 | 4 a V1 | 100 | 14592.3 | vanduo karštas tiekiamasis - T3 1
1489565 | 4 a V1 | 2490 | 14620 | vanduo karštas tiekiamasis - T3 1
1489590 | 4 a V1 | 778 | 17532.3 | vanduo šaltas - V1 2
1489601 | 4 a V1 | 571.64 | 17530 | vanduo šaltas - V1 2
1489604 | 4 a V1 | 80 | 14592.3 | vanduo šaltas - V1 2
1489639 | 4 a V1 | 2900 | 14620 | vanduo šaltas - V1 2
1489664 | 4 a V1 | 403.961 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489673 | 4 a V1 | 115.144 | 17120 | vanduo karštas tiekiamasis - T3 1
1489676 | 4 a V1 | 190 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489684 | 4 a V1 | 185 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1489718 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1489740 | 4 a V1 | 285 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489751 | 4 a V1 | 334.039 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489754 | 4 a V1 | 75 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1489798 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1489820 | 4 a V1 | 1978 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489833 | 4 a V1 | 2256.74 | 17120 | vanduo karštas tiekiamasis - T3 1
1489836 | 4 a V1 | 220 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1489870 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1489894 | 4 a V1 | 2838 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1489907 | 4 a V1 | 86.4599 | 17120 | vanduo karštas tiekiamasis - T3 1
1489910 | 4 a V1 | 153.337 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1489952 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1489994 | 4 a V1 | 1758 | 17122.3 | vanduo karštas tiekiamasis - T3 1
1490005 | 4 a V1 | 123.367 | 17120 | vanduo karštas tiekiamasis - T3 1
1490008 | 4 a V1 | 140 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1490047 | 4 a V1 | 2640 | 14470 | vanduo karštas tiekiamasis - T3 1
1490085 | 4 a V1 | 216 | 17170 | vanduo karštas apytakinis - T4 1
1490095 | 4 a V1 | 256 | 17170 | vanduo karštas apytakinis - T4 1
1490121 | 4 a V1 | 7296 | 17170 | vanduo karštas apytakinis - T4 1
1490131 | 4 a V1 | 3556 | 17170 | vanduo karštas apytakinis - T4 1
1490141 | 4 a V1 | 63 | 17170 | vanduo karštas apytakinis - T4 1
1490163 | 4 a V1 | 220 | 17572.3 | vanduo šaltas - V1 2
1490172 | 4 a V1 | 888.928 | 17572.3 | vanduo šaltas - V1 2
1490175 | 4 a V1 | 6720 | 17572.3 | vanduo šaltas - V1 2
1490183 | 4 a V1 | 75 | 14442.3 | vanduo šaltas - V1 2
1490234 | 4 a V1 | 3090 | 14470 | vanduo šaltas - V1 2
1490283 | 3 a | 93 | 12204.3 | vanduo karštas apytakinis - T4 1; vanduo karštas tiekiamasis - T3 14
1490292 | 2 a | 92.7896 | 12098.5 | vanduo karštas apytakinis - T4 1
1490298 | 3 a | 548 | 12243.3 | vanduo karštas tiekiamasis - T3 14
1490501 | 3 a | 6238 | 12804.3 | vanduo karštas tiekiamasis - T3 14
1490515 | 3 a | 4618 | 12843.3 | vanduo karštas tiekiamasis - T3 14
1490525 | 3 a | 1873 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1490551 | 2 a | 89.5 | 12059.5 | vanduo karštas apytakinis - T4 1
1490560 | 2 a | 8520.52 | 3526 | vanduo karštas apytakinis - T4 1
1490565 | 2 a | 55.5 | 12064.8 | vanduo karštas apytakinis - T4 1
1490593 | 2 a | 665 | 12092.5 | vanduo karštas apytakinis - T4 1
1490623 | 2 a | 6235 | 12769.8 | vanduo karštas apytakinis - T4 1
1490635 | 2 a | 4630 | 12797.5 | vanduo karštas apytakinis - T4 1
1490645 | 2 a | 1915 | 17439.8 | vanduo karštas apytakinis - T4 1
1490691 | 4 a V1 | 10620 | 17439.8 | vanduo karštas apytakinis - T4 1
