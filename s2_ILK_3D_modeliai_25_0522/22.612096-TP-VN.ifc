Properties of the parts of a building model (IFC2X3), part 29 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1454578_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454580_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454578_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454582_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454605_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454613_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454605_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454664_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454693_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454613_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454617_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454668_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454617_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454662_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454664_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454662_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454668_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454684_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454692_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454684_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454705_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454692_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454693_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454696_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454794_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454696_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454715_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454705_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454795_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454707_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454715_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454760_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454717_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454764_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454717_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454758_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454760_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454764_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454794_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454795_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454794_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454804_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454827_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454827_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454869_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454845_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454846_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454845_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455066_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454846_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455289_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454849_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455124_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454867_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455125_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454867_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454869_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454873_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454994_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454873_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454898_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454881_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454883_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454883_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454995_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454887_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454887_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454966_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454900_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454970_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454964_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454966_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454964_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454970_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454986_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454994_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454986_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455037_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454994_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454995_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454998_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455041_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454998_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455035_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455037_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455035_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455041_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455057_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455065_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455057_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455098_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455066_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455069_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455100_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455096_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455098_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455096_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455100_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455116_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455124_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455116_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455136_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455124_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455125_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455128_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455221_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455128_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455193_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455136_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455222_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455138_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455197_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455138_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455191_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455193_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455191_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455213_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455221_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455257_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455221_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455222_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455225_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455261_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455225_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455255_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455257_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455255_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455261_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455279_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455289_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455324_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455289_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455290_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455290_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455293_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455328_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455293_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455322_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455324_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455322_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455328_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455346_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455457_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455346_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455374_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455362_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455362_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455458_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455602_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455366_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455374_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455366_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455376_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455382_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455376_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455427_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455384_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455431_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455384_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455425_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455427_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455425_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455431_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455449_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455457_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455449_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455457_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455458_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455461_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455499_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455461_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455493_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455495_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455493_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455499_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455515_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455523_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455564_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455523_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455524_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455527_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455568_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455527_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455562_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455564_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455562_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455568_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1455584_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455602_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455584_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455614_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455602_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455603_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455603_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455836_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455606_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455688_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455606_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455660_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455689_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455616_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455664_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455616_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455658_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455660_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455658_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455664_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455680_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455766_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455680_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455703_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455688_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455688_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455767_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455692_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455703_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455692_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455736_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455705_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455738_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455705_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455734_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455736_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455734_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455738_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455758_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455766_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455766_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455770_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455770_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455802_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455804_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455802_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455824_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455836_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455824_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455884_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455836_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455837_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455837_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460041_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455840_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455888_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455840_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455882_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455884_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455882_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455888_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455915_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456032_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455915_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455937_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455925_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460042_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455925_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455926_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455925_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456033_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455926_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455929_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455929_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455948_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455939_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455948_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455939_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456004_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455950_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456008_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1455950_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456002_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456004_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456002_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456008_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456024_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456032_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456024_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456079_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456032_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456033_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456036_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456083_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456036_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456077_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456079_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456077_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456099_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456111_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456099_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456161_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456111_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456112_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456112_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456193_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456115_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456115_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456159_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456161_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456159_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456183_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456273_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456183_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456205_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456193_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456193_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456357_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456194_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456441_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456197_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456205_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456245_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456207_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456249_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456207_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456243_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456245_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456249_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456265_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456273_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456283_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456273_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456274_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456274_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456356_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456277_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456283_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456277_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456323_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456285_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456327_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456285_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456321_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456323_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456321_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456327_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456348_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456356_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456348_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456402_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456356_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456360_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456406_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456400_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456402_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456400_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456431_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456441_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456431_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456493_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456441_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456442_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456525_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456445_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456495_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456491_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456493_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456491_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456511_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456600_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456537_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456525_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456526_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456525_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456601_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456529_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456537_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456529_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456572_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456539_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456576_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456539_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456570_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456572_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456570_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456576_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456592_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456600_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456592_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456640_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456600_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456601_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456604_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456644_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456604_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456638_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456640_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456638_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456644_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456660_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456853_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456660_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456680_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456670_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456671_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456670_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457004_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456674_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456780_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456674_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456680_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456781_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456682_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456699_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456682_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456707_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456701_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456741_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456709_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456745_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456739_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456741_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456739_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456772_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456780_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456820_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456780_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456781_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456784_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456824_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456818_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456820_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456818_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456824_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456845_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456853_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456845_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456887_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456853_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456854_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456854_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456917_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456857_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456891_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456857_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456885_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456887_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456885_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456891_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456917_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456929_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456917_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456918_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456918_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457003_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456921_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456929_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456921_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456972_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456931_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456976_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456931_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456970_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456972_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456970_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456976_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456992_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457048_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456992_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457001_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457003_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457001_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457048_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457003_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457004_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457075_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457108_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457118_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457108_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457109_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457112_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457118_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457112_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457128_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457120_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457309_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457120_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457215_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457128_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457130_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457130_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459404_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457146_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457154_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457146_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457164_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457154_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457155_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457158_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457164_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457158_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457174_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457166_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457174_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457166_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457201_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457201_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457213_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457215_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457219_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457283_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457219_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457277_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457279_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457277_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457283_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457301_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457309_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457321_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457309_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457310_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457310_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457594_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457313_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457321_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457313_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457372_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457323_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457376_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457323_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457370_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457372_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457376_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457392_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457513_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457392_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457414_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457402_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457595_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457402_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457403_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457402_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457514_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457403_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457748_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457406_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457414_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457422_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457416_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457422_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457416_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457435_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457424_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457435_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457424_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457443_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457437_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457443_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457437_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457445_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457487_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457481_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457483_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457481_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457505_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457513_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457505_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457523_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457513_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457514_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457517_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457523_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457517_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457564_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457525_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457568_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457525_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457562_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457564_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457562_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457568_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457586_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457594_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457586_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457642_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457594_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457595_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457598_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457646_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457598_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457640_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457642_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457640_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457646_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457662_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457670_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457662_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457706_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457670_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457671_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457674_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457712_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457674_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457704_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457708_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457704_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457712_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457706_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457708_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457730_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457748_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457730_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457763_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457748_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457749_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457749_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457864_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457752_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457752_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457813_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457765_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457817_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457811_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457813_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457811_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457817_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457848_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457928_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457848_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457864_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457865_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457864_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458006_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457865_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458246_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457868_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457902_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457868_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457896_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457898_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457896_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457902_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457920_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457928_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457920_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457977_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457928_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457929_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457929_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458005_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457932_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457981_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457932_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457975_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457977_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457975_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457981_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457997_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458005_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458035_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458005_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458006_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458009_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458039_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458033_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458035_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458033_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458039_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458097_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458105_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458097_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458105_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458106_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458109_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458115_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458125_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458117_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458125_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458117_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458188_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458127_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458192_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458127_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458186_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458188_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458186_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458192_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458224_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458374_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458224_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458258_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458246_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458247_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458246_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458375_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458247_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458463_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458250_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458258_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458250_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458272_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458260_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458272_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458260_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458282_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458274_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458282_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458274_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458346_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458284_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458350_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458344_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458346_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458344_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458350_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458374_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458375_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458374_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458378_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458378_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458396_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458390_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458396_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458390_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458435_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458398_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458437_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458398_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458433_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458435_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458437_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458453_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458463_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458453_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458463_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458464_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458464_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458547_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458467_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458515_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458467_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458509_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458511_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458509_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458515_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458533_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458616_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458533_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458585_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458547_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458548_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458547_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458617_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458548_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458832_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458551_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458587_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458551_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458583_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458585_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458583_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458587_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458608_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458616_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458608_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458664_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458616_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458617_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458620_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458668_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458620_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458662_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458664_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458662_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458668_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458687_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458697_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458687_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458833_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458697_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458698_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458698_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459403_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458701_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458788_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458782_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458784_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458782_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458788_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458814_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458832_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458850_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458832_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458836_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459209_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458836_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458864_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458984_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458852_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458864_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458852_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458874_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458866_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458874_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458866_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458894_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458876_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458894_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458876_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458910_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458896_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458910_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458896_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458955_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458912_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458959_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458912_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458953_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458955_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458953_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458959_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458975_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459082_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458975_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458983_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459210_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458983_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458984_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458983_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459083_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458987_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459025_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1458987_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459021_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459023_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459021_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
