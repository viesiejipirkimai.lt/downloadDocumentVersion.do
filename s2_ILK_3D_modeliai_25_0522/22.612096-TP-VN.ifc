Properties of the parts of a building model (IFC2X3), part 57 of 57

# IfcFlowSegment: Pipe Types:Wavin Tigris Single Pipe (OD) - Standard (5778)
Name (Pipe Types:Wavin Tigris Single Pipe (OD) - Standard:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1490769 | 4 a V1 | 1221.17 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1490783 | 4 a V1 | 1784.96 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1490806 | 4 a V1 | 375 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1490814 | 4 a V1 | 80 | 14592.3 | vanduo karštas tiekiamasis - T3 13
1490856 | 4 a V1 | 2847.31 | 14620 | vanduo karštas tiekiamasis - T3 13
1490890 | 4 a V1 | 680 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1490901 | 4 a V1 | 54.0444 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1490904 | 4 a V1 | 59.4856 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1490952 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1490978 | 4 a V1 | 265 | 17532.3 | vanduo šaltas - V1 2
1490987 | 4 a V1 | 505.715 | 17532.3 | vanduo šaltas - V1 2
1490990 | 4 a V1 | 125 | 14442.3 | vanduo šaltas - V1 2
1491027 | 4 a V1 | 3050 | 14470 | vanduo šaltas - V1 2
1491049 | 4 a V1 | 335 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491058 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491066 | 4 a V1 | 128.98 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1491105 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491127 | 4 a V1 | 1595 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491136 | 4 a V1 | 1571.74 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491139 | 4 a V1 | 396 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491149 | 4 a V1 | 118 | 14590 | vanduo karštas tiekiamasis - T3 13
1491192 | 4 a V1 | 2843.31 | 14622 | vanduo karštas tiekiamasis - T3 13
1491212 | 4 a V1 | 198 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491221 | 4 a V1 | 3950.32 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491224 | 4 a V1 | 136.094 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1491263 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491294 | 4 a V1 | 198 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491303 | 4 a V1 | 1759.38 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491306 | 4 a V1 | 145.147 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1491355 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491377 | 4 a V1 | 178 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491386 | 4 a V1 | 57.0042 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491389 | 4 a V1 | 126.012 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1491428 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491450 | 4 a V1 | 116.407 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491459 | 4 a V1 | 1558.2 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491462 | 4 a V1 | 739 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491479 | 4 a V1 | 101.094 | 14592.3 | vanduo karštas tiekiamasis - T3 13
1491509 | 4 a V1 | 2847.31 | 14620 | vanduo karštas tiekiamasis - T3 13
1491529 | 4 a V1 | 595 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491538 | 4 a V1 | 1687.59 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491541 | 4 a V1 | 139 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491551 | 4 a V1 | 89.6862 | 14592.3 | vanduo karštas tiekiamasis - T3 13
1491598 | 4 a V1 | 2847.31 | 14620 | vanduo karštas tiekiamasis - T3 13
1491611 | 4 a V1 | 2900 | 14620 | vanduo šaltas - V1 2; vanduo karštas tiekiamasis - T3 13
1491614 | 4 a V1 | 498.138 | 17532.3 | vanduo šaltas - V1 2
1491630 | 4 a V1 | 218 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491639 | 4 a V1 | 60.5906 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491642 | 4 a V1 | 111.094 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1491675 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491697 | 4 a V1 | 78 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491706 | 4 a V1 | 60.5906 | 17477.3 | vanduo karštas tiekiamasis - T3 13
1491709 | 4 a V1 | 160 | 17479.6 | vanduo karštas tiekiamasis - T3 13
1491717 | 4 a V1 | 75.3629 | 14442.3 | vanduo karštas tiekiamasis - T3 13
1491742 | 4 a V1 | 2997.31 | 14470 | vanduo karštas tiekiamasis - T3 13
1491835 | 3 a | 1225 | 12383 | vanduo karštas tiekiamasis - T3 1
1491850 | 3 a | 149.916 | 13620.3 | vanduo karštas tiekiamasis - T3 1
1491892 | 4 a V1 | 230 | 13620.3 | vanduo karštas tiekiamasis - T3 1
1491901 | 3 a | 30.0843 | 13620.3 | vanduo karštas tiekiamasis - T3 1
1491904 | 4 a V1 | 1040 | 13620.3 | vanduo karštas tiekiamasis - T3 1
1491998 | 4 a V1 | 105.084 | 14442.3 | vanduo karštas tiekiamasis - T3 15
1492086 | 1 a +-152.84 | 6 | 17397 | vanduo karštas tiekiamasis - T3 1; vanduo karštas apytakinis - T4 1
1492089 | 1 a +-152.84 | 201.1 | 17177.9 | vanduo karštas tiekiamasis - T3 1
1492120 | 1 a +-152.84 | 4658.2 | 12528 | vanduo karštas apytakinis - T4 1
1492167 | 1 a +-152.84 | 295 | 17118.4 | vanduo karštas tiekiamasis - T3 1
1492178 | 1 a +-152.84 | 4480.77 | 12619.1 | vanduo karštas tiekiamasis - T3 1
1492201 | 4 a V1 | 2769.39 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492244 | 4 a V1 | 599 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492258 | 4 a V1 | 100 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492290 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492312 | 4 a V1 | 718 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492323 | 4 a V1 | 3686.04 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492326 | 4 a V1 | 180 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492334 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492394 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492418 | 4 a V1 | 718 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492427 | 4 a V1 | 3436.52 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492430 | 4 a V1 | 380 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492438 | 4 a V1 | 120 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492475 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492513 | 4 a V1 | 715 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492522 | 4 a V1 | 3995.12 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492525 | 4 a V1 | 279 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492545 | 4 a V1 | 129.5 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492625 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492647 | 4 a V1 | 850 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492656 | 4 a V1 | 6854.02 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492659 | 4 a V1 | 100.857 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492695 | 4 a V1 | 2627.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492735 | 4 a V1 | 1979.71 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492744 | 4 a V1 | 2812.9 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492747 | 4 a V1 | 756 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492755 | 4 a V1 | 339 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492769 | 4 a V1 | 100 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492833 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492855 | 4 a V1 | 102.077 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492864 | 4 a V1 | 3744.26 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492867 | 4 a V1 | 142.375 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1492909 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1492933 | 4 a V1 | 328 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492944 | 4 a V1 | 875.923 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1492947 | 4 a V1 | 6535 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492957 | 4 a V1 | 65 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1492967 | 4 a V1 | 135 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1493008 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1493045 | 4 a V1 | 1601.51 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1493068 | 4 a V1 | 5879.03 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1493071 | 4 a V1 | 1859 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1493095 | 4 a V1 | 2820 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1493103 | 4 a V1 | 215 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1493113 | 4 a V1 | 145 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1493149 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1493171 | 4 a V1 | 598 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1493183 | 4 a V1 | 73.3943 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1493213 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1493249 | 4 a V1 | 598.39 | 17131.2 | vanduo karštas tiekiamasis - T3 1
1493258 | 4 a V1 | 649.442 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1493318 | 4 a V1 | 1624.05 | 17128.9 | vanduo karštas tiekiamasis - T3 1
1493322 | 4 a V1 | 80 | 14442.3 | vanduo karštas tiekiamasis - T3 1
1493331 | 4 a V1 | 2648.9 | 14470 | vanduo karštas tiekiamasis - T3 1
1493355 | 4 a V1 | 14109.6 | 17199.5 | vanduo karštas apytakinis - T4 1
1493406 | 4 a V1 | 11775 | 17199.5 | vanduo karštas apytakinis - T4 1
1493415 | 4 a V1 | 10081.4 | 17199.5 | vanduo karštas apytakinis - T4 1
1493418 | 4 a V1 | 95 | 17199.5 | vanduo karštas apytakinis - T4 1
1493473 | 5 a V1 | 5322.1 | 21620 | vanduo karštas tiekiamasis - T3 1
1493501 | 5 a V1 | 6026.56 | 21620 | vanduo karštas tiekiamasis - T3 1
1493513 | 5 a V1 | 79 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1493535 | 5 a V1 | 180 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1493578 | 5 a V1 | 2640 | 18970 | vanduo karštas tiekiamasis - T3 1
1493626 | 5 a V1 | 118 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1493635 | 5 a V1 | 8723.62 | 21620 | vanduo karštas tiekiamasis - T3 1
1493638 | 5 a V1 | 155 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1493693 | 5 a V1 | 2640 | 18970 | vanduo karštas tiekiamasis - T3 1
1493717 | 5 a V1 | 158 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1493728 | 5 a V1 | 65.8171 | 21620 | vanduo karštas tiekiamasis - T3 1
1493731 | 5 a V1 | 3760 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1493741 | 5 a V1 | 100 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1493799 | 5 a V1 | 2640 | 18970 | vanduo karštas tiekiamasis - T3 1
1493827 | 5 a V1 | 6123.1 | 21620 | vanduo karštas tiekiamasis - T3 1
1493836 | 5 a V1 | 7187.9 | 21620 | vanduo karštas tiekiamasis - T3 1
1493839 | 5 a V1 | 1022.35 | 21620 | vanduo karštas tiekiamasis - T3 1
1493853 | 5 a V1 | 196 | 21620 | vanduo karštas tiekiamasis - T3 1
1493867 | 5 a V1 | 178 | 18940 | vanduo karštas tiekiamasis - T3 1
1493908 | 5 a V1 | 2636 | 18972 | vanduo karštas tiekiamasis - T3 1
1493930 | 5 a V1 | 198 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1493939 | 5 a V1 | 705.489 | 21620 | vanduo karštas tiekiamasis - T3 1
1493942 | 5 a V1 | 181.632 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1493983 | 5 a V1 | 2640 | 18970 | vanduo karštas tiekiamasis - T3 1
1494014 | 5 a V1 | 218 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1494023 | 5 a V1 | 448.157 | 21620 | vanduo karštas tiekiamasis - T3 1
1494026 | 5 a V1 | 75 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1494109 | 5 a V1 | 2640 | 18970 | vanduo karštas tiekiamasis - T3 1
1494131 | 5 a V1 | 2535 | 21620 | vanduo karštas tiekiamasis - T3 1
1494142 | 5 a V1 | 3385.9 | 21620 | vanduo karštas tiekiamasis - T3 1
1494145 | 5 a V1 | 99 | 21622.3 | vanduo karštas tiekiamasis - T3 1
1494159 | 5 a V1 | 168.394 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1494233 | 5 a V1 | 2640 | 18970 | vanduo karštas tiekiamasis - T3 1
1494270 | 5 a V1 | 5174.47 | 21557.3 | vanduo karštas apytakinis - T4 1
1494296 | 5 a V1 | 14800 | 21557.3 | vanduo karštas apytakinis - T4 1
1494318 | 5 a V1 | 9490 | 21557.3 | vanduo karštas apytakinis - T4 1
1494327 | 5 a V1 | 7345.53 | 21557.3 | vanduo karštas apytakinis - T4 1
1494360 | 1 a +-152.84 | 113 | 21687 | vanduo karštas tiekiamasis - T3 1
1494394 | 1 a +-152.84 | 270 | 21637 | vanduo karštas apytakinis - T4 1
1494441 | 5 a V1 | 3696 | 21690 | vanduo karštas tiekiamasis - T3 1
1494457 | 5 a V1 | 4336 | 21690 | vanduo karštas tiekiamasis - T3 1
1494471 | 5 a V1 | 2227.41 | 21690 | vanduo karštas tiekiamasis - T3 1
1494483 | 5 a V1 | 2616 | 21690 | vanduo karštas tiekiamasis - T3 1
1494507 | 5 a V1 | 7239 | 21692.3 | vanduo karštas tiekiamasis - T3 1
1494521 | 5 a V1 | 2740 | 21692.3 | vanduo karštas tiekiamasis - T3 1
1494531 | 5 a V1 | 140 | 21692.3 | vanduo karštas tiekiamasis - T3 1
1494556 | 5 a V1 | 60 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1494604 | 5 a V1 | 2710 | 18970 | vanduo karštas tiekiamasis - T3 1
1494658 | 5 a V1 | 378 | 21692.3 | vanduo karštas tiekiamasis - T3 1
1494675 | 5 a V1 | 1868.59 | 21690 | vanduo karštas tiekiamasis - T3 1
1494678 | 5 a V1 | 77.5513 | 18942.3 | vanduo karštas tiekiamasis - T3 1
1494728 | 5 a V1 | 2710 | 18970 | vanduo karštas tiekiamasis - T3 1
1494761 | 1 a +-152.84 | 4619.04 | 17004.7 | vanduo karštas apytakinis - T4 1
1494767 | 5 a V1 | 3680 | 21637 | vanduo karštas apytakinis - T4 1
1494777 | 5 a V1 | 4240 | 21637 | vanduo karštas apytakinis - T4 1
1494789 | 5 a V1 | 4180 | 21637 | vanduo karštas apytakinis - T4 1
1494799 | 5 a V1 | 2715 | 21637 | vanduo karštas apytakinis - T4 1
1494807 | 5 a V1 | 7235 | 21637 | vanduo karštas apytakinis - T4 1
1494817 | 5 a V1 | 2698.07 | 21637 | vanduo karštas apytakinis - T4 1

# IfcFlowTerminal: AB_Fire Hose System_Wall Mount_Electa Glass_Out:PU White 25 m_IndustriallJET_W500 D250 H650 mm (77)
Type - Material: AB_Fire Glass, AB_RAL9011_Graphite black, AB_RAL3000_Red, AB_Steel, AB_Hose White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bocciolone Antincendio S.p.a.
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Classification: D4030 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: PU White 25 m_IndustriallJET_W500 D250 H650 mm; sets with these values: 2
Name (AB_Fire Hose System_Wall Mount_Electa Glass_Out:PU White 25 m_IndustriallJET_W500 D250 H650 mm:...) | In
1831018 | 0 a
1831307 | 0 a
1831832 | 0 a
1831931 | 0 a
1831982 | 0 a
1833525 | 0 a
1833823 | 0 a
1833945 | 0 a
1834174 | 0 a
1834476 | 0 a
1835040 | 1 a +-152.84
1835071 | 1 a +-152.84
1835081 | 1 a +-152.84
1835109 | 1 a +-152.84
1836047 | 1 a +-152.84
1836073 | 1 a +-152.84
1836367 | 1 a +-152.84
1836393 | 1 a +-152.84
1836664 | 1 a +-152.84
1836700 | 1 a +-152.84
1836932 | 1 a +-152.84
1837052 | 1 a +-152.84
1837292 | 1 a +-152.84
1837459 | 2 a
1837711 | 2 a
1837827 | 2 a
1837870 | 2 a
1837937 | 2 a
1838105 | 2 a
1838220 | 2 a
1838320 | 2 a
1838428 | 2 a
1838637 | 2 a
1838741 | 2 a
1838865 | 2 a
1838992 | 2 a
1839774 | 2 a
1839942 | 2 a
1839968 | 2 a
1840000 | 2 a
1840075 | 2 a
1840175 | 2 a
1840644 | 2 a
1840747 | 2 a
1841157 | 2 a
1841180 | 2 a
1841528 | 3 a
1842062 | 3 a
1842093 | 3 a
1842101 | 3 a
1843019 | 3 a
1843044 | 3 a
1843073 | 3 a
1844920 | 3 a
1844940 | 3 a
1844964 | 3 a
1845378 | 3 a
1845395 | 3 a
1846283 | 4 a V1
1846317 | 4 a V1
1846329 | 4 a V1
1847161 | 4 a V1
1847171 | 4 a V1
1847184 | 4 a V1
1847842 | 4 a V1
1849118 | 4 a V1
1849127 | 4 a V1
1849138 | 4 a V1
1849709 | 4 a V1
1849724 | 4 a V1
1849835 | 5 a V1
1849961 | 5 a V1
1850088 | 5 a V1
1850210 | 5 a V1
1850314 | 5 a V1
1850472 | 5 a V1
1850756 | 5 a V1

# IfcFlowTerminal: PF_ST_UN_fixed height hygienic gully W200_ACO:W200 grade 1.4301 fixed height hygienic gully 142 outlet 75 (98)
Type - Description: ACO fixed height hygienic gully W200; PredefinedType: GULLYSUMP; Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: W200 grade 1.4301 fixed height hygienic gully 142 outlet 75; sets with these values: 2
Name (PF_ST_UN_fixed height hygienic gully W200_ACO:W200 grade 1.4301 fixed height hygienic gully 142 outlet 75:...) | In
1132644 | 5 a V1
1142121 | 5 a V1
1143851 | 5 a V1
1146003 | 5 a V1
1159398 | 4 a V1
1159446 | 4 a V1
1159459 | 4 a V1
1159475 | 4 a V1
1159495 | 4 a V1
1159511 | 4 a V1
1159525 | 4 a V1
1167975 | 4 a V1
1167987 | 4 a V1
1167999 | 4 a V1
1172215 | 4 a V1
1172229 | 4 a V1
1172245 | 4 a V1
1172257 | 4 a V1
1178090 | 4 a V1
1178108 | 4 a V1
1178120 | 4 a V1
1178134 | 4 a V1
1178152 | 4 a V1
1179306 | 4 a V1
1180544 | 4 a V1
1184456 | 4 a V1
1184472 | 4 a V1
1184482 | 4 a V1
1200604 | 4 a V1
1201443 | 4 a V1
1201455 | 4 a V1
1201469 | 4 a V1 | Group: Ūkio-buities nuotekos - F1 13
1201505 | 4 a V1
1201521 | 4 a V1 | Group: Ūkio-buities nuotekos - F1 14
1201539 | 4 a V1 | Group: Ūkio-buities nuotekos - F1 16
1201551 | 4 a V1 | Group: Ūkio-buities nuotekos - F1 16
1201567 | 4 a V1 | Group: Ūkio-buities nuotekos - F1 16
1242253 | 2 a
1244936 | 2 a
1246506 | 2 a
1260852 | 2 a
1262763 | 2 a
1265242 | 2 a
1266406 | 2 a
1267708 | 2 a | Group: Ūkio-buities nuotekos - F1 71
1269982 | 2 a
1270416 | 2 a
1272899 | 2 a
1272913 | 2 a
1274063 | 2 a
1274302 | 2 a
1278324 | 2 a
1278338 | 2 a
1278366 | 2 a
1284718 | 2 a
1284745 | 2 a
1284755 | 2 a
1284771 | 2 a
1284781 | 2 a | Group: nuotekos ūkio-buities - F1 4
1292352 | 2 a
1292996 | 2 a
1293523 | 2 a
1294383 | 2 a
1294949 | 2 a
1296322 | 2 a
1298332 | 2 a
1298356 | 2 a
1301274 | 2 a
1302703 | 2 a
1307638 | 1 a +-152.84
1307656 | 1 a +-152.84
1307668 | 1 a +-152.84
1309416 | 1 a +-152.84
1309428 | 1 a +-152.84
1309440 | 1 a +-152.84
1313496 | 1 a +-152.84
1313499 | 1 a +-152.84
1313502 | 1 a +-152.84
1313717 | 1 a +-152.84
1313720 | 1 a +-152.84
1313723 | 1 a +-152.84
1317862 | 1 a +-152.84
1318155 | 1 a +-152.84
1412918 | 0 a
1412962 | 0 a | Group: Ūkio-buities nuotekos - F1 75
1412984 | 0 a
1413002 | 0 a | Group: Ūkio-buities nuotekos - F1 75
1413016 | 0 a | Group: nuotekos ūkio-buities - F1 1
1413030 | 0 a
1413048 | 0 a
1413068 | 0 a | Group: nuotekos ūkio-buities - F1 4
1413082 | 0 a
1413094 | 0 a | Group: Ūkio-buities nuotekos - F1 16
1413106 | 0 a
1413120 | 0 a
1413136 | 0 a | Group: Ūkio-buities nuotekos - F1 16
1413150 | 0 a
1413166 | 0 a

# IfcFlowTerminal: Plumbing_Drainage_Zurn-Industries_Z1715_Roof-Drain:Threaded 3 (22)
Type - Material: Iron - Zurn Industries LLC - Cast Galvanized, Steel - Zurn Industries LLC - Stainless Type 304 CF8
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zurn Industries, LLC
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Classification: D2040200 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Threaded 3; sets with these values: 2
Name (Plumbing_Drainage_Zurn-Industries_Z1715_Roof-Drain:Threaded 3:...) | In
1146344 | stogas | Group: Lietaus nuotekos - L1 8
1150923 | stogas
1150936 | stogas
1150948 | stogas
1150958 | stogas
1150970 | stogas
1150980 | stogas
1150992 | stogas
1151002 | stogas
1151054 | 5 a V1
1151136 | 5 a V1
1151165 | 5 a V1
1151180 | 5 a V1
1151194 | 5 a V1
1151237 | 5 a V1
1151251 | 5 a V1
1151269 | 5 a V1
1151279 | 5 a V1
1151299 | 5 a V1
1151345 | 5 a V1
1151360 | 5 a V1
1151384 | 5 a V1

# IfcFlowTerminal: ZZZ_do not use_PF_ST_UN_fixed height hygienic gully_ACO:std (nested) (98)
Type - Description: ACO fixed height hygienic gully; PredefinedType: USERDEFINED; Material: Stainless steel, 1.4301
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: std (nested); sets with these values: 2
Name (ZZZ_do not use_PF_ST_UN_fixed height hygienic gully_ACO:std (nested):...) | In
1132645 | 5 a V1
1142122 | 5 a V1
1143852 | 5 a V1
1146004 | 5 a V1
1159399 | 4 a V1
1159447 | 4 a V1
1159460 | 4 a V1
1159476 | 4 a V1
1159496 | 4 a V1
1159512 | 4 a V1
1159526 | 4 a V1
1167976 | 4 a V1
1167988 | 4 a V1
1168000 | 4 a V1
1172216 | 4 a V1
1172230 | 4 a V1
1172246 | 4 a V1
1172258 | 4 a V1
1178091 | 4 a V1
1178109 | 4 a V1
1178121 | 4 a V1
1178135 | 4 a V1
1178153 | 4 a V1
1179307 | 4 a V1
1180545 | 4 a V1
1184457 | 4 a V1
1184473 | 4 a V1
1184483 | 4 a V1
1200605 | 4 a V1
1201444 | 4 a V1
1201456 | 4 a V1
1201470 | 4 a V1
1201506 | 4 a V1
1201522 | 4 a V1
1201540 | 4 a V1
1201552 | 4 a V1
1201568 | 4 a V1
1242254 | 2 a
1244937 | 2 a
1246507 | 2 a
1260853 | 2 a
1262764 | 2 a
1265243 | 2 a
1266407 | 2 a
1267709 | 2 a
1269983 | 2 a
1270417 | 2 a
1272900 | 2 a
1272914 | 2 a
1274064 | 2 a
1274303 | 2 a
1278325 | 2 a
1278339 | 2 a
1278367 | 2 a
1284719 | 2 a
1284746 | 2 a
1284756 | 2 a
1284772 | 2 a
1284782 | 2 a
1292353 | 2 a
1292997 | 2 a
1293524 | 2 a
1294384 | 2 a
1294950 | 2 a
1296323 | 2 a
1298333 | 2 a
1298357 | 2 a
1301275 | 2 a
1302704 | 2 a
1307639 | 1 a +-152.84
1307657 | 1 a +-152.84
1307669 | 1 a +-152.84
1309417 | 1 a +-152.84
1309429 | 1 a +-152.84
1309441 | 1 a +-152.84
1313497 | 1 a +-152.84
1313500 | 1 a +-152.84
1313503 | 1 a +-152.84
1313718 | 1 a +-152.84
1313721 | 1 a +-152.84
1313724 | 1 a +-152.84
1317863 | 1 a +-152.84
1318156 | 1 a +-152.84
1412919 | 0 a
1412963 | 0 a
1412985 | 0 a
1413003 | 0 a
1413017 | 0 a
1413031 | 0 a
1413049 | 0 a
1413069 | 0 a
1413083 | 0 a
1413095 | 0 a
1413107 | 0 a
1413121 | 0 a
1413137 | 0 a
1413151 | 0 a
1413167 | 0 a

# IfcFlowTerminal: ZZZ_do not use_PF_ST_UN_square grating for hygienic gully_ACO:std (nested) (98)
Type - Description: ACO square grating for hygienic gully; PredefinedType: GULLYSUMP; Material: Stainless steel, 1.4301
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: std (nested); sets with these values: 2
Name (ZZZ_do not use_PF_ST_UN_square grating for hygienic gully_ACO:std (nested):...) | In
1132646 | 5 a V1
1142123 | 5 a V1
1143853 | 5 a V1
1146005 | 5 a V1
1159400 | 4 a V1
1159448 | 4 a V1
1159461 | 4 a V1
1159477 | 4 a V1
1159497 | 4 a V1
1159513 | 4 a V1
1159527 | 4 a V1
1167977 | 4 a V1
1167989 | 4 a V1
1168001 | 4 a V1
1172217 | 4 a V1
1172231 | 4 a V1
1172247 | 4 a V1
1172259 | 4 a V1
1178092 | 4 a V1
1178110 | 4 a V1
1178122 | 4 a V1
1178136 | 4 a V1
1178154 | 4 a V1
1179308 | 4 a V1
1180546 | 4 a V1
1184458 | 4 a V1
1184474 | 4 a V1
1184484 | 4 a V1
1200606 | 4 a V1
1201445 | 4 a V1
1201457 | 4 a V1
1201471 | 4 a V1
1201507 | 4 a V1
1201523 | 4 a V1
1201541 | 4 a V1
1201553 | 4 a V1
1201569 | 4 a V1
1242255 | 2 a
1244938 | 2 a
1246508 | 2 a
1260854 | 2 a
1262765 | 2 a
1265244 | 2 a
1266408 | 2 a
1267710 | 2 a
1269984 | 2 a
1270418 | 2 a
1272901 | 2 a
1272915 | 2 a
1274065 | 2 a
1274304 | 2 a
1278326 | 2 a
1278340 | 2 a
1278368 | 2 a
1284720 | 2 a
1284747 | 2 a
1284757 | 2 a
1284773 | 2 a
1284783 | 2 a
1292354 | 2 a
1292998 | 2 a
1293525 | 2 a
1294385 | 2 a
1294951 | 2 a
1296324 | 2 a
1298334 | 2 a
1298358 | 2 a
1301276 | 2 a
1302705 | 2 a
1307640 | 1 a +-152.84
1307658 | 1 a +-152.84
1307670 | 1 a +-152.84
1309418 | 1 a +-152.84
1309430 | 1 a +-152.84
1309442 | 1 a +-152.84
1313498 | 1 a +-152.84
1313501 | 1 a +-152.84
1313504 | 1 a +-152.84
1313719 | 1 a +-152.84
1313722 | 1 a +-152.84
1313725 | 1 a +-152.84
1317864 | 1 a +-152.84
1318157 | 1 a +-152.84
1412920 | 0 a
1412964 | 0 a
1412986 | 0 a
1413004 | 0 a
1413018 | 0 a
1413032 | 0 a
1413050 | 0 a
1413070 | 0 a
1413084 | 0 a
1413096 | 0 a
1413108 | 0 a
1413122 | 0 a
1413138 | 0 a
1413152 | 0 a
1413168 | 0 a
