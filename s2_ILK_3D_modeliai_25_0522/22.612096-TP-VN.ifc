Properties of the parts of a building model (IFC2X3), part 33 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1477404_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477337_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477398_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477400_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477398_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477420_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477428_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477420_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477472_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477428_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477429_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477429_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477500_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477432_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477474_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477432_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477470_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477472_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477470_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477474_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477490_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477500_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477490_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477512_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477500_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477501_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477504_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477512_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477504_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477574_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477514_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477578_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477514_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477572_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477574_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477572_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477578_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477602_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477612_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477602_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477612_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477624_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477951_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477626_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477950_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477626_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477673_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477648_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477791_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477648_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477687_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477673_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477675_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477856_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477679_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477687_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477695_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477689_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477695_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477697_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477762_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477756_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477758_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477756_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477762_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477783_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477791_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477783_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477827_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477791_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477792_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477792_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477855_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477795_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477831_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477795_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477825_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477827_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477825_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477831_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477847_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477855_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477847_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477918_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477855_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477859_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477920_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477859_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477916_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477918_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477916_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477920_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477950_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477951_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477950_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477954_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477954_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477990_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477982_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477990_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477982_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477998_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477992_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478136_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477992_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478014_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477998_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478430_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478000_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478014_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478000_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478022_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478016_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478024_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478016_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478102_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478022_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478024_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478028_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478106_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478028_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478100_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478102_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478100_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478106_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478128_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478136_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478128_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478183_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478136_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478137_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478137_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478140_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478189_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478140_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478181_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478185_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478181_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478189_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478183_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478185_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478213_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478214_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478213_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478217_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478214_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478316_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478217_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478229_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478223_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478229_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478223_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478286_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478231_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478290_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478231_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478284_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478286_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478290_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478308_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478316_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478308_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478316_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478317_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478317_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478366_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478320_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 12
Port_1478320_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 12
Port_1478326_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478358_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478366_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478401_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478366_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478367_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478367_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478429_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478370_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478403_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478399_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478401_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478399_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478403_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478421_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478429_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478421_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478442_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478429_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478430_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478433_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478454_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478444_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478548_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478444_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478467_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478454_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478549_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478456_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478467_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478456_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478477_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478469_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478477_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478469_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478518_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478479_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478522_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478479_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478516_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478518_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478516_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478538_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478676_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478563_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478548_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478549_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478548_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478677_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478552_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478803_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478552_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478804_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478565_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478571_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478565_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478573_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478659_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478625_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478627_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478668_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478676_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478668_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478689_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478676_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478677_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478680_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478680_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478691_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478699_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478691_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478701_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478707_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478709_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478771_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478765_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478767_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478771_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478787_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478803_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478787_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478815_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478803_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478807_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478807_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478823_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478817_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478823_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478817_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478825_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478860_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478825_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478854_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478856_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478854_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478860_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1478885_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479113_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478885_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478907_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478897_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478907_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478897_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478920_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478909_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478920_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478909_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478930_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478922_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478930_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478922_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478944_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478932_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478976_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478932_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478954_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478944_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478977_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478946_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478954_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478946_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478968_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478976_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478968_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478986_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478976_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478977_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478980_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478986_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478980_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479031_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478988_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479076_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1478988_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479041_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479031_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479077_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479033_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479041_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479033_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479068_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479076_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479068_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479088_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479076_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479077_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479080_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479088_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479080_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479096_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479090_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479096_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479090_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479113_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479124_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479124_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479143_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479134_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479143_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479134_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479165_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479488_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479165_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479572_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479177_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479179_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479177_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479489_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479210_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479226_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479210_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479320_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479226_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479228_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480105_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479320_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480106_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479482_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479488_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479482_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479503_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479488_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479489_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479492_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479503_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479492_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479513_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479505_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479513_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479505_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479538_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479515_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479538_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479515_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479562_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479572_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479562_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479585_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479574_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479585_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479574_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479593_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479587_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480976_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479587_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481002_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479593_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480977_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479613_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479635_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479623_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479625_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479623_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480010_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479629_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479865_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479629_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479635_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479940_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479637_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479765_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479637_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479657_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479649_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479659_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479649_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479719_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479657_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479663_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479723_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479663_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479717_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479719_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479717_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479723_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479765_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479776_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479776_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479788_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479838_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479788_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479831_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479833_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479831_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479838_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479857_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479865_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479857_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479911_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479865_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479866_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479866_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479939_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479869_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479915_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479869_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479909_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479911_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479909_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479915_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479931_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479939_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479931_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479977_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479939_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479940_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479943_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479979_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479975_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479977_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479975_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479979_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479997_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480009_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480021_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480009_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480013_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480021_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480013_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480023_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480069_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480063_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480063_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480097_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480470_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480097_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480115_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480105_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480106_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480105_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480471_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480109_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480314_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480109_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480125_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480115_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480399_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480117_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480237_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480117_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480142_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480125_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480238_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480127_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480144_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480127_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480203_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480142_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480144_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480148_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480207_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480148_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480201_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480203_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480201_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480207_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480227_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480237_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480227_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480286_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480237_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480241_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480290_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480241_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480284_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480286_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480290_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480306_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480314_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480306_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480324_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480314_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480315_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480315_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480398_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480318_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480324_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480318_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480368_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480326_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480372_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480366_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480368_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480366_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480372_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480390_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480398_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480390_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480408_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480398_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480399_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480402_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480408_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480402_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480410_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480444_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480440_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480442_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480440_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480444_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480460_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480470_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480460_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480485_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480470_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480471_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480474_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480485_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480474_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480496_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480487_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480693_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480506_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480496_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480809_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480498_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480498_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480547_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480578_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480508_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480549_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480545_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480547_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480545_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480549_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480569_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480577_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480569_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480643_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480577_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480578_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480581_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480647_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480581_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480641_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480643_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480641_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480647_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480683_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480693_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480683_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480703_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480693_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480694_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480694_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480894_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480697_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480703_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480713_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480705_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480713_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480705_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480715_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480778_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480715_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480772_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480774_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480778_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480800_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480808_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480800_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480818_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480895_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480809_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480812_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480818_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480812_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480862_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480820_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480864_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480820_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480860_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480862_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480860_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480864_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480886_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480894_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480886_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480904_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480894_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480895_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480898_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480904_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480948_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480906_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480950_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480906_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480946_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480948_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480946_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480950_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1480968_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480976_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480968_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480976_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480977_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480994_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481002_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1480994_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481010_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481004_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481010_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481004_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481030_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481040_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481030_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481183_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481058_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481064_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481058_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481371_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481084_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481104_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481084_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481114_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481104_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481183_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481106_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481269_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481106_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481122_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481114_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481270_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481116_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481122_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481116_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481204_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481196_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481204_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481196_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481245_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481206_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481245_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481206_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481261_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481269_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481261_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481287_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481269_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481270_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481273_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481287_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481273_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481295_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481289_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481295_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481289_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481312_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481297_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481312_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481297_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481341_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481314_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481341_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481314_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481357_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481398_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481369_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481371_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481390_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482628_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481390_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481406_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481398_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482629_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481400_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482435_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481400_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482110_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482436_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481408_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481734_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481408_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481426_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481418_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481426_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481418_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481436_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481428_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481567_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481436_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481438_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481438_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481568_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481442_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481535_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481529_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481531_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481529_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481535_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481555_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481567_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481555_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481622_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481567_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481568_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481571_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481626_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481620_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481622_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481620_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481626_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481726_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481734_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481726_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481818_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481734_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481735_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481735_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481848_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481738_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481822_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481738_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481816_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481818_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481816_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481822_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481840_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481848_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481840_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481909_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481848_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481849_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481939_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481852_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481913_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481852_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481909_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481913_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481931_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482036_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481931_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481951_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481939_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481940_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481939_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482037_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481940_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482110_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481943_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481951_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481959_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481953_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481959_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481953_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482008_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481961_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482012_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481961_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482006_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482008_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482006_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482012_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482028_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482036_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482028_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482087_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482036_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482037_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482040_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482091_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482040_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482085_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482087_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482110_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482265_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482121_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482264_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482121_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482152_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482131_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482154_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482131_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482224_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482152_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482154_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482158_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482228_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482158_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482222_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482224_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482222_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482252_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482264_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482264_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482268_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482359_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
