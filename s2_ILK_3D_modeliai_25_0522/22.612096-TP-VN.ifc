Properties of the parts of a building model (IFC2X3), part 40 of 57

# IfcFlowFitting: PIF_AS+_Super_Bend_Wavin:socket end (1994)
Name (PIF_AS+_Super_Bend_Wavin:socket end:...) | In | Group
1297959 | 2 a | Ūkio-buities nuotekos - F1 19
1298061 | 2 a | Ūkio-buities nuotekos - F1 19
1298067 | 2 a | Ūkio-buities nuotekos - F1 19
1298162 | 2 a | Ūkio-buities nuotekos - F1 19
1298238 | 2 a | Ūkio-buities nuotekos - F1 19
1298292 | 2 a | Ūkio-buities nuotekos - F1 78
1298756 | 2 a | Ūkio-buities nuotekos - F1 19
1298801 | 2 a | Ūkio-buities nuotekos - F1 19
1298809 | 2 a | Ūkio-buities nuotekos - F1 19
1298895 | 2 a | Ūkio-buities nuotekos - F1 19
1298938 | 2 a | Ūkio-buities nuotekos - F1 19
1298944 | 2 a | Ūkio-buities nuotekos - F1 19
1299049 | 2 a | Ūkio-buities nuotekos - F1 19
1299057 | 2 a | Ūkio-buities nuotekos - F1 19
1299246 | 2 a | Ūkio-buities nuotekos - F1 79
1299290 | 2 a | Ūkio-buities nuotekos - F1 19
1299330 | 2 a | Ūkio-buities nuotekos - F1 19
1299336 | 2 a | Ūkio-buities nuotekos - F1 19
1299403 | 2 a | Ūkio-buities nuotekos - F1 19
1299528 | 2 a | Ūkio-buities nuotekos - F1 19
1299571 | 2 a | Ūkio-buities nuotekos - F1 19
1299577 | 2 a | Ūkio-buities nuotekos - F1 19
1299655 | 2 a | Ūkio-buities nuotekos - F1 19
1299729 | 2 a | Ūkio-buities nuotekos - F1 19
1299768 | 2 a | Ūkio-buities nuotekos - F1 19
1299803 | 2 a | Ūkio-buities nuotekos - F1 80
1300089 | 2 a | Ūkio-buities nuotekos - F1 81
1300200 | 2 a | Ūkio-buities nuotekos - F1 81
1300467 | 2 a | Ūkio-buities nuotekos - F1 81
1300658 | 2 a | Ūkio-buities nuotekos - F1 81
1300699 | 2 a | Ūkio-buities nuotekos - F1 81
1300705 | 2 a | Ūkio-buities nuotekos - F1 81
1301029 | 2 a | Ūkio-buities nuotekos - F1 81
1301035 | 2 a | Ūkio-buities nuotekos - F1 81
1301148 | 2 a | Ūkio-buities nuotekos - F1 81
1301162 | 2 a | Ūkio-buities nuotekos - F1 81
1301207 | 2 a | Ūkio-buities nuotekos - F1 81
1301399 | 2 a | Ūkio-buities nuotekos - F1 19
1301450 | 2 a | Ūkio-buities nuotekos - F1 19
1301456 | 2 a | Ūkio-buities nuotekos - F1 19
1301501 | 2 a | Ūkio-buities nuotekos - F1 19
1301540 | 2 a | Ūkio-buities nuotekos - F1 19
1301548 | 2 a | Ūkio-buities nuotekos - F1 19
1301725 | 2 a | Ūkio-buities nuotekos - F1 81
1301751 | 2 a | Ūkio-buities nuotekos - F1 82
1301901 | 2 a | Ūkio-buities nuotekos - F1 19
1301947 | 2 a | Ūkio-buities nuotekos - F1 19
1302064 | 2 a | Ūkio-buities nuotekos - F1 19
1302105 | 2 a | Ūkio-buities nuotekos - F1 19
1302667 | 2 a | Ūkio-buities nuotekos - F1 81
1302673 | 2 a | Ūkio-buities nuotekos - F1 81
1302749 | 2 a | Ūkio-buities nuotekos - F1 81
1302790 | 2 a | Ūkio-buities nuotekos - F1 81
1302796 | 2 a | Ūkio-buities nuotekos - F1 81
1302986 | 2 a | Ūkio-buities nuotekos - F1 81
1303066 | 2 a | Ūkio-buities nuotekos - F1 81
1303072 | 2 a | Ūkio-buities nuotekos - F1 81
1303171 | 2 a | Ūkio-buities nuotekos - F1 81
1303177 | 2 a | Ūkio-buities nuotekos - F1 81
1303794 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1303808 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1303820 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1303845 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1303978 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1304282 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1304320 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1304738 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1304744 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1304846 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1304926 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305030 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 83
1305038 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 83
1305210 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305224 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305309 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305317 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305349 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305546 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305651 | 0 a | Ūkio-buities nuotekos - F1 2
1305900 | 2 a | Ūkio-buities nuotekos - F1 71
1306482 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1306567 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1306575 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1306717 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1306725 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307005 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307318 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307497 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307861 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1307873 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1307955 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1307961 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308005 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308070 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308185 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308235 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308241 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308478 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308484 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308586 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308592 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308958 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309015 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309189 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309321 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309576 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309657 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309665 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309709 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309715 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309823 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309831 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309943 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309951 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310016 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310087 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310093 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310166 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310360 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310366 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310515 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310562 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310654 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310662 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310802 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310810 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310932 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310940 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310989 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1311059 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1311065 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1311315 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1311337 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1311672 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1311757 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1311763 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1312136 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1312142 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1312233 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 85
1312458 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1312464 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313002 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1313048 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313054 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313160 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313270 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313276 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313315 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 86
1313378 | 2 a | Ūkio-buities nuotekos - F1 87
1313396 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313406 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313412 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313430 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313436 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313452 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313468 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313490 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313517 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313523 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313531 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313537 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313553 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313569 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313591 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313601 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313607 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313625 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313631 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313649 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313655 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313671 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313679 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313695 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313711 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313736 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313746 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313752 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313770 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313774 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313782 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313788 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313806 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313812 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313828 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313838 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313844 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313864 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313876 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313882 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313898 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313906 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313916 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313922 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313940 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313946 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313964 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313970 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313986 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313996 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1314002 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1316265 | 4 a V1 | K1 2
1316362 | 1 a +-152.84 | K1 2
1316588 | 1 a +-152.84 | K1 2
1316596 | 1 a +-152.84 | K1 2
1316707 | 1 a +-152.84 | K1 2
1316715 | 1 a +-152.84 | K1 2
1316788 | 1 a +-152.84 | K1 2
1316796 | 1 a +-152.84 | K1 2
1316889 | 1 a +-152.84 | K1 2
1316897 | 1 a +-152.84 | K1 2
1317026 | 1 a +-152.84 | K1 2
1317076 | 1 a +-152.84 | K1 2
1317082 | 1 a +-152.84 | K1 2
1317129 | 1 a +-152.84 | K1 2
1317169 | 1 a +-152.84 | K1 2
1317177 | 1 a +-152.84 | K1 2
1317289 | 1 a +-152.84 | K1 2
1317295 | 1 a +-152.84 | K1 2
1317378 | 1 a +-152.84 | K1 2
1317384 | 1 a +-152.84 | K1 2
1317473 | 1 a +-152.84 | K1 2
1317562 | 1 a +-152.84 | K1 2
1317568 | 1 a +-152.84 | K1 2
1317624 | 1 a +-152.84 | K1 2
1317669 | 1 a +-152.84 | K1 2
1317783 | 1 a +-152.84 | K1 2
1318003 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1318090 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318211 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318307 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318313 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318340 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 88
1318390 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318471 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318477 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318644 | 2 a | Ūkio-buities nuotekos - F1 69
1318741 | 2 a | Ūkio-buities nuotekos - F1 69
1318830 | 2 a | Ūkio-buities nuotekos - F1 69
1318906 | 2 a | Ūkio-buities nuotekos - F1 69
1318912 | 2 a | Ūkio-buities nuotekos - F1 69
1319053 | 2 a | Ūkio-buities nuotekos - F1 69
1319254 | 2 a | Ūkio-buities nuotekos - F1 69
1319319 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319327 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319748 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319756 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319905 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319913 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320045 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320053 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320233 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320272 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320278 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320409 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320415 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320465 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320479 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320526 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320532 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320610 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320616 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320721 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320727 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1411647 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1411794 | 0 a | Ūkio-buities nuotekos - F1 75
1411853 | 0 a | Ūkio-buities nuotekos - F1 75
1411859 | 0 a | Ūkio-buities nuotekos - F1 75
1412248 | 0 a | Ūkio-buities nuotekos - F1 75
1412260 | 0 a | Ūkio-buities nuotekos - F1 75
1412540 | 2 a | Ūkio-buities nuotekos - F1 75
1412668 | 0 a | Ūkio-buities nuotekos - F1 75
1412877 | 0 a | Ūkio-buities nuotekos - F1 75
1413241 | 0 a | Ūkio-buities nuotekos - F1 75
1413247 | 0 a | Ūkio-buities nuotekos - F1 75
1413634 | 0 a | Ūkio-buities nuotekos - F1 75
1413733 | 0 a | Ūkio-buities nuotekos - F1 75
1414162 | 0 a | Ūkio-buities nuotekos - F1 75
1414168 | 0 a | Ūkio-buities nuotekos - F1 75
1414300 | 0 a | Ūkio-buities nuotekos - F1 75
1414356 | 0 a | Ūkio-buities nuotekos - F1 75
1414364 | 0 a | Ūkio-buities nuotekos - F1 75
1414522 | 0 a | Ūkio-buities nuotekos - F1 75
1414530 | 0 a | Ūkio-buities nuotekos - F1 75
1414591 | 0 a | Ūkio-buities nuotekos - F1 75
1414678 | 0 a | Ūkio-buities nuotekos - F1 75
1414684 | 0 a | Ūkio-buities nuotekos - F1 75
1414719 | 0 a | Ūkio-buities nuotekos - F1 75
1414914 | 0 a | Ūkio-buities nuotekos - F1 75
1415033 | 2 a | Ūkio-buities nuotekos - F1 75
1415105 | 2 a | nuotekos ūkio-buities - F1 1
1415361 | 2 a | nuotekos ūkio-buities - F1 1
1415375 | 0 a | nuotekos ūkio-buities - F1 1
1415519 | 0 a | nuotekos ūkio-buities - F1 1
1415613 | 0 a | nuotekos ūkio-buities - F1 1
1415619 | 0 a | nuotekos ūkio-buities - F1 1
1415855 | 0 a | nuotekos ūkio-buities - F1 1
1415891 | 0 a | nuotekos ūkio-buities - F1 1
1415981 | 0 a | nuotekos ūkio-buities - F1 1
1415987 | 0 a | nuotekos ūkio-buities - F1 1
1416119 | 1 a +-152.84 | nuotekos ūkio-buities - F1 4
1416149 | 1 a +-152.84 | nuotekos ūkio-buities - F1 4
1416314 | 0 a | nuotekos ūkio-buities - F1 4
1416431 | 0 a | nuotekos ūkio-buities - F1 4
1416437 | 0 a | nuotekos ūkio-buities - F1 4
1416663 | 0 a | nuotekos ūkio-buities - F1 4
1416669 | 0 a | nuotekos ūkio-buities - F1 4
1416796 | 0 a | nuotekos ūkio-buities - F1 4
1416829 | 0 a | nuotekos ūkio-buities - F1 4
1416894 | 0 a | nuotekos ūkio-buities - F1 4
1417060 | 0 a | nuotekos ūkio-buities - F1 4
1417094 | 0 a | nuotekos ūkio-buities - F1 4
1417286 | 2 a | Ūkio-buities nuotekos - F1 16
1417456 | 0 a | Ūkio-buities nuotekos - F1 16
1417470 | 0 a | Ūkio-buities nuotekos - F1 16
1417827 | 0 a | Ūkio-buities nuotekos - F1 16
1417893 | 0 a | Ūkio-buities nuotekos - F1 16
1417901 | 0 a | Ūkio-buities nuotekos - F1 16
1417940 | 2 a | Ūkio-buities nuotekos - F1 16
1418158 | 0 a | Ūkio-buities nuotekos - F1 16
1418422 | 0 a | Ūkio-buities nuotekos - F1 16
1418816 | 0 a | Ūkio-buities nuotekos - F1 16
1418875 | 0 a | Ūkio-buities nuotekos - F1 75
1419005 | 0 a | Ūkio-buities nuotekos - F1 75
1419052 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1419153 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1419240 | 2 a | Ūkio-buities nuotekos - F1 87
1419336 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1419476 | 2 a | Ūkio-buities nuotekos - F1 69
1419566 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1497991 | 5 a V1 | L1 1
1498258 | 5 a V1 | L1 2
1498272 | 5 a V1 | L1 2
1498383 | 5 a V1 | L1 2
1498476 | 5 a V1 | L1 3
1498484 | 5 a V1 | L1 3
1498494 | 5 a V1 | L1 3
1498709 | 5 a V1 | Lietaus nuotekos - L1 10
1498751 | 5 a V1 | Lietaus nuotekos - L1 10
1498818 | 0 a | Lietaus nuotekos - L1 10
1498861 | 5 a V1 | Lietaus nuotekos - L1 10
1499009 | 5 a V1 | Lietaus nuotekos - L1 10
1499060 | 5 a V1 | Lietaus nuotekos - L1 10
1499064 | 5 a V1 | Lietaus nuotekos - L1 10
1499094 | 5 a V1 | Lietaus nuotekos - L1 10
1499199 | 0 a | Lietaus nuotekos - L1 11
1500741 | 0 a | Lietaus nuotekos - L1 11
1501804 | 0 a | Ūkio-buities nuotekos - F1 84
1501850 | 0 a | Ūkio-buities nuotekos - F1 84
1502319 | 0 a | Ūkio-buities nuotekos - F1 87
1502496 | 0 a | Ūkio-buities nuotekos - F1 87
1502906 | 0 a | Lietaus nuotekos - L1 13
1502914 | 0 a | Lietaus nuotekos - L1 13
1503297 | 4 a V1 | Ūkio-buities nuotekos - F1 17
1503343 | 4 a V1 | Ūkio-buities nuotekos - F1 17
1503355 | 0 a | Ūkio-buities nuotekos - F1 17
1503544 | 5 a V1 | L1 4
1503681 | 0 a | nuotekos ūkio-buities - F1 4
1504082 | 2 a | Ūkio-buities nuotekos - F1 16
1504104 | 0 a | Ūkio-buities nuotekos - F1 16
1504146 | 2 a | Ūkio-buities nuotekos - F1 81
1506149 | 0 a | Ūkio-buities nuotekos - F1 12
1506193 | 0 a | Ūkio-buities nuotekos - F1 12
1506207 | 0 a | Ūkio-buities nuotekos - F1 12
1506618 | 2 a | Ūkio-buities nuotekos - F1 17
1506632 | 2 a | Ūkio-buities nuotekos - F1 17
1856019 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1856033 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1856643 | 5 a V1 | F1 4
1856683 | 5 a V1 | F1 4
1856863 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1857394 | 5 a V1 | K1 4
1857400 | 5 a V1 | K1 4
1857412 | 5 a V1 | K1 4
1857469 | 5 a V1 | K1 4
1857475 | 5 a V1 | K1 4
1857577 | 5 a V1 | K1 4
1857652 | 5 a V1 | K1 1
1857666 | 5 a V1 | K1 1
1858422 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1858443 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1859550 | 4 a V1 | Ūkio-buities nuotekos - F1 12; F1 n.p. 2
1859650 | 4 a V1 | Ūkio-buities nuotekos - F1 1; F1 n.p. 1
1862259 | 2 a | Ūkio-buities nuotekos - F1 69; F1 n.p. 3

# IfcFlowFitting: PIF_AS+_Super_Tee _Wavin:socket End - Tee 45° (+elbow) (721)
Type - Description: Branch; PredefinedType: JUNCTION; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket End - Tee 45° (+elbow); sets with these values: 2
Name (PIF_AS+_Super_Tee _Wavin:socket End - Tee 45° (+elbow):...) | In | Group
1104285 | 0 a | Lietaus nuotekos - L1 1
1104539 | 0 a | Lietaus nuotekos - L1 2
1104766 | 0 a | Lietaus nuotekos - L1 6
1104886 | 0 a | Lietaus nuotekos - L1 4
1105073 | 0 a | Lietaus nuotekos - L1 8
1107124 | 0 a | Lietaus nuotekos - L1 3
1107727 | 0 a | Lietaus nuotekos - L1 9
1108240 | 0 a | Lietaus nuotekos - L1 11
1111246 | 2 a | Lietaus nuotekos - L1 20
1111300 | 2 a | Lietaus nuotekos - L1 20
1111332 | 2 a | Lietaus nuotekos - L1 20
1111606 | 2 a | Lietaus nuotekos - L1 5
1111638 | 2 a | Lietaus nuotekos - L1 5
1111670 | 2 a | Lietaus nuotekos - L1 5
1112416 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1118911 | 4 a V1 | K1 2
1119184 | 5 a V1 | K1 2
1119347 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1119569 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1119887 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1121135 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1121258 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1121324 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1127490 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1127982 | 5 a V1 | Ūkio-buities nuotekos - F1 16
1128099 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1128141 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1128220 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128802 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128882 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1129455 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1129673 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1129740 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1129830 | 4 a V1 | Ūkio-buities nuotekos - F1 20
1129972 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130186 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130317 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130771 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1131312 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1131580 | 5 a V1 | K1 2
1139416 | 5 a V1 | K1 2
1139650 | 5 a V1 | K1 2
1140044 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1140670 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1141370 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1142815 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1143191 | 0 a | Lietaus nuotekos - L1 11
1143496 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1143901 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144127 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144399 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144532 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144651 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145399 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145446 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145820 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1151781 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1151889 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152002 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152440 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152816 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153047 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153201 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153531 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153718 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1154237 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155948 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156122 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156337 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156566 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156811 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157003 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157224 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157289 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157490 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158110 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158269 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158541 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158696 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159090 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159217 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159578 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159732 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159847 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160015 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160316 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160427 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160613 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160732 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160902 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1163080 | 4 a V1 | K1 2
1163543 | 4 a V1 | K1 2
1165571 | 4 a V1 | K1 2
1166247 | 4 a V1 | K1 2
1166776 | 4 a V1 | K1 2
1167059 | 4 a V1 | K1 2
1167263 | 4 a V1 | K1 2
1167438 | 4 a V1 | K1 2
1167633 | 4 a V1 | K1 2
1167846 | 4 a V1 | K1 2
1169377 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1169607 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169780 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170021 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170472 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170585 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170750 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170866 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170975 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171218 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171338 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171514 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171852 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171984 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1172293 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172607 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172728 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173145 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173287 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173487 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173621 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173765 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173919 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174038 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174186 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174309 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174536 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174716 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174852 | 4 a V1 | K1 2
1176335 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1176806 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177056 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1177143 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177304 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177557 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177889 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178244 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178400 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178582 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1179039 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1179402 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1179902 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180126 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180273 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180621 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1180705 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1180802 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1180909 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1182364 | 0 a | Lietaus nuotekos - L1 13
1183029 | 4 a V1 | Lietaus nuotekos - L1 13
1183224 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1183304 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1183481 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1183775 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1183920 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184056 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184308 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1185439 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186143 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186408 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186561 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186659 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186883 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187124 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187256 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187474 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187614 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187722 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187958 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188266 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188408 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188706 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188845 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189175 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189472 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189643 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189840 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190021 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190331 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190637 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190794 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190934 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191161 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191320 | 4 a V1 | K1 2
1191497 | 4 a V1 | K1 2
1191686 | 4 a V1 | K1 2
1191806 | 4 a V1 | K1 2
1192005 | 4 a V1 | K1 2
1192110 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192264 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192399 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192481 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192688 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192847 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193223 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193396 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193810 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193890 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1194061 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194410 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194579 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1194722 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1194858 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1195079 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195168 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195292 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195662 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1196285 | 5 a V1 | K1 2
1196391 | 5 a V1 | K1 2
1196891 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1197238 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1197469 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1197611 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198367 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198795 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198834 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199119 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199454 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200117 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200326 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200449 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1201031 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201153 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201252 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201349 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201645 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201762 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201820 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201988 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202337 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202407 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202684 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202940 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1202995 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203099 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203213 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203308 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203406 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203530 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203615 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203719 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203928 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204053 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204173 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204270 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204609 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204685 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204800 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205302 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205435 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205803 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1205966 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1206273 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206492 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206735 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1207022 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1209673 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1210036 | 3 a | Ūkio-buities nuotekos - F1 16
1210516 | 3 a | Ūkio-buities nuotekos - F1 16
1210679 | 3 a | Ūkio-buities nuotekos - F1 16
1210911 | 3 a | Ūkio-buities nuotekos - F1 16
1211078 | 3 a | Ūkio-buities nuotekos - F1 16
1212944 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1213284 | 3 a | Ūkio-buities nuotekos - F1 14
1213633 | 3 a | Ūkio-buities nuotekos - F1 14
1213900 | 3 a | Ūkio-buities nuotekos - F1 14
1217139 | 3 a | Ūkio-buities nuotekos - F1 13
1217404 | 3 a | Ūkio-buities nuotekos - F1 13
1217620 | 3 a | Ūkio-buities nuotekos - F1 13
1218128 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1218341 | 3 a | Ūkio-buities nuotekos - F1 13
1218457 | 3 a | Ūkio-buities nuotekos - F1 13
1218626 | 3 a | Ūkio-buities nuotekos - F1 13
1218735 | 3 a | Ūkio-buities nuotekos - F1 13
1219531 | 3 a | Ūkio-buities nuotekos - F1 11
1220483 | 0 a | Lietaus nuotekos - L1 13
1221190 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1222898 | 3 a | Ūkio-buities nuotekos - F1 12
1223111 | 3 a | Ūkio-buities nuotekos - F1 12
1223292 | 3 a | Ūkio-buities nuotekos - F1 12
1223520 | 3 a | Ūkio-buities nuotekos - F1 12
1223803 | 3 a | Ūkio-buities nuotekos - F1 12
1224030 | 3 a | Ūkio-buities nuotekos - F1 12
1224261 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1224429 | 3 a | Ūkio-buities nuotekos - F1 9
1224731 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1225317 | 3 a | Ūkio-buities nuotekos - F1 8
1225523 | 3 a | Ūkio-buities nuotekos - F1 8
1225690 | 3 a | Ūkio-buities nuotekos - F1 8
1225794 | 3 a | Ūkio-buities nuotekos - F1 8
1227500 | 2 a | Ūkio-buities nuotekos - F1 6
1227983 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1228157 | 3 a | Ūkio-buities nuotekos - F1 5
1228326 | 3 a | Ūkio-buities nuotekos - F1 5
1228479 | 3 a | Ūkio-buities nuotekos - F1 5
1228613 | 3 a | Ūkio-buities nuotekos - F1 5
1228829 | 4 a V1 | K1 2
1229008 | 3 a | K1 2
1229348 | 3 a | K1 2
1229490 | 3 a | K1 2
1229621 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1229875 | 3 a | Ūkio-buities nuotekos - F1 1
1230343 | 3 a | Ūkio-buities nuotekos - F1 1
1230911 | 3 a | Ūkio-buities nuotekos - F1 1
1230938 | 3 a | Ūkio-buities nuotekos - F1 1
1231050 | 3 a | Ūkio-buities nuotekos - F1 1
1231187 | 3 a | Ūkio-buities nuotekos - F1 1
1231476 | 3 a | Ūkio-buities nuotekos - F1 1
1231698 | 3 a | Ūkio-buities nuotekos - F1 1
1231743 | 3 a | Ūkio-buities nuotekos - F1 1
1231924 | 3 a | Ūkio-buities nuotekos - F1 1
1232074 | 3 a | Ūkio-buities nuotekos - F1 1
1232260 | 3 a | Ūkio-buities nuotekos - F1 1
1232439 | 3 a | Ūkio-buities nuotekos - F1 1
1232546 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1232774 | 3 a | Ūkio-buities nuotekos - F1 1
1232892 | 3 a | Ūkio-buities nuotekos - F1 1
1233193 | 3 a | Ūkio-buities nuotekos - F1 1
1233286 | 3 a | Ūkio-buities nuotekos - F1 1
1233381 | 3 a | Ūkio-buities nuotekos - F1 1
1233450 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1233867 | 3 a | Ūkio-buities nuotekos - F1 1
1234060 | 3 a | Ūkio-buities nuotekos - F1 1
1234345 | 3 a | Ūkio-buities nuotekos - F1 1
1234627 | 3 a | Ūkio-buities nuotekos - F1 1
1234780 | 3 a | Ūkio-buities nuotekos - F1 1
1235467 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1235934 | 3 a | Ūkio-buities nuotekos - F1 1
1236139 | 3 a | Ūkio-buities nuotekos - F1 1
1236422 | 3 a | Ūkio-buities nuotekos - F1 1
1236677 | 3 a | Ūkio-buities nuotekos - F1 1
1237092 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1237126 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1237445 | 3 a | Ūkio-buities nuotekos - F1 2
1237504 | 3 a | Ūkio-buities nuotekos - F1 2
1237633 | 3 a | Ūkio-buities nuotekos - F1 2
1237714 | 3 a | Ūkio-buities nuotekos - F1 2
1238504 | 3 a | Ūkio-buities nuotekos - F1 2
1238806 | 3 a | Ūkio-buities nuotekos - F1 2
1239044 | 3 a | Ūkio-buities nuotekos - F1 2
1239169 | 3 a | Ūkio-buities nuotekos - F1 2
1239293 | 3 a | Ūkio-buities nuotekos - F1 2
1239332 | 3 a | Ūkio-buities nuotekos - F1 2
1239505 | 3 a | Ūkio-buities nuotekos - F1 2
1239631 | 3 a | Ūkio-buities nuotekos - F1 2
1240175 | 3 a | Ūkio-buities nuotekos - F1 2
1240206 | 3 a | Ūkio-buities nuotekos - F1 2
1240356 | 3 a | Ūkio-buities nuotekos - F1 2
1241058 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1241259 | 2 a | Ūkio-buities nuotekos - F1 2
1241368 | 2 a | Ūkio-buities nuotekos - F1 2
1241538 | 2 a | Ūkio-buities nuotekos - F1 2
1241664 | 2 a | Ūkio-buities nuotekos - F1 2
1241809 | 2 a | Ūkio-buities nuotekos - F1 2
1241911 | 2 a | Ūkio-buities nuotekos - F1 2
1242037 | 2 a | Ūkio-buities nuotekos - F1 2
1242278 | 2 a | Ūkio-buities nuotekos - F1 2
1242354 | 2 a | Ūkio-buities nuotekos - F1 2
1242447 | 2 a | Ūkio-buities nuotekos - F1 2
1242545 | 2 a | Ūkio-buities nuotekos - F1 2
1242850 | 2 a | Ūkio-buities nuotekos - F1 2
1243832 | 2 a | Ūkio-buities nuotekos - F1 2
1244197 | 2 a | Ūkio-buities nuotekos - F1 2
1244393 | 2 a | Ūkio-buities nuotekos - F1 2
1244730 | 2 a | Ūkio-buities nuotekos - F1 2
1244975 | 2 a | Ūkio-buities nuotekos - F1 1
1245530 | 2 a | Ūkio-buities nuotekos - F1 1
1245694 | 2 a | Ūkio-buities nuotekos - F1 1
1245907 | 2 a | Ūkio-buities nuotekos - F1 1
1246061 | 2 a | Ūkio-buities nuotekos - F1 1
1246228 | 2 a | Ūkio-buities nuotekos - F1 1
1246361 | 2 a | Ūkio-buities nuotekos - F1 1
1246553 | 2 a | Ūkio-buities nuotekos - F1 1
1246774 | 2 a | Ūkio-buities nuotekos - F1 1
1246973 | 2 a | Ūkio-buities nuotekos - F1 1
1247323 | 2 a | Ūkio-buities nuotekos - F1 1
1247594 | 4 a V1 | K1 2
1247936 | 2 a | K1 2
1248078 | 2 a | K1 2
1248101 | 2 a | K1 2
1248190 | 2 a | K1 2
1248299 | 2 a | K1 2
1248425 | 2 a | K1 2
1248626 | 2 a | K1 2
1248766 | 2 a | K1 2
1249043 | 2 a | K1 2
1249439 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1249596 | 2 a | Ūkio-buities nuotekos - F1 5
1249820 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1250093 | 2 a | Ūkio-buities nuotekos - F1 6
1250195 | 2 a | Ūkio-buities nuotekos - F1 6
1250651 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1250944 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1251035 | 2 a | Ūkio-buities nuotekos - F1 12
1251153 | 2 a | Ūkio-buities nuotekos - F1 12
1251310 | 2 a | Ūkio-buities nuotekos - F1 12
1251425 | 2 a | Ūkio-buities nuotekos - F1 12
1251527 | 2 a | Ūkio-buities nuotekos - F1 12
1251801 | 2 a | Ūkio-buities nuotekos - F1 12
1251923 | 2 a | Ūkio-buities nuotekos - F1 12
1251966 | 2 a | Ūkio-buities nuotekos - F1 12
1252043 | 2 a | Ūkio-buities nuotekos - F1 12
1252181 | 2 a | Ūkio-buities nuotekos - F1 12
1252352 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1252403 | 2 a | Ūkio-buities nuotekos - F1 12
1252778 | 2 a | Ūkio-buities nuotekos - F1 12
1253313 | 2 a | Ūkio-buities nuotekos - F1 12
1253460 | 2 a | Ūkio-buities nuotekos - F1 12
1253645 | 2 a | Ūkio-buities nuotekos - F1 12
1253758 | 2 a | Ūkio-buities nuotekos - F1 12
1253902 | 4 a V1 | Ūkio-buities nuotekos - F1 17
1254142 | 2 a | Ūkio-buities nuotekos - F1 17
1254300 | 2 a | Ūkio-buities nuotekos - F1 17
1254450 | 2 a | Ūkio-buities nuotekos - F1 17
1254700 | 2 a | Ūkio-buities nuotekos - F1 17
1254826 | 2 a | Ūkio-buities nuotekos - F1 17
1254954 | 2 a | Ūkio-buities nuotekos - F1 17
1255073 | 2 a | Ūkio-buities nuotekos - F1 17
1255206 | 2 a | Ūkio-buities nuotekos - F1 17
1255370 | 2 a | Ūkio-buities nuotekos - F1 17
1255741 | 2 a | Ūkio-buities nuotekos - F1 17
1255906 | 2 a | Ūkio-buities nuotekos - F1 17
1256097 | 2 a | Ūkio-buities nuotekos - F1 17
1256231 | 2 a | Ūkio-buities nuotekos - F1 17
1256579 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1256804 | 2 a | Ūkio-buities nuotekos - F1 18
1257194 | 2 a | Ūkio-buities nuotekos - F1 18
1258014 | 2 a | Ūkio-buities nuotekos - F1 18
1258202 | 2 a | Ūkio-buities nuotekos - F1 18
1258411 | 2 a | Ūkio-buities nuotekos - F1 18
1258497 | 2 a | Ūkio-buities nuotekos - F1 18
1258620 | 2 a | Ūkio-buities nuotekos - F1 18
1258731 | 2 a | Ūkio-buities nuotekos - F1 18
1258845 | 2 a | Ūkio-buities nuotekos - F1 18
1259191 | 2 a | Ūkio-buities nuotekos - F1 18
1259879 | 2 a | Ūkio-buities nuotekos - F1 13
1260093 | 2 a | Ūkio-buities nuotekos - F1 13
1260536 | 2 a | Ūkio-buities nuotekos - F1 13
1260882 | 2 a | Ūkio-buities nuotekos - F1 13
1261069 | 2 a | Ūkio-buities nuotekos - F1 13
1261110 | 2 a | Ūkio-buities nuotekos - F1 13
1261294 | 2 a | Ūkio-buities nuotekos - F1 13
1261862 | 2 a | Ūkio-buities nuotekos - F1 69
1262009 | 2 a | Ūkio-buities nuotekos - F1 69
1262540 | 2 a | Ūkio-buities nuotekos - F1 69
1262825 | 2 a | Ūkio-buities nuotekos - F1 69
1263054 | 2 a | Ūkio-buities nuotekos - F1 69
1263253 | 2 a | Ūkio-buities nuotekos - F1 69
1263368 | 2 a | Ūkio-buities nuotekos - F1 69
1264303 | 2 a | Ūkio-buities nuotekos - F1 71
1264646 | 2 a | Ūkio-buities nuotekos - F1 71
1264684 | 2 a | Ūkio-buities nuotekos - F1 71
1265047 | 2 a | Ūkio-buities nuotekos - F1 71
1265302 | 2 a | Ūkio-buities nuotekos - F1 71
1265335 | 2 a | Ūkio-buities nuotekos - F1 71
1265882 | 2 a | Ūkio-buities nuotekos - F1 71
1266022 | 2 a | Ūkio-buities nuotekos - F1 71
1266261 | 2 a | Ūkio-buities nuotekos - F1 71
1266578 | 2 a | Ūkio-buities nuotekos - F1 71
1266925 | 2 a | Ūkio-buities nuotekos - F1 71
1267016 | 2 a | Ūkio-buities nuotekos - F1 71
1267269 | 2 a | Ūkio-buities nuotekos - F1 71
1267561 | 2 a | Ūkio-buities nuotekos - F1 71
1267832 | 2 a | Ūkio-buities nuotekos - F1 71
1267887 | 2 a | Ūkio-buities nuotekos - F1 71
1268131 | 2 a | Ūkio-buities nuotekos - F1 71
1268268 | 2 a | Ūkio-buities nuotekos - F1 71
1268372 | 2 a | Ūkio-buities nuotekos - F1 71
1269117 | 2 a | Ūkio-buities nuotekos - F1 72
1269214 | 2 a | Ūkio-buities nuotekos - F1 72
1269262 | 2 a | Ūkio-buities nuotekos - F1 72
1269300 | 2 a | Ūkio-buities nuotekos - F1 72
1269607 | 2 a | Ūkio-buities nuotekos - F1 72
1269789 | 2 a | Ūkio-buities nuotekos - F1 72
1270062 | 2 a | Ūkio-buities nuotekos - F1 72
1270237 | 2 a | Ūkio-buities nuotekos - F1 72
1270448 | 2 a | Ūkio-buities nuotekos - F1 72
1270559 | 2 a | Ūkio-buities nuotekos - F1 72
1270687 | 2 a | Ūkio-buities nuotekos - F1 72
1270985 | 2 a | Ūkio-buities nuotekos - F1 72
1271166 | 2 a | Ūkio-buities nuotekos - F1 72
1271915 | 2 a | Ūkio-buities nuotekos - F1 72
1272132 | 2 a | Ūkio-buities nuotekos - F1 72
1272232 | 2 a | Ūkio-buities nuotekos - F1 72
1272448 | 2 a | Ūkio-buities nuotekos - F1 72
1272557 | 2 a | Ūkio-buities nuotekos - F1 72
1272943 | 2 a | Ūkio-buities nuotekos - F1 72
1273196 | 2 a | Ūkio-buities nuotekos - F1 72
1273349 | 2 a | Ūkio-buities nuotekos - F1 72
1273448 | 2 a | Ūkio-buities nuotekos - F1 72
1273727 | 2 a | Ūkio-buities nuotekos - F1 72
1273902 | 2 a | Ūkio-buities nuotekos - F1 72
1274099 | 2 a | Ūkio-buities nuotekos - F1 72
1274342 | 2 a | Ūkio-buities nuotekos - F1 72
1274790 | 2 a | Ūkio-buities nuotekos - F1 72
1275044 | 2 a | Ūkio-buities nuotekos - F1 72
1275139 | 2 a | Ūkio-buities nuotekos - F1 72
1275402 | 2 a | Ūkio-buities nuotekos - F1 72
1275620 | 2 a | Ūkio-buities nuotekos - F1 72
1277103 | 2 a | Ūkio-buities nuotekos - F1 75
1277180 | 2 a | Ūkio-buities nuotekos - F1 75
1277411 | 2 a | Ūkio-buities nuotekos - F1 75
1277620 | 2 a | Ūkio-buities nuotekos - F1 75
1277881 | 2 a | Ūkio-buities nuotekos - F1 75
1278054 | 2 a | Ūkio-buities nuotekos - F1 75
1278181 | 2 a | Ūkio-buities nuotekos - F1 75
1278398 | 2 a | Ūkio-buities nuotekos - F1 75
1278538 | 2 a | Ūkio-buities nuotekos - F1 75
1278757 | 2 a | Ūkio-buities nuotekos - F1 75
1278838 | 2 a | Ūkio-buities nuotekos - F1 75
1279174 | 2 a | Ūkio-buities nuotekos - F1 75
1279368 | 2 a | Ūkio-buities nuotekos - F1 75
1279657 | 2 a | Ūkio-buities nuotekos - F1 71
1282484 | 2 a | nuotekos ūkio-buities - F1 1
1282673 | 2 a | nuotekos ūkio-buities - F1 1
1282966 | 2 a | nuotekos ūkio-buities - F1 1
1283277 | 2 a | nuotekos ūkio-buities - F1 1
1283389 | 2 a | nuotekos ūkio-buities - F1 1
1283570 | 2 a | nuotekos ūkio-buities - F1 1
1283672 | 2 a | Ūkio-buities nuotekos - F1 75
1283808 | 2 a | Ūkio-buities nuotekos - F1 75
1283852 | 2 a | Ūkio-buities nuotekos - F1 75
1284140 | 2 a | nuotekos ūkio-buities - F1 1
1284376 | 2 a | nuotekos ūkio-buities - F1 1
1284569 | 2 a | nuotekos ūkio-buities - F1 1
1284815 | 2 a | nuotekos ūkio-buities - F1 1
1285255 | 2 a | nuotekos ūkio-buities - F1 1
1285409 | 2 a | nuotekos ūkio-buities - F1 1
1285449 | 2 a | nuotekos ūkio-buities - F1 1
1285573 | 2 a | nuotekos ūkio-buities - F1 1
1285830 | 2 a | nuotekos ūkio-buities - F1 1
1286059 | 2 a | nuotekos ūkio-buities - F1 4
1286541 | 2 a | nuotekos ūkio-buities - F1 4
1286978 | 2 a | nuotekos ūkio-buities - F1 4
1287041 | 2 a | nuotekos ūkio-buities - F1 4
1287387 | 2 a | nuotekos ūkio-buities - F1 4
1287488 | 2 a | nuotekos ūkio-buities - F1 4
1287980 | 2 a | nuotekos ūkio-buities - F1 4
1288206 | 2 a | nuotekos ūkio-buities - F1 4
1291410 | 2 a | Ūkio-buities nuotekos - F1 16
1291942 | 2 a | Ūkio-buities nuotekos - F1 16
1292075 | 2 a | Ūkio-buities nuotekos - F1 16
1292232 | 2 a | Ūkio-buities nuotekos - F1 16
1292384 | 2 a | Ūkio-buities nuotekos - F1 16
1292494 | 2 a | Ūkio-buities nuotekos - F1 16
1292691 | 2 a | Ūkio-buities nuotekos - F1 16
1292736 | 2 a | Ūkio-buities nuotekos - F1 16
1293041 | 2 a | Ūkio-buities nuotekos - F1 16
1293182 | 2 a | Ūkio-buities nuotekos - F1 16
1293307 | 2 a | Ūkio-buities nuotekos - F1 16
1293394 | 2 a | Ūkio-buities nuotekos - F1 16
1293561 | 2 a | Ūkio-buities nuotekos - F1 16
1294288 | 2 a | Ūkio-buities nuotekos - F1 16
1294540 | 2 a | Ūkio-buities nuotekos - F1 16
1294629 | 2 a | Ūkio-buities nuotekos - F1 16
1294676 | 2 a | Ūkio-buities nuotekos - F1 16
1294980 | 2 a | Ūkio-buities nuotekos - F1 16
1295078 | 2 a | Ūkio-buities nuotekos - F1 16
1295201 | 2 a | Ūkio-buities nuotekos - F1 16
1295379 | 2 a | Ūkio-buities nuotekos - F1 16
1295885 | 2 a | Ūkio-buities nuotekos - F1 16
1295998 | 2 a | Ūkio-buities nuotekos - F1 16
1296119 | 2 a | Ūkio-buities nuotekos - F1 16
1296358 | 2 a | Ūkio-buities nuotekos - F1 16
1296552 | 2 a | Ūkio-buities nuotekos - F1 16
1296926 | 2 a | Ūkio-buities nuotekos - F1 16
1297086 | 2 a | Ūkio-buities nuotekos - F1 16
1297268 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1297766 | 2 a | Ūkio-buities nuotekos - F1 19
1297883 | 2 a | Ūkio-buities nuotekos - F1 19
1297997 | 2 a | Ūkio-buities nuotekos - F1 19
1298140 | 2 a | Ūkio-buities nuotekos - F1 19
1298568 | 2 a | Ūkio-buities nuotekos - F1 19
1298879 | 2 a | Ūkio-buities nuotekos - F1 19
1299005 | 2 a | Ūkio-buities nuotekos - F1 19
1299276 | 2 a | Ūkio-buities nuotekos - F1 19
1299395 | 2 a | Ūkio-buities nuotekos - F1 19
1299512 | 2 a | Ūkio-buities nuotekos - F1 19
1299639 | 2 a | Ūkio-buities nuotekos - F1 19
1300332 | 2 a | Ūkio-buities nuotekos - F1 81
1300989 | 2 a | Ūkio-buities nuotekos - F1 81
1301132 | 2 a | Ūkio-buities nuotekos - F1 81
1301487 | 2 a | Ūkio-buities nuotekos - F1 19
1301691 | 2 a | Ūkio-buities nuotekos - F1 81
1302030 | 2 a | Ūkio-buities nuotekos - F1 19
1302624 | 2 a | Ūkio-buities nuotekos - F1 81
1302733 | 2 a | Ūkio-buities nuotekos - F1 81
1302853 | 2 a | Ūkio-buities nuotekos - F1 81
1303112 | 2 a | Ūkio-buities nuotekos - F1 81
1304157 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1305196 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1305596 | 0 a | Ūkio-buities nuotekos - F1 2
1305762 | 2 a | Ūkio-buities nuotekos - F1 71
1306442 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1306604 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1306889 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307271 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307366 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1307816 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1307997 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308062 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308165 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308437 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308516 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1308942 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309065 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309241 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309474 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309701 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1309898 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310002 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310146 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310501 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310692 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310840 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310973 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1311429 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1312048 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1312413 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1312702 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1313152 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313200 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 1
1313370 | 2 a | Ūkio-buities nuotekos - F1 87
1313388 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313420 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313444 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313460 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313476 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313509 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313547 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313563 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313577 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313615 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313639 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313663 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313687 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313703 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313726 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313764 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313796 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313820 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313852 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313890 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313930 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313954 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313978 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1315117 | 4 a V1 | K1 2
1316525 | 1 a +-152.84 | K1 2
1316629 | 1 a +-152.84 | K1 2
1316749 | 1 a +-152.84 | K1 2
1316829 | 1 a +-152.84 | K1 2
1317010 | 1 a +-152.84 | K1 2
1317115 | 1 a +-152.84 | K1 2
1317207 | 1 a +-152.84 | K1 2
1317329 | 1 a +-152.84 | K1 2
1317457 | 1 a +-152.84 | K1 2
1317602 | 1 a +-152.84 | K1 2
1317914 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1318195 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318382 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318424 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5
1318900 | 2 a | Ūkio-buities nuotekos - F1 69
1319385 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319804 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1319943 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320219 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320347 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320449 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320569 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1320657 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 69
1411742 | 2 a | Ūkio-buities nuotekos - F1 75
1412035 | 0 a | Ūkio-buities nuotekos - F1 75
1412461 | 2 a | Ūkio-buities nuotekos - F1 75
1412845 | 0 a | Ūkio-buities nuotekos - F1 75
1413423 | 0 a | Ūkio-buities nuotekos - F1 75
1413624 | 0 a | Ūkio-buities nuotekos - F1 75
1413709 | 0 a | Ūkio-buities nuotekos - F1 75
1414017 | 0 a | Ūkio-buities nuotekos - F1 75
1414270 | 0 a | Ūkio-buities nuotekos - F1 75
1414439 | 0 a | Ūkio-buities nuotekos - F1 75
1414575 | 0 a | Ūkio-buities nuotekos - F1 75
1414875 | 0 a | Ūkio-buities nuotekos - F1 75
1414960 | 0 a | Ūkio-buities nuotekos - F1 75
1415256 | 2 a | nuotekos ūkio-buities - F1 1
1415788 | 0 a | nuotekos ūkio-buities - F1 1
1415925 | 0 a | nuotekos ūkio-buities - F1 1
1416272 | 1 a +-152.84 | nuotekos ūkio-buities - F1 4
1416541 | 0 a | nuotekos ūkio-buities - F1 4
1416737 | 0 a | nuotekos ūkio-buities - F1 4
1416874 | 0 a | nuotekos ūkio-buities - F1 4
1417013 | 0 a | nuotekos ūkio-buities - F1 4
1417259 | 2 a | Ūkio-buities nuotekos - F1 16
1417703 | 0 a | Ūkio-buities nuotekos - F1 16
1417813 | 0 a | Ūkio-buities nuotekos - F1 16
1417865 | 0 a | Ūkio-buities nuotekos - F1 16
1418045 | 0 a | Ūkio-buities nuotekos - F1 16
1418118 | 0 a | Ūkio-buities nuotekos - F1 16
1418406 | 0 a | Ūkio-buities nuotekos - F1 16
1418804 | 0 a | Ūkio-buities nuotekos - F1 16
1418845 | 0 a | Ūkio-buities nuotekos - F1 75
1497554 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1499003 | 5 a V1 | Lietaus nuotekos - L1 10
1499046 | 5 a V1 | Lietaus nuotekos - L1 10
1499088 | 5 a V1 | Lietaus nuotekos - L1 10
1500747 | 1 a +-152.84 | Lietaus nuotekos - L1 11
1502244 | 0 a | Ūkio-buities nuotekos - F1 87
1502900 | 0 a | Lietaus nuotekos - L1 13
1503661 | 0 a | nuotekos ūkio-buities - F1 4
1506133 | 0 a | Ūkio-buities nuotekos - F1 12
1506602 | 2 a | Ūkio-buities nuotekos - F1 17
1856005 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1856419 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1856505 | 5 a V1 | F1 4
1856849 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1856914 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1857386 | 5 a V1 | K1 4
1857461 | 5 a V1 | K1 4
1858416 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1859543 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1859643 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1862253 | 2 a | Ūkio-buities nuotekos - F1 69

# IfcFlowFitting: PIF_Tigris_Elbow_M-K_Wavin:Standard (101)
Type - Description: Elbow; PredefinedType: BEND; Material: Steel WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (PIF_Tigris_Elbow_M-K_Wavin:Standard:...) | In | Group
1114275 | 0 a | vanduo šaltas - V1 2
1114515 | 0 a | vanduo šaltas - V1 2
1117826 | 0 a | vanduo šaltas - V1 2
1118405 | 0 a | vanduo šaltas - V1 2
1329596 | 0 a | vanduo šaltas - V1 2
1329953 | 0 a | vanduo šaltas - V1 2
1329979 | 1 a +-152.84 | vanduo šaltas - V1 2
1330160 | 1 a +-152.84 | vanduo šaltas - V1 2
1330329 | 1 a +-152.84 | vanduo šaltas - V1 2
1330456 | 1 a +-152.84 | vanduo šaltas - V1 2
1330521 | 3 a | vanduo šaltas - V1 2
1332858 | 2 a | vanduo šaltas - V1 2
1336193 | 2 a | vanduo šaltas - V1 2
1336231 | 2 a | vanduo šaltas - V1 2
1338233 | 2 a | vanduo šaltas - V1 2
1338789 | 2 a | vanduo šaltas - V1 2
1338868 | 2 a | vanduo šaltas - V1 2
1348688 | 2 a | vanduo šaltas - V1 2
1349056 | 2 a | vanduo šaltas - V1 2
1349098 | 4 a V1 | vanduo šaltas - V1 2
1349158 | 4 a V1 | vanduo šaltas - V1 2
1349208 | 4 a V1 | vanduo šaltas - V1 2
1352468 | 2 a | vanduo šaltas - V1 2
1354766 | 1 a +-152.84 | vanduo šaltas - V1 2
1354794 | 0 a | vanduo šaltas - V1 2
1354817 | 1 a +-152.84 | vanduo šaltas - V1 2
1371930 | 2 a | vanduo šaltas - V1 2
1372003 | 2 a | vanduo šaltas - V1 2
1372021 | 2 a | vanduo šaltas - V1 2
1372035 | 2 a | vanduo šaltas - V1 2
1372049 | 2 a | vanduo šaltas - V1 2
1410319 | 1 a +-152.84 | vanduo šaltas - V1 2
1410325 | 1 a +-152.84 | vanduo šaltas - V1 2
1410401 | 1 a +-152.84 | vanduo šaltas - V1 2
1410523 | 1 a +-152.84 | vanduo šaltas - V1 2
1410643 | 0 a | vanduo šaltas - V1 2
1410653 | 0 a | vanduo šaltas - V1 2
1410661 | 0 a | vanduo šaltas - V1 2
1411058 | 0 a | vanduo šaltas - V1 2
1411138 | 0 a | vanduo šaltas - V1 2
1411400 | 0 a | vanduo šaltas - V1 2
1411526 | 0 a | vanduo šaltas - V1 2
1423685 | 0 a | vanduo šaltas - V1 2
1424466 | 0 a | vanduo šaltas - V1 2
1424474 | 0 a | vanduo šaltas - V1 2
1425720 | 0 a | vanduo šaltas - V1 2
1425757 | 0 a | vanduo šaltas - V1 2
1425790 | 0 a | vanduo karštas tiekiamasis - T3 1
1425880 | 0 a | vanduo karštas tiekiamasis - T3 1
1425890 | 0 a | vanduo karštas tiekiamasis - T3 1
1426042 | 0 a | vanduo karštas tiekiamasis - T3 1
1426065 | 0 a | vanduo karštas tiekiamasis - T3 1
1426384 | 0 a | vanduo karštas tiekiamasis - T3 1
1426505 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1426743 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1426751 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1426774 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1426778 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1426913 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1427004 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 2
1427166 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1427734 | 0 a | vanduo karštas tiekiamasis - T3 1
1427746 | 0 a | vanduo karštas tiekiamasis - T3 1
1427760 | 0 a | vanduo karštas tiekiamasis - T3 1
1427772 | 0 a | vanduo karštas tiekiamasis - T3 1
1427810 | 0 a | vanduo karštas tiekiamasis - T3 1
1427839 | 0 a | vanduo karštas tiekiamasis - T3 1
1427885 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1427889 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1431143 | 0 a | vanduo karštas tiekiamasis - T3 1
1431151 | 0 a | vanduo karštas tiekiamasis - T3 1
1432043 | 0 a | vanduo karštas apytakinis - T4 1
1432071 | 0 a | vanduo karštas apytakinis - T4 1
1432087 | 0 a | vanduo karštas apytakinis - T4 1
1432403 | 0 a | vanduo karštas apytakinis - T4 1
1432415 | 0 a | vanduo karštas apytakinis - T4 1
1432435 | 0 a | vanduo karštas apytakinis - T4 1
1432530 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1432542 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1432646 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1432654 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1432835 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1432923 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1433119 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1433776 | 0 a | vanduo karštas apytakinis - T4 1
1433790 | 0 a | vanduo karštas apytakinis - T4 1
1433798 | 0 a | vanduo karštas apytakinis - T4 1
1433810 | 0 a | vanduo karštas apytakinis - T4 1
1433826 | 0 a | vanduo karštas apytakinis - T4 1
1433840 | 0 a | vanduo karštas apytakinis - T4 1
1434011 | 0 a | vanduo karštas apytakinis - T4 1
1434015 | 0 a | vanduo karštas apytakinis - T4 1
1434045 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1436304 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437456 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1449501 | 2 a | vanduo karštas tiekiamasis - T3 1
1449571 | 2 a | vanduo karštas tiekiamasis - T3 1
1451264 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1471138 | 3 a | vanduo karštas tiekiamasis - T3 1
1471236 | 3 a | vanduo karštas tiekiamasis - T3 1
1481064 | 3 a | vanduo karštas tiekiamasis - T3 1

# IfcFlowFitting: PIF_Tigris_Elbow_M-K_Wavin:Standard (3281)
Type - Description: Elbow; PredefinedType: BEND; Material: Steel WVN-T, Brass WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (PIF_Tigris_Elbow_M-K_Wavin:Standard:...) | In | Group
1330604 | 3 a | vanduo šaltas - V1 2
1330827 | 4 a V1 | vanduo šaltas - V1 2
1330998 | 4 a V1 | vanduo šaltas - V1 2
1331103 | 4 a V1 | vanduo šaltas - V1 2
1331107 | 4 a V1 | vanduo šaltas - V1 2
1331217 | 4 a V1 | vanduo šaltas - V1 2
1331278 | 4 a V1 | vanduo šaltas - V1 2
1331280 | 4 a V1 | vanduo šaltas - V1 2
1331369 | 4 a V1 | vanduo šaltas - V1 2
1331371 | 4 a V1 | vanduo šaltas - V1 2
1331554 | 4 a V1 | vanduo šaltas - V1 2
1331594 | 4 a V1 | vanduo šaltas - V1 2
1331598 | 4 a V1 | vanduo šaltas - V1 2
1331629 | 4 a V1 | vanduo šaltas - V1 2
1331676 | 4 a V1 | vanduo šaltas - V1 2
1331762 | 4 a V1 | vanduo šaltas - V1 2
1331766 | 4 a V1 | vanduo šaltas - V1 2
1331863 | 4 a V1 | vanduo šaltas - V1 2
1331867 | 4 a V1 | vanduo šaltas - V1 2
1332062 | 4 a V1 | vanduo šaltas - V1 2
1332066 | 4 a V1 | vanduo šaltas - V1 2
1332115 | 4 a V1 | vanduo šaltas - V1 2
1332119 | 4 a V1 | vanduo šaltas - V1 2
1332170 | 4 a V1 | vanduo šaltas - V1 2
1332233 | 4 a V1 | vanduo šaltas - V1 2
1332237 | 4 a V1 | vanduo šaltas - V1 2
1332314 | 4 a V1 | vanduo šaltas - V1 2
1332316 | 4 a V1 | vanduo šaltas - V1 2
1332363 | 4 a V1 | vanduo šaltas - V1 2
1332425 | 4 a V1 | vanduo šaltas - V1 2
1332429 | 4 a V1 | vanduo šaltas - V1 2
1332519 | 4 a V1 | vanduo šaltas - V1 2
1332521 | 4 a V1 | vanduo šaltas - V1 2
1332579 | 4 a V1 | vanduo šaltas - V1 2
1332617 | 4 a V1 | vanduo šaltas - V1 2
1332619 | 4 a V1 | vanduo šaltas - V1 2
1332695 | 4 a V1 | vanduo šaltas - V1 2
1332699 | 4 a V1 | vanduo šaltas - V1 2
1333408 | 2 a | vanduo šaltas - V1 2
1333494 | 2 a | vanduo šaltas - V1 2
1333514 | 2 a | vanduo šaltas - V1 2
1333699 | 4 a V1 | vanduo šaltas - V1 2
1333789 | 4 a V1 | vanduo šaltas - V1 2
1333794 | 4 a V1 | vanduo šaltas - V1 2
1333890 | 4 a V1 | vanduo šaltas - V1 2
1333894 | 4 a V1 | vanduo šaltas - V1 2
1333973 | 4 a V1 | vanduo šaltas - V1 2
1333977 | 4 a V1 | vanduo šaltas - V1 2
1334005 | 4 a V1 | vanduo šaltas - V1 2
1334054 | 2 a | vanduo šaltas - V1 2
1334120 | 4 a V1 | vanduo šaltas - V1 2
1334167 | 4 a V1 | vanduo šaltas - V1 2
1334171 | 4 a V1 | vanduo šaltas - V1 2
1334527 | 4 a V1 | vanduo šaltas - V1 2
1334531 | 4 a V1 | vanduo šaltas - V1 2
1334603 | 4 a V1 | vanduo šaltas - V1 2
1334607 | 4 a V1 | vanduo šaltas - V1 2
1334641 | 4 a V1 | vanduo šaltas - V1 2
1334687 | 4 a V1 | vanduo šaltas - V1 2
1334689 | 4 a V1 | vanduo šaltas - V1 2
1334749 | 4 a V1 | vanduo šaltas - V1 2
1334789 | 4 a V1 | vanduo šaltas - V1 2
1334793 | 4 a V1 | vanduo šaltas - V1 2
