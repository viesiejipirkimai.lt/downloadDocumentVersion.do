Properties of the parts of a building model (IFC2X3), part 30 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1459074_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459082_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459074_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459092_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459082_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459086_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459092_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459086_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459125_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459094_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459127_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459094_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459123_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459125_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459123_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459127_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459197_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459209_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459221_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459209_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459210_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459213_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459221_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459213_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459270_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459223_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459274_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459223_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459268_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459270_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459274_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459292_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459306_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459318_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459306_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459310_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459310_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459359_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459320_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459361_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459320_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459357_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459359_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459385_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459403_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459385_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459415_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459403_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459407_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459415_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459407_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459453_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459417_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459455_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459417_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459451_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459453_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459451_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459455_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459473_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459587_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459473_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459501_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459489_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459490_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459489_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459650_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459493_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459501_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459493_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459559_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459503_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459563_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459503_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459557_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459559_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459557_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459579_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459587_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459579_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459621_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459587_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459588_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459588_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459649_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459591_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459625_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459591_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459619_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459621_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459619_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459641_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459761_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459641_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459673_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459649_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459650_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459649_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459762_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459653_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459675_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459653_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459729_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459673_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459679_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459731_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459727_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459729_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459727_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459731_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459753_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459761_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459773_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459761_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459762_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459765_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459773_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459775_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459877_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459775_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459844_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459810_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459810_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459906_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459814_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459846_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459842_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459844_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459842_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459846_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459862_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459881_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459862_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459875_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459877_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459875_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459877_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459878_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459878_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459905_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459897_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459905_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459897_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459933_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459905_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459906_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459909_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459933_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459909_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459935_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460001_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459935_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459995_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459997_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459995_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460001_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460019_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460146_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460019_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460059_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460041_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460042_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460041_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460207_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460045_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460061_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460045_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460118_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460059_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460065_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460122_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460116_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460118_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460116_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460122_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460138_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460146_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460138_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460178_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460146_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460147_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460147_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460206_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460150_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460182_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460150_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460176_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460178_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460176_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460182_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460198_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460206_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460198_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460250_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460206_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460207_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460210_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460252_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460210_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460248_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460250_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460248_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460270_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460282_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460270_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460294_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460282_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460283_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460286_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460294_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460286_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460316_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460296_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460316_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460296_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460338_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460318_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460440_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460318_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460356_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460338_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460851_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460340_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460358_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460356_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460362_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460370_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460372_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460414_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460372_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460408_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460410_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460408_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460414_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460432_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460440_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460432_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460494_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460440_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460441_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460441_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460530_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460444_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460498_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460444_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460492_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460494_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460492_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460498_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460516_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460516_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460545_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460530_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460530_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460695_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460531_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460534_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460547_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460585_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460545_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460547_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460551_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460589_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460551_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460583_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460585_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460583_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460589_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460605_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460613_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460605_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460666_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460613_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460617_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460670_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460617_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460664_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460666_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460664_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460670_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460686_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460694_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460686_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460737_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460694_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460766_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460694_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460695_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460698_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460741_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460698_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460733_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460735_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460733_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460741_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460735_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460737_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460757_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460765_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460757_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460813_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460765_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460766_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460769_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460817_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460809_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460811_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460809_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460817_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460811_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460813_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460842_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460850_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460842_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460926_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460850_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460851_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460913_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460930_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460913_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460922_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460924_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460922_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460930_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460924_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460926_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461036_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461036_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461062_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461048_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461048_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461195_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461062_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461571_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461064_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461570_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461064_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461100_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461074_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461100_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461074_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461160_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461102_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461164_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461102_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461156_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461158_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461156_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461164_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461158_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461160_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461186_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461307_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461186_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461220_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461194_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461195_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461194_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461484_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461198_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461222_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461198_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461234_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461220_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461222_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461226_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461234_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461226_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461272_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461236_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461276_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461270_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461272_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461270_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461276_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461295_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461307_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461295_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461319_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461307_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461308_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461308_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461414_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461311_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461319_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461311_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461334_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461321_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461336_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461321_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461334_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461336_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461340_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461386_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461380_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461382_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461380_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461386_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461404_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461414_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461426_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461414_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461415_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461415_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461418_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461426_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461418_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461453_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461428_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461457_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461451_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461453_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461451_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461457_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461473_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461483_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461473_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461483_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461484_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461487_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461495_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461536_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461497_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461540_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461497_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461534_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461536_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461540_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461562_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461562_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461582_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461570_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461570_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461676_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461582_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461584_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461584_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461612_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461606_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461612_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461606_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461645_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461649_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461641_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461643_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461641_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461649_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461643_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461645_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461667_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461675_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461712_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461675_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461676_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461679_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461716_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461710_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461712_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461710_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461716_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461814_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461814_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464632_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461841_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461849_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461841_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461857_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461851_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461857_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461851_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461869_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461859_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462345_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461859_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461879_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461869_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462256_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461871_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461871_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461896_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461879_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462166_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461881_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461978_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461908_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461896_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461898_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462056_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461902_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461908_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461902_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461942_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461910_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461944_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461910_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461940_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461942_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461940_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461944_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461968_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461978_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461968_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461978_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461979_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461979_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462055_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461982_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462031_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461982_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462025_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462027_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462031_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462049_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462055_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462055_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462056_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462059_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462095_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462059_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462089_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462091_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462095_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462157_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462165_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462157_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462211_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462166_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462169_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462240_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462169_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462209_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462211_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462209_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462240_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462249_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462255_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462249_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462307_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462255_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462346_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462255_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462256_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462259_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462311_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462259_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462303_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462305_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462311_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462305_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462307_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462327_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462741_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462327_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462345_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462346_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462345_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462850_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462349_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462359_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462349_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462369_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462357_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462359_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462395_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462371_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462395_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462371_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462408_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462397_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462490_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462397_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462418_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462408_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462563_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462410_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462418_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462462_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462420_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462466_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462420_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462460_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462462_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462460_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462466_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462482_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462490_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462482_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462490_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462491_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462491_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462562_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462494_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462538_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462494_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462532_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462534_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462532_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462554_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462562_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462554_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462604_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462562_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462566_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462608_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462566_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462602_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462604_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462602_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462608_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462624_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462632_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462687_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462632_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462742_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462632_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462633_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462633_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462636_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462708_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462636_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462685_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462687_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462685_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462691_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462691_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462731_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462741_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462731_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462751_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462741_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462742_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462745_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462751_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462770_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462753_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462770_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462821_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462772_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462825_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462819_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462821_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462819_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462825_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462841_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462849_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462841_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462888_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462849_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462853_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462892_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462853_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462886_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462888_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462886_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1462892_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463031_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463032_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463031_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463037_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463037_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463091_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463085_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463183_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463128_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463220_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463093_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463161_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463093_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463126_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463130_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463126_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463161_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463128_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463130_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463170_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463187_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463170_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463181_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463183_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463181_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463187_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463183_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463184_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463184_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463219_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463211_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463219_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463211_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463262_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463219_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463220_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463223_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463266_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463223_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463260_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463262_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463260_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463266_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463282_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463292_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463282_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463306_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463292_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463404_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463292_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463293_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463298_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463306_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463298_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463335_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463308_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463339_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463308_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463333_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463335_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463333_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463339_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463403_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463443_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463403_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463411_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463445_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463411_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463441_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463443_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463441_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463484_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463492_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463484_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463492_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463493_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463524_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463532_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463524_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463609_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463532_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463533_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463538_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463609_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463642_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463611_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463646_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463611_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463640_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463642_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463640_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463646_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463695_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463696_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463788_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463788_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464631_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463828_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465288_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463828_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463862_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463856_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463862_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463874_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463864_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463874_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463864_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464859_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463876_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464390_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463876_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463898_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463888_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463888_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463941_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464197_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463900_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463939_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463956_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463939_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463941_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463945_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463956_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463945_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463967_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463958_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463967_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464031_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463969_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464035_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463969_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464029_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464031_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464029_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464035_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464051_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464065_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464051_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464077_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464066_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464066_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464069_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464077_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1464069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
