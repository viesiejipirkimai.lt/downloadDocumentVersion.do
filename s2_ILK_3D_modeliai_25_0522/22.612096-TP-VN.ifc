Properties of the parts of a building model (IFC2X3), part 8 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1241903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241950_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241911_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241911_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243833_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241911_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242448_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242545_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241921_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241958_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241950_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241988_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242037_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241988_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242192_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242038_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242037_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242851_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242190_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242192_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
OutPort_1242253_1 | SOURCE
Port_1242268_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242278_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242279_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242354_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242286_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242324_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242286_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242316_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242318_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242346_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242354_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242370_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242354_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242355_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242364_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242364_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242409_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242378_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242415_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242378_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242409_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242415_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242437_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242447_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242437_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242461_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242455_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242507_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242469_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242515_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242469_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242507_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242515_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242537_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242545_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242537_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242561_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242545_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242546_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242850_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242555_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242555_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242569_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242575_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242583_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242663_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242583_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242653_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242655_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242653_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242663_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242842_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242850_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242842_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242950_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242851_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242860_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242958_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242860_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242950_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243787_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244976_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1243824_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243832_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243824_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243949_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243832_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243833_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243923_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243949_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243923_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243997_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244005_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243997_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244019_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244011_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244019_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244011_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244048_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244040_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244048_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244040_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244062_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244056_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244197_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244056_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244076_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244731_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244070_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244076_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244070_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244117_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244119_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244117_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244127_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244183_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244197_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244213_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244197_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244198_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244198_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244730_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244393_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244291_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244213_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244394_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244289_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244291_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244329_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244393_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244329_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244451_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244393_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244403_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244459_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244449_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244451_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244459_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244720_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244730_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244814_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244730_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244731_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244812_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244814_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244822_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1244822_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
OutPort_1244936_1 | SOURCE
Port_1244965_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245907_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244965_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245005_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244975_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244976_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244975_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246062_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244975_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245531_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244999_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1244999_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245214_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245206_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245222_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245262_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245222_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245252_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245254_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245252_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245518_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245530_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245518_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245593_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245530_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245530_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245695_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245538_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245599_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245591_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245593_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245591_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245702_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245783_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245694_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245694_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245908_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245694_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245702_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245708_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245822_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245708_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245781_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245783_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245781_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245822_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245897_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245915_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245897_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245987_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245907_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245908_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245907_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245915_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245985_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245987_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1245985_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246026_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246026_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246053_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246228_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246053_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246061_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246061_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246362_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246061_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246229_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246125_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246127_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246125_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246164_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246209_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246236_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246209_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246226_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246228_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246226_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246236_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246228_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246353_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246361_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246361_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246362_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246361_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246775_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246448_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246450_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
OutPort_1246506_1 | SOURCE
Port_1246553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246554_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246553_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246554_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246774_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246602_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246604_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246602_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246612_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246604_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246612_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246764_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246973_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246764_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246774_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246974_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246784_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246790_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246784_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246798_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246804_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246798_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246861_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246812_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246869_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246859_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246861_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246859_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246957_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247323_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246957_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247162_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246973_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246974_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246973_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247324_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247154_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247170_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247261_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247170_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247251_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247253_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247315_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247331_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247323_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247323_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247331_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247337_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247451_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247408_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247410_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247451_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1247594_1 | SOURCEANDSINK | K1 2
Port_1314993_0 | SOURCEANDSINK | K1 2
Port_1247594_2 | SOURCEANDSINK | K1 2
Port_1247595_1 | SOURCEANDSINK | K1 2
Port_1247594_3 | SOURCEANDSINK | K1 2
Port_1248426_0 | SOURCEANDSINK | K1 2
Port_1247654_0 | SOURCEANDSINK | K1 2
Port_1248299_2 | SOURCEANDSINK | K1 2
Port_1247654_1 | SOURCEANDSINK | K1 2
Port_1247724_1 | SOURCEANDSINK | K1 2
Port_1247716_0 | SOURCEANDSINK | K1 2
Port_1247724_2 | SOURCEANDSINK | K1 2
Port_1247716_1 | SOURCEANDSINK | K1 2
Port_1247736_1 | SOURCEANDSINK | K1 2
Port_1247736_2 | SOURCEANDSINK | K1 2
Port_1248191_0 | SOURCEANDSINK | K1 2
Port_1247758_0 | SOURCEANDSINK | K1 2
Port_1247936_2 | SOURCEANDSINK | K1 2
Port_1247758_1 | SOURCEANDSINK | K1 2
Port_1247843_1 | SOURCEANDSINK | K1 2
Port_1247841_0 | SOURCEANDSINK | K1 2
Port_1247843_2 | SOURCEANDSINK | K1 2
Port_1247841_1 | SOURCEANDSINK | K1 2
Port_1247881_1 | SOURCEANDSINK | K1 2
Port_1247924_0 | SOURCEANDSINK | K1 2
Port_1247936_3 | SOURCEANDSINK | K1 2
Port_1247924_1 | SOURCEANDSINK | K1 2
Port_1247980_1 | SOURCEANDSINK | K1 2
Port_1247936_1 | SOURCEANDSINK | K1 2
Port_1247937_1 | SOURCEANDSINK | K1 2
Port_1247937_0 | SOURCEANDSINK | K1 2
Port_1248101_2 | SOURCEANDSINK | K1 2
Port_1247944_0 | SOURCEANDSINK | K1 2
Port_1248078_3 | SOURCEANDSINK | K1 2
Port_1247944_1 | SOURCEANDSINK | K1 2
Port_1247978_0 | SOURCEANDSINK | K1 2
Port_1247980_2 | SOURCEANDSINK | K1 2
Port_1247978_1 | SOURCEANDSINK | K1 2
Port_1248078_1 | SOURCEANDSINK | K1 2
Port_1248078_2 | SOURCEANDSINK | K1 2
Port_1248089_0 | SOURCEANDSINK | K1 2
Port_1248101_3 | SOURCEANDSINK | K1 2
Port_1248089_1 | SOURCEANDSINK | K1 2
Port_1248152_1 | SOURCEANDSINK | K1 2
Port_1248101_1 | SOURCEANDSINK | K1 2
Port_1248102_1 | SOURCEANDSINK | K1 2
Port_1248102_0 | SOURCEANDSINK | K1 2
Port_1248190_2 | SOURCEANDSINK | K1 2
Port_1248111_0 | SOURCEANDSINK | K1 2
Port_1248158_2 | SOURCEANDSINK | K1 2
Port_1248111_1 | SOURCEANDSINK | K1 2
Port_1248150_0 | SOURCEANDSINK | K1 2
Port_1248152_2 | SOURCEANDSINK | K1 2
Port_1248150_1 | SOURCEANDSINK | K1 2
Port_1248158_1 | SOURCEANDSINK | K1 2
Port_1248180_0 | SOURCEANDSINK | K1 2
Port_1248190_3 | SOURCEANDSINK | K1 2
Port_1248180_1 | SOURCEANDSINK | K1 2
Port_1248206_2 | SOURCEANDSINK | K1 2
Port_1248190_1 | SOURCEANDSINK | K1 2
Port_1248191_1 | SOURCEANDSINK | K1 2
Port_1248200_0 | SOURCEANDSINK | K1 2
Port_1248206_1 | SOURCEANDSINK | K1 2
Port_1248200_1 | SOURCEANDSINK | K1 2
Port_1248254_1 | SOURCEANDSINK | K1 2
Port_1248252_0 | SOURCEANDSINK | K1 2
Port_1248254_2 | SOURCEANDSINK | K1 2
Port_1248252_1 | SOURCEANDSINK | K1 2
Port_1248262_1 | SOURCEANDSINK | K1 2
Port_1248262_2 | SOURCEANDSINK | K1 2
Port_1248289_0 | SOURCEANDSINK | K1 2
Port_1248299_3 | SOURCEANDSINK | K1 2
Port_1248289_1 | SOURCEANDSINK | K1 2
Port_1248315_1 | SOURCEANDSINK | K1 2
Port_1248299_1 | SOURCEANDSINK | K1 2
Port_1248300_1 | SOURCEANDSINK | K1 2
Port_1248300_0 | SOURCEANDSINK | K1 2
Port_1248766_2 | SOURCEANDSINK | K1 2
Port_1248309_0 | SOURCEANDSINK | K1 2
Port_1248315_2 | SOURCEANDSINK | K1 2
Port_1248309_1 | SOURCEANDSINK | K1 2
Port_1248361_1 | SOURCEANDSINK | K1 2
Port_1248323_0 | SOURCEANDSINK | K1 2
Port_1248369_2 | SOURCEANDSINK | K1 2
Port_1248323_1 | SOURCEANDSINK | K1 2
Port_1248359_0 | SOURCEANDSINK | K1 2
Port_1248361_2 | SOURCEANDSINK | K1 2
Port_1248359_1 | SOURCEANDSINK | K1 2
Port_1248369_1 | SOURCEANDSINK | K1 2
Port_1248403_0 | SOURCEANDSINK | K1 2
Port_1248626_2 | SOURCEANDSINK | K1 2
Port_1248403_1 | SOURCEANDSINK | K1 2
Port_1248524_1 | SOURCEANDSINK | K1 2
Port_1248425_1 | SOURCEANDSINK | K1 2
Port_1248426_1 | SOURCEANDSINK | K1 2
Port_1248425_2 | SOURCEANDSINK | K1 2
Port_1248767_0 | SOURCEANDSINK | K1 2
Port_1248425_3 | SOURCEANDSINK | K1 2
Port_1248627_0 | SOURCEANDSINK | K1 2
Port_1248522_0 | SOURCEANDSINK | K1 2
Port_1248524_2 | SOURCEANDSINK | K1 2
Port_1248522_1 | SOURCEANDSINK | K1 2
Port_1248530_1 | SOURCEANDSINK | K1 2
Port_1248530_2 | SOURCEANDSINK | K1 2
Port_1248618_0 | SOURCEANDSINK | K1 2
Port_1248626_3 | SOURCEANDSINK | K1 2
Port_1248618_1 | SOURCEANDSINK | K1 2
Port_1248672_1 | SOURCEANDSINK | K1 2
Port_1248626_1 | SOURCEANDSINK | K1 2
Port_1248627_1 | SOURCEANDSINK | K1 2
Port_1248634_0 | SOURCEANDSINK | K1 2
Port_1248680_2 | SOURCEANDSINK | K1 2
Port_1248634_1 | SOURCEANDSINK | K1 2
Port_1248670_0 | SOURCEANDSINK | K1 2
Port_1248672_2 | SOURCEANDSINK | K1 2
Port_1248670_1 | SOURCEANDSINK | K1 2
Port_1248680_1 | SOURCEANDSINK | K1 2
Port_1248750_0 | SOURCEANDSINK | K1 2
Port_1248766_3 | SOURCEANDSINK | K1 2
Port_1248750_1 | SOURCEANDSINK | K1 2
Port_1248782_1 | SOURCEANDSINK | K1 2
Port_1248766_1 | SOURCEANDSINK | K1 2
Port_1248767_1 | SOURCEANDSINK | K1 2
Port_1248776_0 | SOURCEANDSINK | K1 2
Port_1249043_2 | SOURCEANDSINK | K1 2
Port_1248776_1 | SOURCEANDSINK | K1 2
Port_1248845_1 | SOURCEANDSINK | K1 2
Port_1248782_2 | SOURCEANDSINK | K1 2
Port_1249044_0 | SOURCEANDSINK | K1 2
Port_1248790_0 | SOURCEANDSINK | K1 2
Port_1248853_2 | SOURCEANDSINK | K1 2
Port_1248790_1 | SOURCEANDSINK | K1 2
Port_1248843_0 | SOURCEANDSINK | K1 2
Port_1248845_2 | SOURCEANDSINK | K1 2
Port_1248843_1 | SOURCEANDSINK | K1 2
Port_1248853_1 | SOURCEANDSINK | K1 2
Port_1249001_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 61
Port_1249001_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 61
Port_1249033_0 | SOURCEANDSINK | K1 2
Port_1249043_3 | SOURCEANDSINK | K1 2
Port_1249033_1 | SOURCEANDSINK | K1 2
Port_1249057_1 | SOURCEANDSINK | K1 2
Port_1249043_1 | SOURCEANDSINK | K1 2
Port_1249044_1 | SOURCEANDSINK | K1 2
Port_1249051_0 | SOURCEANDSINK | K1 2
Port_1249057_2 | SOURCEANDSINK | K1 2
Port_1249051_1 | SOURCEANDSINK | K1 2
Port_1249071_2 | SOURCEANDSINK | K1 2
Port_1249071_1 | SOURCEANDSINK | K1 2
Port_1249162_0 | SOURCEANDSINK | K1 2
Port_1249162_1 | SOURCEANDSINK | K1 2
Port_1249221_1 | SOURCEANDSINK | K1 2
Port_1249219_0 | SOURCEANDSINK | K1 2
Port_1249221_2 | SOURCEANDSINK | K1 2
Port_1249219_1 | SOURCEANDSINK | K1 2
Port_1249227_1 | SOURCEANDSINK | K1 2
Port_1249227_2 | SOURCEANDSINK | K1 2
Port_1249439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317915_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249439_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249439_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249597_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249489_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249596_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249489_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249513_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249507_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249513_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249507_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249558_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249521_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249566_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249521_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249556_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249558_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249556_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249566_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249588_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249596_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249588_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249610_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249596_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249597_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249604_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249610_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249604_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249618_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249664_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249618_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249656_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249658_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249656_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1249758_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 62
Port_1249758_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 62
Port_1249778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 63
Port_1249778_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 63
Port_1249812_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250195_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249812_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249932_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249820_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250353_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249820_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249820_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250196_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249924_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250093_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249924_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249946_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249932_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250094_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249940_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249946_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249992_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249954_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249998_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249954_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249990_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249992_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249990_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1249998_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250079_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250107_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250159_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250089_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250093_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250089_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250101_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250090_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250101_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250107_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250093_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250094_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250113_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250165_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250157_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250159_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250157_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250165_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250195_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250195_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250205_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250205_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250251_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250278_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250268_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 64
Port_1250316_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 64
Port_1250344_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250426_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250344_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250366_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250426_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250366_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250398_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250398_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1419336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1250643_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250651_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250643_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250778_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250652_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250652_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250770_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250770_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250792_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250786_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250792_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250786_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250847_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250845_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250847_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250855_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250855_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1250896_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 65
Port_1250896_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 65
Port_1250936_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251035_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250936_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250944_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250945_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250944_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253461_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250994_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251002_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251018_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251027_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251310_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251027_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251049_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251035_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251426_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251036_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252352_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251043_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251049_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251043_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251100_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251057_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251106_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251098_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251100_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251098_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251106_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251145_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251161_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251145_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251153_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251153_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251311_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251153_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251161_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251154_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251425_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251167_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251215_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251199_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251201_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251199_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251215_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251310_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251310_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251311_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251320_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251326_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251320_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251381_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251334_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251389_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251334_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251379_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251381_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251389_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251411_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251527_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251441_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251425_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251426_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251425_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251528_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251435_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251441_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251435_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251489_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251449_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251497_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251487_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251489_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251487_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251497_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251519_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251535_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251519_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251617_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251527_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251527_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251535_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251541_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251658_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251541_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251615_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251617_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251615_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251791_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252043_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251791_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251862_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251801_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251801_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252353_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251801_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251924_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251802_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252403_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251860_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251862_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251860_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251899_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251908_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251931_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251908_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251921_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251923_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251931_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251923_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251924_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251923_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251967_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251953_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251974_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251953_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251964_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251966_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251964_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251974_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251967_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1251966_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252044_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252029_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252043_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252029_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252059_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252043_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252053_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252181_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252053_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252059_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252779_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252067_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252151_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252067_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252143_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252151_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252173_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252189_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252173_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252201_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252181_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252189_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252778_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252195_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252201_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252195_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252242_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252286_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252242_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252276_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252278_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252286_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252344_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252352_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252344_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252366_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252352_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252366_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252393_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252403_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252393_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252404_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252404_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253645_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252413_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252457_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252413_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252449_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252779_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252778_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252786_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1252786_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253194_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253314_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253265_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253265_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253275_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253305_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253313_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253305_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253376_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253313_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253314_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253313_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253406_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253321_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253370_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253321_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253376_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253336_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253424_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253452_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253460_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253452_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253460_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253646_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253470_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253476_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253484_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253568_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253498_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253576_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253498_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253566_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253568_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253566_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253576_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253603_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 66
Port_1253603_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 66
Port_1253637_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253758_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253661_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253645_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253646_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253645_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253759_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253655_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253661_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253675_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253669_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253675_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253669_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253712_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253683_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253720_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253683_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253710_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253712_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253710_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253742_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253772_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253784_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253754_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253758_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253754_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253755_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253766_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253755_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253772_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253758_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253759_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253778_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253784_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253836_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253792_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253844_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253792_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253834_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253836_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253834_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1253894_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253902_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253894_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253953_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253902_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253903_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253947_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255370_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253947_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254018_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253953_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254451_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254016_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254018_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254053_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255206_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254158_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254827_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254142_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254143_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254700_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254152_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254152_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254212_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254158_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1255742_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254210_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254212_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254210_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254247_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254292_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254300_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254372_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254301_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254301_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1256231_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254370_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254372_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254380_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254380_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1254422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 67
Port_1254422_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 67
Port_1254442_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
