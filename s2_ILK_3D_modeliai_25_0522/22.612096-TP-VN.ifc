Properties of the parts of a building model (IFC2X3), part 20 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1380707_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380628_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380628_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380648_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380682_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380676_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380678_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380682_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380698_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380706_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380698_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382926_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380706_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382865_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380706_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380707_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380710_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382926_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380710_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380738_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380730_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380746_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380740_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380740_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380756_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380975_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380748_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380756_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380748_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380758_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380793_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380758_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380789_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380809_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380817_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380809_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380827_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380817_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380818_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380974_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380821_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380827_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380821_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380837_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380829_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380829_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380883_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380839_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380887_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380839_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380883_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380887_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380964_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380974_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380964_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380984_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380974_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380975_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380978_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380984_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380978_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381028_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380986_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381032_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1380986_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381026_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381028_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381026_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381032_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381048_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381087_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381058_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381059_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381058_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381174_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381059_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381250_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381062_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381087_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381062_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381135_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381091_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381139_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381133_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381135_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381133_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381139_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381173_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381173_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381177_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381224_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381177_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381218_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381220_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381240_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381250_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381240_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381292_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381250_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381251_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381324_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381254_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381296_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381290_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381292_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381290_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381296_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381314_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381324_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381314_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381365_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381324_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381325_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381325_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381397_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381328_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381369_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381328_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381363_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381365_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381385_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381397_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381385_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381437_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381397_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381398_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381398_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381401_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381441_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381435_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381437_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381441_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381473_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381473_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381501_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381489_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381490_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381489_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381490_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381716_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381493_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381501_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381493_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381503_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381537_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381503_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381531_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381533_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381537_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381553_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381561_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381571_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381561_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381562_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381562_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381631_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381565_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381571_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381603_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381573_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381607_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381573_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381601_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381603_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381607_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381623_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381631_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381667_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381631_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381635_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381671_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381665_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381667_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381671_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381706_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381716_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381706_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381737_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381716_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381717_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381811_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381720_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381737_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381720_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381767_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381739_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381771_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381739_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381765_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381767_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381771_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381811_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382318_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381811_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382228_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381978_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382227_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381978_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382012_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381986_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382014_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1381986_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382051_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382012_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382014_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382018_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382055_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382018_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382049_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382051_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382049_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382055_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382213_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382227_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382213_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382279_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382227_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382228_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382231_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382283_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382231_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382277_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382279_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382277_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382283_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382305_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382305_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382347_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382317_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382317_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382785_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382321_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382480_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382321_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382362_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382347_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382481_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382349_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382364_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382349_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382374_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382362_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382364_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382368_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382413_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382376_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382417_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382376_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382411_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382413_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382417_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382470_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382480_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382470_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382531_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382480_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382481_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382484_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382535_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382484_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382529_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382531_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382529_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382535_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382551_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382561_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382561_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382562_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382562_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382638_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382565_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382610_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382604_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382606_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382604_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382628_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382638_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382628_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382638_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382639_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382639_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382721_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382642_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382653_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382688_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382655_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382692_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382686_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382688_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382686_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382692_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382711_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382721_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382711_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382750_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382721_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382722_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382722_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382784_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382725_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382754_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382725_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382748_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382750_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382748_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382754_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382772_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382784_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382772_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382826_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382784_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382785_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382788_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382830_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382824_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382826_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382824_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382856_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382864_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382856_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382903_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382864_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382865_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382868_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382907_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382901_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382903_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382926_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382945_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382945_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382969_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382961_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382969_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1382961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383368_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383505_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383504_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383505_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383504_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459307_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383526_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383526_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385608_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383623_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383635_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383647_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383883_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383635_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383636_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383636_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1459306_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383639_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383639_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383655_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383647_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383798_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383649_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383657_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383649_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383669_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383657_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383661_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383669_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383671_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383703_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383671_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383697_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383697_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383703_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383719_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383729_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383729_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383730_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383730_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383797_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383733_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383767_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383733_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383761_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383763_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383761_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383767_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383785_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383797_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383785_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383832_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383797_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383798_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383801_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383836_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383801_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383830_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383832_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383836_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383860_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383882_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383860_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383894_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383882_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384654_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383882_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383883_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383894_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384540_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383896_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383896_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383914_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383908_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384184_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383908_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383943_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383914_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384280_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383916_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383945_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383916_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383955_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383943_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383945_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383949_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383955_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383949_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383965_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383957_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383967_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383995_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383989_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383991_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383989_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1383995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384011_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384105_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384011_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384036_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384021_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384022_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384021_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384106_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384022_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384025_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384036_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384025_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384072_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384038_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384076_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384070_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384072_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384070_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384076_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384097_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384105_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384097_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384148_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384105_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384106_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384109_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384152_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384146_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384148_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384146_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384152_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384176_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384184_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384176_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384184_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384185_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384279_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384188_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384224_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384188_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384218_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384220_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384271_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384279_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384271_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384314_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384279_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384280_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384283_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384318_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384283_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384312_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384314_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384312_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384351_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384451_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384375_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384363_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384364_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384363_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384452_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384364_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384539_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384367_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384375_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384367_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384377_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384415_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384377_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384409_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384411_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384409_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384415_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384443_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384451_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384443_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384451_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384452_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384513_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384507_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384509_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384529_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384529_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384539_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384540_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384539_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384616_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384543_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384551_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384543_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384553_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384589_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384583_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384585_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384583_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384604_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384619_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384604_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384613_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384615_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384615_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384616_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384645_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384653_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384645_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384729_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384764_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384653_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384657_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384733_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384657_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384727_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384729_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384733_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384751_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458105_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384775_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384850_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384763_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384764_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384763_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1458106_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384767_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384775_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384767_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384813_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384777_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384817_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384777_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384811_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384813_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384811_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384835_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385061_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384835_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384891_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384849_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385257_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384849_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384849_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384999_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384853_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384895_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384853_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384889_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384891_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384889_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384895_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384990_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384998_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384990_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384998_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385062_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384998_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1384999_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385002_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385038_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385002_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385032_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385034_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385032_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385053_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385061_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385053_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385088_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385061_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385062_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385065_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385092_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385065_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385086_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385088_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385086_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385092_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385109_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385887_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385159_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385119_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385419_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385119_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385120_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385119_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385888_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385120_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385256_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385123_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385163_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385123_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385157_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385159_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385157_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385246_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457670_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385246_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385271_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385256_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385257_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385256_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1457671_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385260_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385273_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385260_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385332_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385271_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385273_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385277_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385336_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385277_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385330_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385332_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385330_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385336_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385408_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385418_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385408_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385439_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385418_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385508_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385418_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385419_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385422_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385439_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385477_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385441_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385481_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385441_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385475_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385477_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385475_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385481_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385499_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385507_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385499_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385557_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385507_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385508_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385511_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385561_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385555_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385557_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385555_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385596_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385610_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385608_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385614_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385648_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385614_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385642_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385644_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385648_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385879_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385887_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385899_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385887_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385888_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385891_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385899_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385891_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385901_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385939_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385933_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385935_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385933_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1385939_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386029_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386030_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386029_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386033_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386033_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386221_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386223_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386221_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386445_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386433_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386433_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386480_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386445_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387021_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386466_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386482_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386480_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386482_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386486_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386524_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386486_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386518_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386520_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386524_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386732_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387642_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386732_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386758_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386746_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386747_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386746_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387643_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386747_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386839_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386750_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386758_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386750_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386768_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386760_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386768_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386760_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386810_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386770_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386814_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386808_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386810_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386808_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386814_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386829_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386839_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386829_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386876_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386839_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386903_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386843_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386880_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386843_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386874_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386876_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386874_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386880_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386895_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386903_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386895_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386968_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386903_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386904_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387294_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386907_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386972_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386907_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386966_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386968_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386966_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1386972_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387006_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387035_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387295_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387020_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387020_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387198_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387024_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387037_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387024_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387035_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387037_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387041_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387095_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387041_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387089_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387091_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387089_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387095_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387116_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387124_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387116_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387124_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387125_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387125_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387197_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387128_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387167_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387128_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387161_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387163_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387161_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387189_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387197_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387189_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387239_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387197_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387198_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387201_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387243_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387201_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387237_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387239_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387262_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387470_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387309_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387294_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387295_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387294_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387575_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387298_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387311_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387298_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387321_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387309_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387311_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387315_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387321_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387323_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387331_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387323_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387442_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387333_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387446_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387440_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387442_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387440_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387446_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387462_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387470_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387462_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387470_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387471_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387471_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387574_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387474_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387515_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387474_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387509_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387511_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387566_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387574_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387566_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387574_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387575_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387578_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387619_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387578_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387613_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387615_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387619_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387634_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387642_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387634_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387658_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387642_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387643_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387646_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387658_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387646_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387668_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387660_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387668_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387660_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387670_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387676_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387670_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387709_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387678_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387713_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387707_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387709_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387707_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387788_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387815_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387829_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387815_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387819_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389182_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387819_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387874_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387829_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389183_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387874_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387906_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387906_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387920_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387920_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389278_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387939_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388585_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387939_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387947_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388082_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387947_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388014_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387959_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387961_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387959_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388380_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387965_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388016_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388014_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388016_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388020_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388054_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388020_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388048_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388050_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388054_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388070_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388164_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388070_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388092_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388082_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388083_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388082_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388165_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388083_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388086_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447497_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388086_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388128_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388092_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1447498_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388094_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388132_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388094_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388126_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388128_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388132_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388148_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388164_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388148_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388164_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388165_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388168_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388206_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388168_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388200_0 | SOURCEANDSINK | vanduo šaltas - V1 2
