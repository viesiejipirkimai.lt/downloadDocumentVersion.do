Properties of the parts of a building model (IFC2X3), part 26 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1434795_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434793_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434799_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434815_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434835_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434904_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434835_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434836_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434839_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434908_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434839_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434902_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434904_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434902_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434908_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434926_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434942_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434926_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434956_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434942_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434943_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434946_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434956_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434946_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434964_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434958_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435053_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434977_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434964_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435054_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434966_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434977_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434966_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435019_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434979_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435023_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434979_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435017_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435019_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435017_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435045_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435053_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435045_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435103_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435053_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435054_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435057_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435107_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435057_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435101_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435103_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435101_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435107_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435123_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435414_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435123_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435139_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435140_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435139_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435573_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435140_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436168_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435145_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435145_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435262_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435167_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435266_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435167_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435260_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435262_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435260_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435266_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435406_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435414_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435530_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435414_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435415_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435415_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435572_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435418_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435534_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435418_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435528_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435530_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435528_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435564_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435572_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435564_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435655_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435572_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435576_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435659_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435576_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435653_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435655_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435653_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435675_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436024_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435724_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436169_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435708_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435708_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441892_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435709_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436600_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435714_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435865_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435714_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435772_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435724_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435949_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435726_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435774_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435726_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435778_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435837_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435778_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435831_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435833_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435831_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435837_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435853_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435865_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435853_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435918_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435865_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435866_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435866_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435948_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435869_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435922_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435869_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435916_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435918_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435916_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435922_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435938_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435948_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435938_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435992_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435948_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435949_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435952_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435996_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435952_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435990_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435992_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435990_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435996_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436014_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436024_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436014_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436099_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436024_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436025_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441891_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436028_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436103_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436028_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436097_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436099_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436097_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436103_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436158_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486825_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436158_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436304_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436168_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436169_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436168_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1468209_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436292_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436304_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436292_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1493495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436341_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486857_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436341_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436361_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436351_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1442097_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436351_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436352_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436351_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1468718_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436355_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436361_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436355_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1494290_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436590_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436600_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436590_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436616_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436600_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1442153_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436606_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436777_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436606_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436624_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436616_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436707_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436618_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436626_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436618_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436676_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436626_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436630_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436680_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436630_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436674_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436676_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436674_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436680_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436696_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436706_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436696_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436747_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436706_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436778_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436706_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436710_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436751_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436710_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436745_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436747_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436751_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436767_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436777_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436828_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436777_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436778_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436781_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436832_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436781_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436826_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436828_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436826_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436832_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436919_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437013_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436919_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437456_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436927_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436927_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436928_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436927_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463293_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436928_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437529_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436972_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437013_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1436972_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437013_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437014_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437014_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463403_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437019_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437237_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437019_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437070_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437027_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437349_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437029_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437072_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437029_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437121_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437070_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437072_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437076_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437125_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437076_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437119_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437121_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437119_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437125_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437141_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437149_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437141_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437193_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437149_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437238_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437149_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437150_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437150_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437348_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437153_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437197_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437153_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437191_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437193_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437191_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437225_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437237_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437225_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437320_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437237_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437241_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437324_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437241_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437318_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437320_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437318_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437324_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437340_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437348_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437421_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437348_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437349_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437352_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437425_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437352_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437419_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437421_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437419_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437425_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437456_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440127_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437487_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440126_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1465429_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437521_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437529_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437521_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437544_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437529_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437530_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437530_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463031_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437535_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437535_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437554_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437544_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437786_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437546_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437554_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437546_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437639_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437556_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437643_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437556_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437637_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437639_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437637_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437643_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437659_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437667_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437667_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437668_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437668_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437785_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437671_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437757_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437671_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437751_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437753_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437751_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437757_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437777_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437785_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437777_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437954_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437785_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437786_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437789_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437958_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437789_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437952_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437954_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437952_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437980_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438117_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438012_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437996_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463032_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437996_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437996_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438338_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438000_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438000_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438077_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438010_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438012_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438016_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438081_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438016_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438075_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438077_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438081_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438105_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438117_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438105_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438164_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438117_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438118_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438118_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438237_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438121_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438168_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438121_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438162_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438164_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438162_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438168_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438227_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438237_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438227_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438291_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438237_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438238_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438241_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438295_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438241_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438289_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438291_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438289_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438295_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438321_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438337_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438321_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438355_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438337_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438519_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438337_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438338_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438341_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438355_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438341_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438357_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438363_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438357_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438479_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438365_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438483_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438477_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438479_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438477_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438506_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438518_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438579_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438518_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438518_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438519_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438522_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438583_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438577_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438579_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438583_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438601_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438771_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438601_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438613_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438613_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438772_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438617_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438625_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438617_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438636_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438627_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438636_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438711_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438638_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438715_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438638_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438709_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438711_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438715_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438763_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438771_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438827_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438771_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438775_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438831_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438775_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438825_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438827_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438825_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438831_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438847_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438855_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438847_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438881_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438855_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438856_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438856_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465483_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438863_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438881_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438863_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438945_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438955_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438945_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438967_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438955_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438956_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438961_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438967_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438961_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438980_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438969_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438969_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438988_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438982_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438988_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438982_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439000_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438990_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439000_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438990_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439008_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439002_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439008_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439002_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439010_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439089_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439083_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439085_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439123_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439165_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439123_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439184_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439132_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439166_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439174_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439184_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439174_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439194_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439186_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439186_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439259_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439196_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439263_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439257_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439259_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439257_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439263_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439279_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439287_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439287_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439288_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439293_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439370_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439293_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439347_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439301_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439351_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439345_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439347_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439345_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439351_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439370_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439381_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439381_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439399_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439393_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439399_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439393_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439491_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439401_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439495_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439401_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439489_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439491_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439489_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439511_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439612_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439537_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439523_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1443774_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439523_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439524_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439523_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439613_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439524_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439730_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439529_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439537_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439529_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439586_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439539_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439588_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439539_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439584_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439586_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439584_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439588_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439604_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439612_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439604_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439612_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439616_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439625_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439616_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439688_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439627_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439692_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439686_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439688_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439686_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439692_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439710_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439730_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439710_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439998_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439730_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439731_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439731_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439736_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439736_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439752_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439746_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439752_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439746_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439764_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439754_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439764_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439754_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439823_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439766_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439827_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439766_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439821_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439823_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439821_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439827_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439843_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439849_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439843_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439901_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439849_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439850_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439929_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439853_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439905_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439853_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439899_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439901_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439899_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439905_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439921_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439929_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439921_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439974_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439929_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439930_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439930_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439998_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439933_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439978_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439933_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439972_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439974_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439972_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439978_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439998_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440025_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440049_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440041_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440041_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440057_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440051_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440057_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440051_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440114_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440126_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440114_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440162_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440126_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440127_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440154_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440162_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440154_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440508_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440478_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440773_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440478_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440518_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440680_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440510_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440895_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440510_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440588_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440518_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440896_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440520_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440594_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440520_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440586_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440590_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440586_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440594_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440588_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440590_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440671_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440679_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440671_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463493_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440679_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440680_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440683_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 5
Port_1440683_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 5
Port_1440699_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440765_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440773_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440783_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440773_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440774_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463492_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440777_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440783_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440777_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440848_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440785_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440854_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440785_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440846_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440850_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440846_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440854_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440848_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440883_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440895_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440883_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440947_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440895_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440896_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440899_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440947_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440899_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440955_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440949_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440955_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440949_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440965_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440957_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440965_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440957_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441047_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440967_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441051_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1440967_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441043_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441045_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441043_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441051_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441045_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441047_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441095_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441103_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441095_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441115_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441103_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441260_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441103_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441104_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441104_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463532_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441109_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441115_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441109_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441226_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441117_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441228_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441117_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441224_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441226_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441224_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441251_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441259_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441251_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441269_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441259_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441260_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441269_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467205_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1467204_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441338_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441318_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441526_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441318_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441348_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441336_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441720_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441336_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441338_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441342_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441348_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441342_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441350_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441358_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441350_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441452_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441360_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441473_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441450_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441452_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441450_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441456_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441456_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441473_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441500_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441526_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441500_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441526_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441527_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441527_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441719_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441530_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441632_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441530_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441548_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441538_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441633_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
