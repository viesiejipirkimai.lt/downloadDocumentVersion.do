Properties of the parts of a building model (IFC2X3), part 1 of 57

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 3b5bbf0d-af93-4f24-9eee-1719261267b4, NumberOfSaves: 468], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Project Number
Time: 2024-01-05T09:05:07+02:00
Written by: ODA SDAI 22.12
Made in: 23.1.10.4 - Exporter 23.2.2.0 - Alternate UI 23.2.2.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 54, 45, 7, 339197; RefLongitude: 25, 16, 31, 313663; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 7
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (9)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
0 a | 0 a | -3000
0 a esamo pastato | 0 a esamo pastato | -2130
1 a +-152.84 | 1 a +-152.84 | 0
1 a esamo pastato | 1 a esamo pastato | 1250
2 a | 2 a | 4500
3 a | 3 a | 9300
4 a V1 | 4 a V1 | 13800
5 a V1 | 5 a V1 | 18300
stogas | stogas | 22800

# IfcDistributionPort (38115)
Description: Flow
Name | FlowDirection | Group
Port_1102731_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1102731_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1117826_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1103431_0 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104321_2 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1103431_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1103487_0 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1103487_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104145_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1103802_0 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104551_2 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1103802_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1103913_0 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1103913_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104416_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1103968_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1103968_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104639_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1103989_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104778_2 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1103989_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1103991_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104732_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1103991_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118767_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104008_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105085_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1104008_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1104010_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1104958_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1104010_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118471_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1104088_0 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104285_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104088_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104145_2 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104286_0 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104281_0 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104285_3 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104281_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104315_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104282_0 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104315_2 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104282_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104321_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104285_2 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104286_1 | SOURCEANDSINK | Lietaus nuotekos - L1 1
Port_1104408_0 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104539_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104408_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104416_2 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104540_0 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104535_0 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104539_3 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104535_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104545_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104536_0 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104545_2 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104536_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104551_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104539_2 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104540_1 | SOURCEANDSINK | Lietaus nuotekos - L1 2
Port_1104631_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104639_2 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104631_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104653_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104647_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104653_2 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104647_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104830_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104724_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104766_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104724_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104732_2 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104767_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104762_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104766_3 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104762_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104772_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104763_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104772_2 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104763_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104778_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104766_2 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104767_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1104830_2 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104887_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104852_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104886_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104852_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104872_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104898_2 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104872_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104882_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104886_3 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104882_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104892_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104883_0 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104892_2 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104883_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104898_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104886_2 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104887_1 | SOURCEANDSINK | Lietaus nuotekos - L1 4
Port_1104958_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105074_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105041_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105073_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105041_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105069_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105073_3 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105069_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105079_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105070_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105079_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105070_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105085_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105073_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105074_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1105173_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162299_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1105173_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1105321_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107757_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1105321_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1105353_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108362_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1105353_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1105385_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1105385_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107359_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1105397_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1105397_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1107973_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1106663_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106663_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106747_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106739_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106747_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106739_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106761_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106761_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106767_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106767_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106879_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1106879_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107010_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107010_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107026_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107020_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107026_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107020_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107071_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107065_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107124_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107065_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107071_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107125_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107120_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107124_3 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107120_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107130_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107121_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107130_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107121_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107136_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107124_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107125_1 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107136_2 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1162237_0 | SOURCEANDSINK | Lietaus nuotekos - L1 3
Port_1107351_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107359_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107351_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107373_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107367_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107373_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107367_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107475_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107467_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107475_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107467_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107521_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107509_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107521_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107509_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107533_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107527_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107727_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107527_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107533_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107728_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107725_0 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107727_3 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107725_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107757_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107727_2 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107728_1 | SOURCEANDSINK | Lietaus nuotekos - L1 9
Port_1107965_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1107973_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1107965_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143125_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108001_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1143192_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108001_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108167_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108167_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108183_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108177_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108183_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108177_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108195_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108195_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108241_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108226_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175813_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108226_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108236_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108240_3 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108236_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108246_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108237_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108246_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108237_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108252_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108240_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1500748_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108240_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108241_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108252_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1175753_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108354_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108362_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108354_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108376_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108370_0 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108376_2 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1108370_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1499199_1 | SOURCEANDSINK | Lietaus nuotekos - L1 11
Port_1109074_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109074_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109135_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109129_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220483_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109129_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1502914_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109135_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1220484_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109445_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1214299_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109445_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122100_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109463_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1499060_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109463_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1499064_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109477_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1499094_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109477_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109503_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109503_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125096_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1109673_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1109673_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129212_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1109687_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109687_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109709_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109709_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109723_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109717_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109723_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109717_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109735_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109729_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1502900_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109729_1 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1109735_2 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1502901_0 | SOURCEANDSINK | Lietaus nuotekos - L1 13
Port_1110457_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111676_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110457_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110571_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111644_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110571_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110587_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111612_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110587_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110607_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111375_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110607_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1110786_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111252_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110786_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110788_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111306_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110788_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110790_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111338_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110790_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110792_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281559_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110792_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110880_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1281143_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110880_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110934_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110934_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111146_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110942_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111146_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1110942_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111158_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111152_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111246_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111152_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111158_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111333_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111244_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111246_3 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111244_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111252_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111246_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111247_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111247_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111300_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111298_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111300_3 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111298_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111306_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111300_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111301_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111301_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111332_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111330_0 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111332_3 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111330_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111338_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111332_2 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111333_1 | SOURCEANDSINK | Lietaus nuotekos - L1 20
Port_1111367_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111375_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111367_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111444_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111432_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111444_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111432_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111456_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111450_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111670_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111450_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111456_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111607_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111604_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111606_3 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111604_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111612_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111606_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111639_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111606_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111607_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111636_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111638_3 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111636_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111644_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111638_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111671_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111638_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111639_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111668_0 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111670_3 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111668_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111676_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111670_2 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1111671_1 | SOURCEANDSINK | Lietaus nuotekos - L1 5
Port_1112151_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157289_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112151_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112233_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112233_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112417_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112382_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112423_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112470_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112416_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159579_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112416_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112416_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112423_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1157225_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112551_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159578_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112551_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112565_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112559_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190331_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112602_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112565_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1190332_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112594_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312702_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112594_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1858443_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112602_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112838_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1152002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112838_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151781_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112925_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235467_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112925_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1243795_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112933_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1151744_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1112933_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233451_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1113160_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1246553_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1113160_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1243795_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1113226_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1243787_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1113226_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1311315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1113313_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1113313_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1303794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1113383_0 | SOURCEANDSINK | K1 2
Port_1315117_1 | SOURCEANDSINK | K1 2
Port_1113383_1 | SOURCEANDSINK | K1 2
Port_1113482_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1317914_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1113482_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1113596_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1176806_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1113596_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1113624_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1224261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1113624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 9
Port_1113800_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1250944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1113800_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1419566_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1113880_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121574_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1113880_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128429_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1114110_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1253902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1114110_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1503297_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 17
Port_1114120_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1114120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1114150_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1114150_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1114239_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1117826_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114239_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114275_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114275_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1387816_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114372_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1357234_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114372_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1354817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114402_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118340_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114402_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1114515_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1115007_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117424_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115007_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115808_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115288_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117584_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115288_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115322_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117777_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115322_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115441_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117432_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115441_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1425655_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115534_0 | SOURCEANDSINK | vanduo šaltas - V1 4
Port_1115534_1 | SOURCEANDSINK | vanduo šaltas - V1 4
Port_1115628_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117457_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115628_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1425657_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115727_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115777_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115727_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115749_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115739_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115749_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115739_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115777_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117770_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115800_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115808_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115800_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115816_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115810_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115816_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1115810_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117424_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117425_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117424_3 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117432_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117425_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117449_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117449_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117450_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117449_3 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117457_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117450_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117576_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117576_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117577_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117576_3 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117584_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117577_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117769_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117769_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117770_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117769_3 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1117777_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1118340_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424503_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118340_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425709_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118351_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425708_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118405_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118405_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1328942_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1118453_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118471_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118453_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118529_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118519_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118529_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118519_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118594_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118584_0 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118594_2 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118584_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1150799_1 | SOURCEANDSINK | Lietaus nuotekos - L1 8
Port_1118753_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118767_2 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118753_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118781_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118775_0 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118781_2 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118775_1 | SOURCEANDSINK | Lietaus nuotekos - L1 6
Port_1118911_1 | SOURCEANDSINK | K1 2
Port_1118911_2 | SOURCEANDSINK | K1 2
Port_1118911_3 | SOURCEANDSINK | K1 2
Port_1131581_0 | SOURCEANDSINK | K1 2
Port_1118912_0 | SOURCEANDSINK | K1 2
Port_1118912_1 | SOURCEANDSINK | K1 2
Port_1119184_1 | SOURCEANDSINK | K1 2
Port_1119185_1 | SOURCEANDSINK | K1 2
Port_1119184_2 | SOURCEANDSINK | K1 2
Port_1139417_0 | SOURCEANDSINK | K1 2
Port_1119184_3 | SOURCEANDSINK | K1 2
Port_1139651_0 | SOURCEANDSINK | K1 2
Port_1119185_0 | SOURCEANDSINK | K1 2
Port_1131580_2 | SOURCEANDSINK | K1 2
Port_1119216_0 | SOURCEANDSINK | K1 2
Port_1139650_2 | SOURCEANDSINK | K1 2
Port_1119216_1 | SOURCEANDSINK | K1 2
Port_1139848_1 | SOURCEANDSINK | K1 2
Port_1119339_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119569_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119339_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119347_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1168487_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119347_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119348_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119347_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140045_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119348_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119457_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119553_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1856849_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119887_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119569_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119570_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119569_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1141371_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119570_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1140670_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119887_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119900_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119887_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119916_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1119916_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1121135_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121136_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121135_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142922_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121135_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142816_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121136_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1179402_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121180_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1142815_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121180_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121196_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121190_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144127_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121190_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121210_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121196_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121325_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121210_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121259_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121244_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121258_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121258_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1145447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121258_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144400_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121316_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143901_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144030_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121325_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121324_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1144128_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121324_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121332_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1143497_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1121480_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121494_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121480_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121508_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121494_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129456_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121502_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121508_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1121566_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121574_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121566_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121588_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121582_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121588_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121582_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121655_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128220_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121669_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121663_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121669_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121663_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121683_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121677_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121683_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1121677_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1122055_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122100_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122055_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122515_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122507_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122515_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122507_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122616_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122624_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122616_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122638_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128142_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122632_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122638_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122632_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1122905_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1499060_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1122905_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1123237_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1123229_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1123237_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1123229_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1123293_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1209416_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1123293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1209424_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1123309_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1209416_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1123309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 15
Port_1124047_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1297268_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124047_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124061_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124055_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124061_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124055_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124075_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124069_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129740_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124069_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1124075_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129741_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1125096_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125110_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125110_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125255_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125208_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125255_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125208_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125457_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125449_0 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125457_2 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125449_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1498861_1 | SOURCEANDSINK | Lietaus nuotekos - L1 10
Port_1125912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1125912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1125926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1125920_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1125926_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1125920_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126263_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126255_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126263_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126255_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126299_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126291_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126299_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1126291_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127982_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127277_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127277_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127283_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204574_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127283_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204801_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127337_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127491_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127480_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127490_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127480_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127491_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127606_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127614_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127622_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205302_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205019_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127628_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205436_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127982_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204271_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127982_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204174_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127997_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128099_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1127997_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203851_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128091_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204053_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128099_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128100_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128099_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128107_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128100_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204173_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128107_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203929_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1128131_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1212022_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128141_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128141_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203616_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1128220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128221_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128220_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202408_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128221_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1215448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128274_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201820_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128274_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128288_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128282_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201762_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201611_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128288_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201646_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128421_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128429_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128421_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128443_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128437_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128802_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128437_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128443_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128803_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128612_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128620_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128612_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128634_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1218129_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128794_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128802_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128802_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128803_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128844_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201349_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200652_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128852_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201032_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128874_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128882_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128874_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128902_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128882_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201154_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128883_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201031_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1128902_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200844_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1129204_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129212_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129204_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129242_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129234_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129242_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129234_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129352_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129342_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129352_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129342_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129388_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129388_2 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1221815_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129408_0 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1222142_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129408_1 | SOURCEANDSINK | Lietaus nuotekos - L1 7
Port_1129447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200117_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198122_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1221558_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129455_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129456_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129455_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129674_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129665_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197611_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129665_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129673_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129674_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129673_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200118_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129673_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129681_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129681_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1129740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129741_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129740_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205967_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129777_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205966_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129777_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129793_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129787_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205803_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129787_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205636_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129793_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205804_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1129822_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129830_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129822_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129908_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129830_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129831_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129831_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129900_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129908_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206093_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1129964_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130186_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1129964_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130063_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1129972_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1256580_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1129972_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1129973_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1129972_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130187_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1129973_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130055_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130063_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130055_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130077_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130071_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130077_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130071_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130085_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130091_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206187_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130178_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130194_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130178_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130235_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130186_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130187_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130186_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130229_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130235_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130229_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130282_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130276_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206273_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130276_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206274_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130290_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206492_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206632_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130317_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206736_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130317_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206493_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130330_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207022_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130330_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130354_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130348_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130354_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130348_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206825_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1130562_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130598_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130562_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130640_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130598_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1158111_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130620_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130640_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130700_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130646_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1159217_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1130646_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
