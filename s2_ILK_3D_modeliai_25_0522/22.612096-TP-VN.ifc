Properties of the parts of a building model (IFC2X3), part 34 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1482310_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482314_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482310_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482318_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482312_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482314_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482318_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482360_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482345_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482359_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482345_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482371_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482359_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482371_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482411_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482373_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482411_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482373_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482427_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482427_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482435_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482436_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482435_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482535_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482439_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482445_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482439_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482455_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482447_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482455_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482447_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482502_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482457_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482506_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482457_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482500_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482502_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482500_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482522_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482534_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482582_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482534_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482535_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482538_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482586_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482538_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482580_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482582_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482580_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482586_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482604_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482628_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482604_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483134_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482628_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482629_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482632_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482744_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482632_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482648_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482642_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482648_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482642_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482658_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482650_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482658_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482650_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482704_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482660_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482708_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482660_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482702_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482704_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482702_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482732_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482744_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482732_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482744_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482745_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482844_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482748_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482812_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482748_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482812_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482830_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482984_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482830_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482856_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482844_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482845_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482844_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483056_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482845_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483134_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482848_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482848_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482858_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482941_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482858_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482935_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482937_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482935_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482941_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482976_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482984_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482976_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482984_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482985_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482985_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483055_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482988_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483029_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1482988_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483023_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483025_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483029_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483047_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483055_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483047_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483113_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483055_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483056_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483059_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483117_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483059_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483111_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483113_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483117_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483134_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483145_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483145_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483169_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483169_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483301_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483171_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483300_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483171_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483198_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483192_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483198_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483192_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483200_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483267_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483263_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483265_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483263_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483267_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483294_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483300_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483294_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483339_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483300_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483304_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483341_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483304_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483337_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483339_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483337_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483341_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483387_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483397_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483387_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483469_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483397_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483398_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483419_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483433_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483419_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485143_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483433_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483434_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483433_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1494761_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483455_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483924_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483455_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483481_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483467_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484878_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483467_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483469_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483473_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483773_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483473_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483489_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483481_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483860_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483483_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483697_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483506_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483489_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483491_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483491_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483593_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483495_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483552_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483508_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483554_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483550_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483552_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483550_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483554_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483584_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483592_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483584_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483669_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483592_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483698_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483592_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483593_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483596_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483673_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483596_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483667_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483669_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483673_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483689_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483697_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483743_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483697_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483698_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483701_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483747_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483741_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483743_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483741_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483747_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483763_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483773_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483820_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483773_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483774_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483859_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483777_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483824_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483777_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483816_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483818_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483816_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483824_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483818_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483820_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483851_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483859_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483851_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483894_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483859_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483860_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483863_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483898_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483863_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483892_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483894_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483892_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483898_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483916_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483924_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483916_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483934_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483924_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483925_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483925_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483928_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483928_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483944_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483934_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484027_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483936_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483944_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483936_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483995_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483946_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483997_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483946_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483993_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483995_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483993_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1483997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484015_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484030_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484015_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484024_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484026_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484024_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484030_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484026_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484062_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484026_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484046_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484046_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484059_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484061_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484059_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484061_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484062_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484081_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484081_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484161_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484089_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484090_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484089_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484405_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484090_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484496_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484093_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484250_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484093_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484211_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484161_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484163_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484163_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484332_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484167_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484215_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484167_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484209_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484211_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484209_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484215_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484242_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484250_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484242_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484250_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484251_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484251_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484331_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484254_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484307_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484254_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484301_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484303_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484301_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484307_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484323_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484331_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484323_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484374_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484331_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484335_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484378_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484335_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484372_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484374_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484372_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484378_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484396_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484404_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484396_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484452_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484404_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484405_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484408_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484456_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484408_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484450_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484452_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484450_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484456_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484488_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484599_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484488_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484506_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484496_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484497_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484496_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484805_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484497_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484877_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484500_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484500_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484508_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484524_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484569_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484522_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484524_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484528_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484573_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484528_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484567_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484569_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484567_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484589_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484599_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484589_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484599_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484600_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484600_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484734_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484603_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484705_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484603_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484699_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484701_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484705_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484726_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484734_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484726_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484734_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484735_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484735_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484738_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484778_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484738_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484772_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484774_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484778_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484796_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484804_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484796_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484804_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484805_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484808_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484851_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484847_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484849_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484847_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484851_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484867_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484959_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484867_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484887_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484877_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484878_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484877_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485076_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484881_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484887_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484935_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484889_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484937_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484889_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484933_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484935_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484933_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484953_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484959_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484953_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485047_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484959_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484960_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484960_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484963_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485051_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1484963_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485045_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485047_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485045_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485051_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485069_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485075_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485075_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485076_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485079_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485113_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485079_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485109_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485111_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485109_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485113_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485131_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485143_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485131_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485153_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485145_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485153_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485145_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485179_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485331_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485179_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485393_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485215_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485356_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485215_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486743_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485331_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485356_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485357_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1485369_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486629_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485369_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485409_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485391_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485393_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485391_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486359_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485397_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486662_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485397_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485433_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485409_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486663_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485411_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485411_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485445_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486225_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485435_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485669_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485435_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485468_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485445_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485834_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485447_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485470_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485447_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485482_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485468_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485470_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485474_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485561_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485474_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485533_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485482_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485562_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485484_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485537_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485484_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485531_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485533_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485537_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485553_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485561_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485553_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485573_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485561_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485562_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485565_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485565_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485610_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485575_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485648_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485575_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485608_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485610_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485608_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485648_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485657_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485669_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485657_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485716_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485669_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485670_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485670_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485673_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485720_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485673_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485714_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485716_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485714_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485720_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485753_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485763_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485801_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485763_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485764_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485764_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485767_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485805_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485799_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485801_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485799_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485805_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485821_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485944_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485821_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485845_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485833_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485834_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485833_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485945_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485837_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485845_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485837_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485902_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485847_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485904_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485847_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485900_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485902_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485904_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485936_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485944_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485936_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485981_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485944_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485945_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485948_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485985_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485948_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485979_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485981_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485979_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1485985_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486001_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486001_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486051_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486009_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486009_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486086_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486010_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486224_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486013_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486057_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486013_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486049_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486053_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486057_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486051_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486053_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486085_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486086_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486085_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486197_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486089_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486196_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486089_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486122_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486114_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486122_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486114_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486124_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486167_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486124_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486163_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486163_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486167_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486185_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486200_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486185_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486194_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486196_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486194_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486196_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486216_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486328_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486216_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486234_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486224_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486225_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486224_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486329_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486228_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486234_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486244_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486236_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486244_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486295_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486246_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486299_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486246_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486293_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486295_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486293_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486299_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486315_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486332_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486315_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486326_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486328_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486328_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486329_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486350_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486465_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486350_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486368_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486630_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486358_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486359_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486358_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486548_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486362_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486368_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486412_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486370_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486414_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486410_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486412_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486414_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486457_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486465_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486457_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486513_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486465_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486466_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486466_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486547_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486469_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486517_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486469_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486511_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486513_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486517_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486541_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486547_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486541_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486595_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486547_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486548_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486551_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486597_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486551_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486593_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486595_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486593_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486597_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486618_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486633_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486618_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486627_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486629_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486633_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486629_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486630_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486652_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486662_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486652_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486709_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486662_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486663_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486666_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486713_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486666_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486707_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486709_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486713_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486733_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486743_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486733_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486765_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486745_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486765_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486745_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486777_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486767_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486777_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486767_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486796_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486779_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486796_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486779_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486815_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486825_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486968_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486825_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486826_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486845_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486857_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486845_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1488581_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486857_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486858_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1486960_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486968_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486960_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486976_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486970_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486970_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487007_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486976_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487687_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486978_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487007_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1486978_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487019_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487011_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487019_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487011_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487021_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487027_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487021_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487114_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487029_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487118_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487029_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487112_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487114_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487112_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487118_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487157_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487165_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487157_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487265_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487166_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487166_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487293_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487169_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487269_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487169_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487263_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487265_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487263_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487269_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487285_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487548_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487285_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487293_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487294_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487293_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487549_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487294_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487686_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487297_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487466_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487297_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487317_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487303_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487305_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487305_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1487392_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
