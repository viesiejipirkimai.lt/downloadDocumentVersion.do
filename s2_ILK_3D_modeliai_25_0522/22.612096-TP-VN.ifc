Properties of the parts of a building model (IFC2X3), part 49 of 57

# IfcFlowSegment: Pipe Types:Wavin AS+ (socket end) OD (3301)
Name (Pipe Types:Wavin AS+ (socket end) OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1209219 | 4 a V1 | 231.803 | 7799.95 | Ūkio-buities nuotekos - F1 16
1209376 | 4 a V1 | 3851.81 | 13183.1 | Ūkio-buities nuotekos - F1 15
1209661 | 4 a V1 | 621.405 | 8239.14 | Ūkio-buities nuotekos - F1 16
1209674 | 4 a V1 | 4254.24 | 8253.96 | Ūkio-buities nuotekos - F1 16
1209732 | 3 a | 525.691 | 8286.79 | Ūkio-buities nuotekos - F1 16
1209748 | 3 a | 284.516 | 8303.2 | Ūkio-buities nuotekos - F1 16
1209762 | 3 a | 106.655 | 9552.62 | Ūkio-buities nuotekos - F1 16
1209827 | 3 a | 954.585 | 8477.23 | Ūkio-buities nuotekos - F1 16
1210037 | 3 a | 84.4239 | 8281.62 | Ūkio-buities nuotekos - F1 16
1210431 | 3 a | 429.334 | 8313.76 | Ūkio-buities nuotekos - F1 16
1210517 | 3 a | 182.042 | 8275.16 | Ūkio-buities nuotekos - F1 16
1210598 | 3 a | 1215.65 | 8419.19 | Ūkio-buities nuotekos - F1 16
1210657 | 3 a | 1351.49 | 8306.31 | Ūkio-buities nuotekos - F1 16
1210680 | 3 a | 754.21 | 8257.27 | Ūkio-buities nuotekos - F1 16
1210689 | 3 a | 28.7546 | 8337.31 | Ūkio-buities nuotekos - F1 16
1210703 | 3 a | 171.908 | 8341.66 | Ūkio-buities nuotekos - F1 16
1210767 | 3 a | 1192.91 | 8441.94 | Ūkio-buities nuotekos - F1 16
1210901 | 3 a | 68.7366 | 8263.97 | Ūkio-buities nuotekos - F1 16
1210912 | 4 a V1 | 285.696 | 8224.3 | Ūkio-buities nuotekos - F1 16
1210921 | 3 a | 5792.96 | 8269.12 | Ūkio-buities nuotekos - F1 16
1210978 | 3 a | 1153.04 | 8481.8 | Ūkio-buities nuotekos - F1 16
1211066 | 3 a | 3792.04 | 8270.49 | Ūkio-buities nuotekos - F1 16
1211079 | 4 a V1 | 185.174 | 8232.83 | Ūkio-buities nuotekos - F1 16
1211088 | 3 a | 6110.43 | 8350.09 | Ūkio-buities nuotekos - F1 16
1211182 | 3 a | 1065.73 | 8569.12 | Ūkio-buities nuotekos - F1 16
1211785 | 3 a | 438.642 | 8306.01 | Ūkio-buities nuotekos - F1 16
1211795 | 3 a | 365.322 | 8319.19 | Ūkio-buities nuotekos - F1 16
1211811 | 3 a | 600.594 | 8496.41 | Ūkio-buities nuotekos - F1 16
1212022 | 4 a V1 | 97.4009 | 12661.4 | Ūkio-buities nuotekos - F1 14
1212094 | 4 a V1 | 109.132 | 12439.1 | Ūkio-buities nuotekos - F1 14
1212207 | 4 a V1 | 30.6595 | 12432.4 | Ūkio-buities nuotekos - F1 14
1212237 | 4 a V1 | 3.05664 | 12426.7 | Ūkio-buities nuotekos - F1 14
1212333 | 4 a V1 | 8375.89 | -426.992 | Ūkio-buities nuotekos - F1 14
1212936 | 4 a V1 | 2028.54 | 8119.51 | Ūkio-buities nuotekos - F1 14
1212945 | 4 a V1 | 4234.72 | 8123 | Ūkio-buities nuotekos - F1 14
1212963 | 3 a | 371.335 | 8235.4 | Ūkio-buities nuotekos - F1 14
1212979 | 3 a | 371.876 | 8265.29 | Ūkio-buities nuotekos - F1 14
1213104 | 3 a | 1265.27 | 8369.57 | Ūkio-buities nuotekos - F1 14
1213244 | 3 a | 637.486 | 8258.5 | Ūkio-buities nuotekos - F1 14
1213285 | 3 a | 3416.54 | 8164.48 | Ūkio-buities nuotekos - F1 14
1213294 | 3 a | 202.356 | 8275.02 | Ūkio-buities nuotekos - F1 14
1213308 | 3 a | 83.998 | 8282.84 | Ūkio-buities nuotekos - F1 14
1213542 | 3 a | 135.018 | 9729.46 | Ūkio-buities nuotekos - F1 14
1213557 | 3 a | 1253.48 | 8381.37 | Ūkio-buities nuotekos - F1 14
1213593 | 3 a | 2479.97 | 8261.08 | Ūkio-buities nuotekos - F1 14
1213634 | 3 a | 290.136 | 8250.23 | Ūkio-buities nuotekos - F1 14
1213647 | 3 a | 483.644 | 8313.85 | Ūkio-buities nuotekos - F1 14
1213694 | 3 a | 49.2202 | 8327.3 | Ūkio-buities nuotekos - F1 14
1213807 | 3 a | 1209.72 | 8425.13 | Ūkio-buities nuotekos - F1 14
1213864 | 3 a | 1388.53 | 8134.31 | Ūkio-buities nuotekos - F1 14
1213901 | 4 a V1 | 348.167 | 8109.92 | Ūkio-buities nuotekos - F1 14
1213921 | 3 a | 308.739 | 8165.85 | Ūkio-buities nuotekos - F1 14
1213943 | 3 a | 311.864 | 8175.8 | Ūkio-buities nuotekos - F1 14
1214022 | 3 a | 1355.96 | 8278.89 | Ūkio-buities nuotekos - F1 14
1214138 | 5 a V1 | 12179.7 | -4524.95 | Lietaus nuotekos - L1 10
1214291 | 5 a V1 | 77.1923 | 13091.2 | Lietaus nuotekos - L1 10
1214346 | 4 a V1 | 256.103 | 13078.8 | Lietaus nuotekos - L1 10
1214370 | 4 a V1 | 37.7963 | 13070.8 | Lietaus nuotekos - L1 10
1214483 | 4 a V1 | 4882.84 | 8110.08 | Lietaus nuotekos - L1 10
1214659 | 4 a V1 | 37.1843 | 7818.01 | Lietaus nuotekos - L1 10
1214689 | 3 a | 243.306 | 7805.87 | Lietaus nuotekos - L1 10
1214705 | 3 a | 63.8843 | 7797.31 | Lietaus nuotekos - L1 10
1214971 | 4 a V1 | 4726.98 | 3178.63 | Ūkio-buities nuotekos - F1 13
1215440 | 4 a V1 | 9.41817 | 12417.9 | Ūkio-buities nuotekos - F1 13
1215475 | 4 a V1 | 340.284 | 12405.4 | Ūkio-buities nuotekos - F1 13
1215505 | 4 a V1 | 518.649 | 12389.5 | Ūkio-buities nuotekos - F1 13
1215529 | 4 a V1 | 18.1894 | 12383.4 | Ūkio-buities nuotekos - F1 13
1215722 | 4 a V1 | 4023.64 | 8290.79 | Ūkio-buities nuotekos - F1 13
1216624 | 4 a V1 | 143.89 | 8067.74 | Ūkio-buities nuotekos - F1 13
1216710 | 3 a | 110.138 | 8048.88 | Ūkio-buities nuotekos - F1 13
1216728 | 3 a | 404.85 | 8035.08 | Ūkio-buities nuotekos - F1 13
1216842 | 3 a | 148.482 | 8026.41 | Ūkio-buities nuotekos - F1 13
1217131 | 3 a | 395.235 | 8096.16 | Ūkio-buities nuotekos - F1 13
1217140 | 3 a | 407.228 | 8053.89 | Ūkio-buities nuotekos - F1 13
1217149 | 3 a | 229.352 | 8107.84 | Ūkio-buities nuotekos - F1 13
1217163 | 3 a | 133.396 | 9729.46 | Ūkio-buities nuotekos - F1 13
1217365 | 3 a | 1425.58 | 8209.27 | Ūkio-buities nuotekos - F1 13
1217394 | 3 a | 1459.76 | 8091.83 | Ūkio-buities nuotekos - F1 13
1217405 | 3 a | 87.4396 | 8085.04 | Ūkio-buities nuotekos - F1 13
1217418 | 3 a | 271.949 | 8124.1 | Ūkio-buities nuotekos - F1 13
1217507 | 3 a | 1408.46 | 8226.38 | Ūkio-buities nuotekos - F1 13
1217606 | 3 a | 7981.11 | 8098.74 | Ūkio-buities nuotekos - F1 13
1217621 | 3 a | 222.198 | 8089.25 | Ūkio-buities nuotekos - F1 13
1217634 | 3 a | 71.8157 | 8254.71 | Ūkio-buities nuotekos - F1 13
1217780 | 3 a | 147.493 | 9729.46 | Ūkio-buities nuotekos - F1 13
1217857 | 3 a | 1281.85 | 8353 | Ūkio-buities nuotekos - F1 13
1217888 | 4 a V1 | 287.364 | 7824.4 | Ūkio-buities nuotekos - F1 13
1217968 | 2 a | 654.885 | 7590.87 | Ūkio-buities nuotekos - F1 13
1217978 | 2 a | 1336.04 | 7558.45 | Ūkio-buities nuotekos - F1 13
1218082 | 2 a | 3974.88 | 3514.62 | Ūkio-buities nuotekos - F1 13
1218120 | 4 a V1 | 109.238 | 8272.78 | Ūkio-buities nuotekos - F1 13
1218129 | 4 a V1 | 4043.06 | 8285.87 | Ūkio-buities nuotekos - F1 13
1218167 | 3 a | 474.375 | 8339.49 | Ūkio-buities nuotekos - F1 13
1218276 | 3 a | 789.497 | 8470.58 | Ūkio-buities nuotekos - F1 13
1218327 | 3 a | 165.691 | 8354.32 | Ūkio-buities nuotekos - F1 13
1218342 | 3 a | 321.385 | 8330.46 | Ūkio-buities nuotekos - F1 13
1218351 | 3 a | 851.439 | 8361.41 | Ūkio-buities nuotekos - F1 13
1218365 | 3 a | 451.892 | 8382.21 | Ūkio-buities nuotekos - F1 13
1218379 | 3 a | 67.4769 | 9729.46 | Ūkio-buities nuotekos - F1 13
1218415 | 3 a | 1146.75 | 8488.1 | Ūkio-buities nuotekos - F1 13
1218447 | 3 a | 265.711 | 8345.29 | Ūkio-buities nuotekos - F1 13
1218458 | 3 a | 799.174 | 8311.88 | Ūkio-buities nuotekos - F1 13
1218467 | 3 a | 4274.71 | 8354.38 | Ūkio-buities nuotekos - F1 13
1218481 | 3 a | 1288.93 | 8443.63 | Ūkio-buities nuotekos - F1 13
1218495 | 3 a | 31.8082 | 8473.18 | Ūkio-buities nuotekos - F1 13
1218509 | 3 a | 87.4809 | 9729.46 | Ūkio-buities nuotekos - F1 13
1218584 | 3 a | 1064.19 | 8570.66 | Ūkio-buities nuotekos - F1 13
1218614 | 3 a | 1186.43 | 8326.71 | Ūkio-buities nuotekos - F1 13
1218627 | 3 a | 1048.43 | 8288.31 | Ūkio-buities nuotekos - F1 13
1218668 | 3 a | 1187.57 | 8447.28 | Ūkio-buities nuotekos - F1 13
1218723 | 3 a | 45.9603 | 8291.51 | Ūkio-buities nuotekos - F1 13
1218736 | 3 a | 281.606 | 8279.37 | Ūkio-buities nuotekos - F1 13
1218743 | 3 a | 411.315 | 8305.05 | Ūkio-buities nuotekos - F1 11
1219290 | 3 a | 547.158 | 8409.48 | Ūkio-buities nuotekos - F1 11
1219304 | 3 a | 531.908 | 8424.2 | Ūkio-buities nuotekos - F1 11
1219318 | 3 a | 165.557 | 9729.46 | Ūkio-buities nuotekos - F1 11
1219363 | 3 a | 1103.17 | 8531.68 | Ūkio-buities nuotekos - F1 11
1219527 | 3 a | 46.8099 | 8412.06 | Ūkio-buities nuotekos - F1 11
1219528 | 3 a | 46.848 | 8375.24 | Ūkio-buities nuotekos - F1 11
1219532 | 3 a | 4499.25 | 8317.05 | Ūkio-buities nuotekos - F1 11
1219584 | 3 a | 5.37011 | 8327.03 | Ūkio-buities nuotekos - F1 11
1219755 | 3 a | 2572.32 | 8330.91 | Ūkio-buities nuotekos - F1 11
1219769 | 3 a | 107.485 | 9729.46 | Ūkio-buities nuotekos - F1 11
1219841 | 3 a | 1155.65 | 8479.2 | Ūkio-buities nuotekos - F1 11
1219957 | 0 a | 5356.77 | 12338.9 | Lietaus nuotekos - L1 13
1219966 | 0 a | 19.8111 | 12737.4 | Lietaus nuotekos - L1 13
1220322 | 0 a | 12931.7 | -670.601 | Lietaus nuotekos - L1 13
1220481 | 0 a | 25.12 | -897.748 | Lietaus nuotekos - L1 13
1220484 | 0 a | 3462.3 | -903.341 | Lietaus nuotekos - L1 13
1220563 | 4 a V1 | 7.59041 | 12426.2 | Ūkio-buities nuotekos - F1 10
1220572 | 4 a V1 | 22.4167 | 12646.5 | Ūkio-buities nuotekos - F1 10
1220953 | 4 a V1 | 5463.98 | 12311.3 | Ūkio-buities nuotekos - F1 10
1221108 | 4 a V1 | 4442.94 | 3657.58 | Ūkio-buities nuotekos - F1 10
1221191 | 4 a V1 | 4001.07 | 8241.22 | Ūkio-buities nuotekos - F1 10
1221214 | 3 a | 7888.72 | 8256.43 | Ūkio-buities nuotekos - F1 10
1221224 | 3 a | 1909.59 | 8417.95 | Ūkio-buities nuotekos - F1 10
1221279 | 3 a | 1081.87 | 8552.98 | Ūkio-buities nuotekos - F1 10
1221549 | 4 a V1 | 882.357 | 12069.1 | Ūkio-buities nuotekos - F1 12
1221558 | 4 a V1 | 21.6782 | 12306.9 | Ūkio-buities nuotekos - F1 12
1221757 | 4 a V1 | 4114.93 | 7885.19 | Ūkio-buities nuotekos - F1 12
1221771 | 4 a V1 | 405.814 | 7656.89 | Ūkio-buities nuotekos - F1 12
1221806 | 5 a V1 | 543.176 | 13036.1 | Lietaus nuotekos - L1 7
1221815 | 5 a V1 | 3826.76 | 13338.3 | Lietaus nuotekos - L1 7
1221929 | 4 a V1 | 731.239 | 13014.2 | Lietaus nuotekos - L1 7
1222010 | 4 a V1 | 4303.47 | 8632.84 | Lietaus nuotekos - L1 7
1222140 | 4 a V1 | 142.568 | 8321.81 | Lietaus nuotekos - L1 7
1222336 | 3 a | 942.629 | 8322.67 | Lietaus nuotekos - L1 7
1222890 | 3 a | 53.3023 | 7661.09 | Ūkio-buities nuotekos - F1 12
1222899 | 4 a V1 | 307.613 | 7646.3 | Ūkio-buities nuotekos - F1 12
1222908 | 3 a | 462.981 | 7667.86 | Ūkio-buities nuotekos - F1 12
1222922 | 3 a | 84.8012 | 9552.62 | Ūkio-buities nuotekos - F1 12
1222992 | 3 a | 809.395 | 8622.42 | Ūkio-buities nuotekos - F1 12
1223103 | 3 a | 11.1782 | 8592.76 | Ūkio-buities nuotekos - F1 12
1223112 | 3 a | 319.948 | 8080.27 | Ūkio-buities nuotekos - F1 12
1223119 | 3 a | 657.692 | 8761.32 | Ūkio-buities nuotekos - F1 12
1223284 | 3 a | 322.317 | 8104.06 | Ūkio-buities nuotekos - F1 12
1223293 | 3 a | 94.1147 | 7845.44 | Ūkio-buities nuotekos - F1 12
1223315 | 3 a | 417.013 | 8129.07 | Ūkio-buities nuotekos - F1 12
1223331 | 3 a | 889.127 | 8141.18 | Ūkio-buities nuotekos - F1 12
1223345 | 3 a | 87.4809 | 9729.46 | Ūkio-buities nuotekos - F1 12
1223430 | 3 a | 1379.04 | 8255.81 | Ūkio-buities nuotekos - F1 12
1223512 | 3 a | 899.8 | 8126.66 | Ūkio-buities nuotekos - F1 12
1223521 | 3 a | 501.881 | 8113.98 | Ūkio-buities nuotekos - F1 12
1223534 | 3 a | 102.986 | 9804.46 | Ūkio-buities nuotekos - F1 12
1223576 | 3 a | 1469.42 | 8240.43 | Ūkio-buities nuotekos - F1 12
1223791 | 3 a | 3120.81 | 8131.65 | Ūkio-buities nuotekos - F1 12
1223804 | 3 a | 6.02405 | 8126.48 | Ūkio-buities nuotekos - F1 12
1223811 | 3 a | 107.485 | 9729.46 | Ūkio-buities nuotekos - F1 12
1223913 | 3 a | 1343.95 | 8290.9 | Ūkio-buities nuotekos - F1 12
1224020 | 3 a | 202.288 | 8106.64 | Ūkio-buities nuotekos - F1 12
1224031 | 3 a | 305.66 | 8095.48 | Ūkio-buities nuotekos - F1 12
1224038 | 3 a | 968.907 | 8114.46 | Ūkio-buities nuotekos - F1 12
1224052 | 3 a | 1774.21 | 8137.61 | Ūkio-buities nuotekos - F1 12
1224134 | 3 a | 89.2282 | 8176.86 | Ūkio-buities nuotekos - F1 12
1224152 | 3 a | 59.4646 | 9729.46 | Ūkio-buities nuotekos - F1 12
1224214 | 3 a | 1359.36 | 8275.49 | Ūkio-buities nuotekos - F1 12
1224253 | 4 a V1 | 96.6566 | 8440.62 | Ūkio-buities nuotekos - F1 9
1224262 | 4 a V1 | 3907.98 | 8425.41 | Ūkio-buities nuotekos - F1 9
1224319 | 3 a | 662.38 | 8446.8 | Ūkio-buities nuotekos - F1 9
1224335 | 3 a | 2269.13 | 8463.82 | Ūkio-buities nuotekos - F1 9
1224349 | 3 a | 431.888 | 8512.97 | Ūkio-buities nuotekos - F1 9
1224398 | 3 a | 1016.39 | 8618.45 | Ūkio-buities nuotekos - F1 9
1224442 | 3 a | 104.375 | 8445.02 | Ūkio-buities nuotekos - F1 9
1224454 | 3 a | 971.996 | 8450.88 | Ūkio-buities nuotekos - F1 9
1224468 | 3 a | 187.501 | 9729.46 | Ūkio-buities nuotekos - F1 9
1224501 | 3 a | 1067.68 | 8567.17 | Ūkio-buities nuotekos - F1 9
1224732 | 4 a V1 | 4022.63 | 3748.39 | Ūkio-buities nuotekos - F1 8
1224784 | 3 a | 2023.23 | 7969.74 | Ūkio-buities nuotekos - F1 8
1224792 | 3 a | 631.928 | 8043.7 | Ūkio-buities nuotekos - F1 8
1225173 | 3 a | 1481.67 | 8153.18 | Ūkio-buities nuotekos - F1 8
1225309 | 3 a | 568.219 | 8098.83 | Ūkio-buities nuotekos - F1 8
1225318 | 3 a | 87.3918 | 7963.55 | Ūkio-buities nuotekos - F1 8
1225325 | 3 a | 1562.39 | 8115.89 | Ūkio-buities nuotekos - F1 8
1225339 | 3 a | 85.7947 | 8152.83 | Ūkio-buities nuotekos - F1 8
1225353 | 3 a | 14.7577 | 9552.62 | Ūkio-buities nuotekos - F1 8
1225428 | 3 a | 1108.93 | 8322.89 | Ūkio-buities nuotekos - F1 8
1225513 | 3 a | 1970.31 | 8118.05 | Ūkio-buities nuotekos - F1 8
1225524 | 3 a | 629.061 | 8082.77 | Ūkio-buities nuotekos - F1 8
1225604 | 3 a | 1036.73 | 8279.05 | Ūkio-buities nuotekos - F1 8
1225678 | 3 a | 366.971 | 8142.4 | Ūkio-buities nuotekos - F1 8
1225691 | 3 a | 5301.41 | 7973.95 | Ūkio-buities nuotekos - F1 8
1225700 | 3 a | 129.236 | 8153.51 | Ūkio-buities nuotekos - F1 8
1225714 | 3 a | 50.1426 | 9729.46 | Ūkio-buities nuotekos - F1 8
1225751 | 3 a | 1381.91 | 8252.94 | Ūkio-buities nuotekos - F1 8
1225782 | 3 a | 202.288 | 8144.98 | Ūkio-buities nuotekos - F1 8
1225795 | 3 a | 1301.37 | 8113.91 | Ūkio-buities nuotekos - F1 8
1225802 | 3 a | 1168.91 | 8152.8 | Ūkio-buities nuotekos - F1 8
1225816 | 3 a | 1272.06 | 8179.95 | Ūkio-buities nuotekos - F1 8
1225830 | 3 a | 135.345 | 9729.46 | Ūkio-buities nuotekos - F1 8
1225890 | 3 a | 1332.62 | 8302.23 | Ūkio-buities nuotekos - F1 8
1226415 | 4 a V1 | 475.596 | 12446.8 | Ūkio-buities nuotekos - F1 6
1226424 | 4 a V1 | 170.544 | 12676.4 | Ūkio-buities nuotekos - F1 6
1226516 | 4 a V1 | 1735.19 | 12406.4 | Ūkio-buities nuotekos - F1 6
1226532 | 4 a V1 | 2896.36 | 12342.7 | Ūkio-buities nuotekos - F1 6
1226572 | 4 a V1 | 4339.69 | 7934.1 | Ūkio-buities nuotekos - F1 6
1227229 | 4 a V1 | 349.124 | 7706.97 | Ūkio-buities nuotekos - F1 6
1227285 | 2 a | 1385.2 | 7663.98 | Ūkio-buities nuotekos - F1 6
1227492 | 2 a | 590.773 | 7880.5 | Ūkio-buities nuotekos - F1 6
1227501 | 2 a | 340.264 | 7694.47 | Ūkio-buities nuotekos - F1 6
1227510 | 2 a | 131.86 | 8565.88 | Ūkio-buities nuotekos - F1 6
1227538 | 3 a | 3.89659 | 8572.49 | Ūkio-buities nuotekos - F1 6
1227554 | 3 a | 49.2202 | 8576.34 | Ūkio-buities nuotekos - F1 6
1227674 | 3 a | 960.675 | 8674.17 | Ūkio-buities nuotekos - F1 6
1227975 | 4 a V1 | 356.201 | 7934.92 | Ūkio-buities nuotekos - F1 5
1227984 | 4 a V1 | 4265.5 | 7936.52 | Ūkio-buities nuotekos - F1 5
1228008 | 3 a | 1420.47 | 8101.65 | Ūkio-buities nuotekos - F1 5
1228072 | 3 a | 1189.38 | 8251.66 | Ūkio-buities nuotekos - F1 5
1228149 | 3 a | 446.281 | 8116.48 | Ūkio-buities nuotekos - F1 5
1228158 | 3 a | 645.942 | 8086.13 | Ūkio-buities nuotekos - F1 5
1228247 | 3 a | 1412.6 | 8222.25 | Ūkio-buities nuotekos - F1 5
1228318 | 3 a | 446.281 | 8100.96 | Ūkio-buities nuotekos - F1 5
1228327 | 3 a | 6855.1 | 7946.45 | Ūkio-buities nuotekos - F1 5
1228336 | 3 a | 27.4689 | 9729.46 | Ūkio-buities nuotekos - F1 5
1228407 | 3 a | 1428.12 | 8206.73 | Ūkio-buities nuotekos - F1 5
1228461 | 3 a | 1108.47 | 7943.51 | Ūkio-buities nuotekos - F1 5
1228480 | 4 a V1 | 210.928 | 7921.86 | Ūkio-buities nuotekos - F1 5
1228489 | 3 a | 409.292 | 7969.45 | Ūkio-buities nuotekos - F1 5
1228503 | 3 a | 87.4809 | 9729.46 | Ūkio-buities nuotekos - F1 5
1228548 | 3 a | 1560.36 | 8074.48 | Ūkio-buities nuotekos - F1 5
1228599 | 3 a | 1365.93 | 7949.75 | Ūkio-buities nuotekos - F1 5
1228614 | 4 a V1 | 181.673 | 7928.68 | Ūkio-buities nuotekos - F1 5
1228623 | 3 a | 3412.48 | 7980.84 | Ūkio-buities nuotekos - F1 5
1228637 | 3 a | 155.157 | 9729.46 | Ūkio-buities nuotekos - F1 5
1228683 | 3 a | 1488.93 | 8145.92 | Ūkio-buities nuotekos - F1 5
1228821 | 4 a V1 | 769.474 | 7808.52 | K1 2
1228830 | 4 a V1 | 4495.34 | 7821.61 | K1 2
1228849 | 3 a | 1034.66 | 7939.17 | K1 2
1228937 | 3 a | 1178.62 | 8081.45 | K1 2
1229000 | 3 a | 573.089 | 7959.45 | K1 2
1229009 | 3 a | 3299.43 | 7870.59 | K1 2
1229018 | 3 a | 171.836 | 7974.68 | K1 2
1229032 | 3 a | 147.493 | 9729.46 | K1 2
1229093 | 3 a | 1559.88 | 8074.97 | K1 2
1229342 | 3 a | 139.408 | 7960.91 | K1 2
1229349 | 3 a | 209.45 | 7952.79 | K1 2
1229400 | 3 a | 1579.54 | 8055.31 | K1 2
1229449 | 3 a | 148.724 | 9729.46 | K1 2
1229480 | 3 a | 646.321 | 7885.41 | K1 2
1229491 | 3 a | 1983.59 | 7828.32 | K1 2
1229500 | 3 a | 127.489 | 9729.46 | K1 2
1229543 | 3 a | 1639.66 | 7995.19 | K1 2
1229613 | 4 a V1 | 890.568 | 8356.65 | Ūkio-buities nuotekos - F1 1
1229622 | 4 a V1 | 3851.57 | 8374.27 | Ūkio-buities nuotekos - F1 1
1229655 | 3 a | 7323.29 | 8380.16 | Ūkio-buities nuotekos - F1 1
1229675 | 3 a | 647.469 | 8575.67 | Ūkio-buities nuotekos - F1 1
1229721 | 3 a | 184.773 | 9552.62 | Ūkio-buities nuotekos - F1 1
1229732 | 3 a | 674.859 | 8756.95 | Ūkio-buities nuotekos - F1 1
1229876 | 3 a | 516.406 | 8561.86 | Ūkio-buities nuotekos - F1 1
1230004 | 3 a | 441.869 | 8602.64 | Ūkio-buities nuotekos - F1 1
1230079 | 3 a | 180.231 | 8616.08 | Ūkio-buities nuotekos - F1 1
1230290 | 3 a | 531.262 | 8741.28 | Ūkio-buities nuotekos - F1 1
1230325 | 3 a | 1157.04 | 8607.49 | Ūkio-buities nuotekos - F1 1
1230344 | 3 a | 515.797 | 8532.3 | Ūkio-buities nuotekos - F1 1
1230353 | 3 a | 799.794 | 8635.04 | Ūkio-buities nuotekos - F1 1
1230369 | 3 a | 276.058 | 8820.94 | Ūkio-buities nuotekos - F1 1
1230860 | 3 a | 746.96 | 8609.1 | Ūkio-buities nuotekos - F1 1
1230901 | 3 a | 303.054 | 8793.95 | Ūkio-buities nuotekos - F1 1
1230912 | 3 a | 2065.09 | 8562.9 | Ūkio-buities nuotekos - F1 1
1230926 | 3 a | 249.274 | 8593 | Ūkio-buities nuotekos - F1 1
1230939 | 3 a | 647.768 | 8546.09 | Ūkio-buities nuotekos - F1 1
1230948 | 3 a | 109.662 | 9729.46 | Ūkio-buities nuotekos - F1 1
1231001 | 3 a | 940.011 | 8694.84 | Ūkio-buities nuotekos - F1 1
1231042 | 3 a | 328.965 | 8619.34 | Ūkio-buities nuotekos - F1 1
1231051 | 3 a | 267.341 | 8594.69 | Ūkio-buities nuotekos - F1 1
1231066 | 3 a | 129.231 | 8625.58 | Ūkio-buities nuotekos - F1 1
1231113 | 3 a | 127.489 | 9729.46 | Ūkio-buities nuotekos - F1 1
1231146 | 3 a | 909.832 | 8725.02 | Ūkio-buities nuotekos - F1 1
1231188 | 3 a | 296.02 | 8615.25 | Ūkio-buities nuotekos - F1 1
1231219 | 3 a | 82.2639 | 8620.08 | Ūkio-buities nuotekos - F1 1
1231357 | 3 a | 148.707 | 8625.5 | Ūkio-buities nuotekos - F1 1
1231371 | 3 a | 91.8202 | 8632.25 | Ūkio-buities nuotekos - F1 1
1231385 | 3 a | 87.4809 | 9729.46 | Ūkio-buities nuotekos - F1 1
1231422 | 3 a | 903.915 | 8730.93 | Ūkio-buities nuotekos - F1 1
1231464 | 3 a | 333.471 | 8360.85 | Ūkio-buities nuotekos - F1 1
1231477 | 4 a V1 | 380.327 | 8344.61 | Ūkio-buities nuotekos - F1 1
1231484 | 3 a | 281.938 | 8406.45 | Ūkio-buities nuotekos - F1 1
1231605 | 3 a | 701.385 | 8580.43 | Ūkio-buities nuotekos - F1 1
1231687 | 3 a | 123.09 | 9552.62 | Ūkio-buities nuotekos - F1 1
1231696 | 3 a | 796.52 | 8635.29 | Ūkio-buities nuotekos - F1 1
1231699 | 3 a | 265.148 | 8387.22 | Ūkio-buities nuotekos - F1 1
1231727 | 3 a | 729.921 | 8406.45 | Ūkio-buities nuotekos - F1 1
1231744 | 3 a | 525.656 | 8373.23 | Ūkio-buities nuotekos - F1 1
1231832 | 3 a | 773.135 | 8542.64 | Ūkio-buities nuotekos - F1 1
1231925 | 3 a | 123.051 | 8396.97 | Ūkio-buities nuotekos - F1 1
1231934 | 3 a | 8.76458 | 8432.99 | Ūkio-buities nuotekos - F1 1
1231940 | 3 a | 151.832 | 8436.94 | Ūkio-buities nuotekos - F1 1
1231994 | 3 a | 1098.03 | 8536.82 | Ūkio-buities nuotekos - F1 1
1232060 | 3 a | 3453.16 | 8447.92 | Ūkio-buities nuotekos - F1 1
1232075 | 3 a | 69.7831 | 8402.24 | Ūkio-buities nuotekos - F1 1
1232084 | 3 a | 91.8042 | 8520.74 | Ūkio-buities nuotekos - F1 1
1232098 | 3 a | 87.4809 | 9729.46 | Ūkio-buities nuotekos - F1 1
1232134 | 3 a | 1015.42 | 8619.43 | Ūkio-buities nuotekos - F1 1
1232252 | 3 a | 4150.5 | 8450.7 | Ūkio-buities nuotekos - F1 1
1232261 | 3 a | 393.029 | 8437.59 | Ūkio-buities nuotekos - F1 1
1232268 | 3 a | 2280.4 | 8612.11 | Ūkio-buities nuotekos - F1 1
1232282 | 3 a | 147.493 | 9729.46 | Ūkio-buities nuotekos - F1 1
1232355 | 3 a | 880.296 | 8754.55 | Ūkio-buities nuotekos - F1 1
1232431 | 3 a | 895.592 | 8739.26 | Ūkio-buities nuotekos - F1 1
1232440 | 3 a | 3609.31 | 8537.47 | Ūkio-buities nuotekos - F1 1
1232447 | 3 a | 147.493 | 9729.47 | Ūkio-buities nuotekos - F1 1
1232547 | 4 a V1 | 25.5192 | 8268.39 | Ūkio-buities nuotekos - F1 1
1232567 | 3 a | 1875.65 | 8275.8 | Ūkio-buities nuotekos - F1 1
1232575 | 3 a | 452.179 | 8366.67 | Ūkio-buities nuotekos - F1 1
1232589 | 3 a | 458.848 | 8388.29 | Ūkio-buities nuotekos - F1 1
1232665 | 3 a | 719.713 | 8565.81 | Ūkio-buities nuotekos - F1 1
1232772 | 3 a | 804.398 | 8627.42 | Ūkio-buities nuotekos - F1 1
1232775 | 3 a | 121.98 | 8381.41 | Ūkio-buities nuotekos - F1 1
1232882 | 3 a | 233.326 | 8370.87 | Ūkio-buities nuotekos - F1 1
1232893 | 3 a | 491 | 8352.4 | Ūkio-buities nuotekos - F1 1
1232900 | 3 a | 223.013 | 8381.23 | Ūkio-buities nuotekos - F1 1
1232914 | 3 a | 181.393 | 9552.62 | Ūkio-buities nuotekos - F1 1
1232960 | 3 a | 877.782 | 8554.03 | Ūkio-buities nuotekos - F1 1
1233176 | 3 a | 114.032 | 9728.92 | Ūkio-buities nuotekos - F1 1
1233191 | 3 a | 1103.96 | 8529.6 | Ūkio-buities nuotekos - F1 1
1233194 | 3 a | 590.532 | 8329.39 | Ūkio-buities nuotekos - F1 1
1233271 | 3 a | 114.325 | 9728.92 | Ūkio-buities nuotekos - F1 1
1233284 | 3 a | 1118.58 | 8514.98 | Ūkio-buities nuotekos - F1 1
1233287 | 3 a | 378.643 | 8319.01 | Ūkio-buities nuotekos - F1 1
1233370 | 3 a | 129.399 | 9552.12 | Ūkio-buities nuotekos - F1 1
1233379 | 3 a | 914.21 | 8515.49 | Ūkio-buities nuotekos - F1 1
1233382 | 3 a | 355.797 | 8264.25 | Ūkio-buities nuotekos - F1 1
1233442 | 4 a V1 | 281.843 | 8439.23 | Ūkio-buities nuotekos - F1 1
1233451 | 4 a V1 | 3941.08 | 8436.96 | Ūkio-buities nuotekos - F1 1
1233811 | 3 a | 693.608 | 8566.47 | Ūkio-buities nuotekos - F1 1
1233857 | 3 a | 307.543 | 8430.58 | Ūkio-buities nuotekos - F1 1
1233868 | 4 a V1 | 10.3769 | 8423.87 | Ūkio-buities nuotekos - F1 1
1233943 | 3 a | 757.447 | 8558.33 | Ūkio-buities nuotekos - F1 1
1234052 | 3 a | 732.419 | 8454.89 | Ūkio-buities nuotekos - F1 1
1234061 | 4 a V1 | 222.359 | 8427.38 | Ūkio-buities nuotekos - F1 1
1234070 | 3 a | 50.1449 | 8474.58 | Ūkio-buities nuotekos - F1 1
1234242 | 3 a | 1062.42 | 8572.43 | Ūkio-buities nuotekos - F1 1
1234337 | 3 a | 59.3482 | 8457.47 | Ūkio-buities nuotekos - F1 1
1234346 | 3 a | 158.164 | 8449.26 | Ūkio-buities nuotekos - F1 1
1234458 | 3 a | 1081.91 | 8552.94 | Ūkio-buities nuotekos - F1 1
1234640 | 3 a | 1467.22 | 8472 | Ūkio-buities nuotekos - F1 1
1234650 | 3 a | 69.2242 | 8505.11 | Ūkio-buities nuotekos - F1 1
1234664 | 3 a | 111.324 | 9729.46 | Ūkio-buities nuotekos - F1 1
1234701 | 3 a | 1031.5 | 8603.35 | Ūkio-buities nuotekos - F1 1
1234781 | 4 a V1 | 74.9777 | 8434.43 | Ūkio-buities nuotekos - F1 1
1234788 | 3 a | 96.1383 | 8442.43 | Ūkio-buities nuotekos - F1 1
1234808 | 3 a | 750.512 | 8448.76 | Ūkio-buities nuotekos - F1 1
1235309 | 3 a | 1160.51 | 8468.18 | Ūkio-buities nuotekos - F1 1
1235354 | 3 a | 702.795 | 8612.98 | Ūkio-buities nuotekos - F1 1
1235468 | 4 a V1 | 8.15941 | 8063.46 | Ūkio-buities nuotekos - F1 1
1235639 | 3 a | 2689.85 | 8050.46 | Ūkio-buities nuotekos - F1 1
1235714 | 3 a | 927.127 | 8122.12 | Ūkio-buities nuotekos - F1 1
1235848 | 3 a | 1053.52 | 8262.26 | Ūkio-buities nuotekos - F1 1
1235924 | 3 a | 168.283 | 8129.56 | Ūkio-buities nuotekos - F1 1
1235935 | 3 a | 173.554 | 8108.66 | Ūkio-buities nuotekos - F1 1
1235944 | 3 a | 5310.27 | 8136.7 | Ūkio-buities nuotekos - F1 1
1235958 | 3 a | 128.562 | 9729.46 | Ūkio-buities nuotekos - F1 1
1236073 | 3 a | 1295.12 | 8339.73 | Ūkio-buities nuotekos - F1 1
1236131 | 3 a | 145.631 | 8135.49 | Ūkio-buities nuotekos - F1 1
1236140 | 3 a | 239.314 | 8114.73 | Ūkio-buities nuotekos - F1 1
1236155 | 3 a | 991.984 | 8135.79 | Ūkio-buities nuotekos - F1 1
1236202 | 3 a | 153.315 | 9729.46 | Ūkio-buities nuotekos - F1 1
1236282 | 3 a | 1382.37 | 8252.48 | Ūkio-buities nuotekos - F1 1
1236410 | 3 a | 1091.5 | 8383.55 | Ūkio-buities nuotekos - F1 1
1236423 | 3 a | 278.845 | 8344.02 | Ūkio-buities nuotekos - F1 1
1236432 | 3 a | 4949.69 | 8409.15 | Ūkio-buities nuotekos - F1 1
1236446 | 3 a | 1963.95 | 8595.26 | Ūkio-buities nuotekos - F1 1
1236491 | 3 a | 107.447 | 9729.45 | Ūkio-buities nuotekos - F1 1
1236502 | 3 a | 903.464 | 8731.38 | Ūkio-buities nuotekos - F1 1
1236669 | 3 a | 911.89 | 8722.41 | Ūkio-buities nuotekos - F1 1
1236678 | 3 a | 4045.77 | 8511.9 | Ūkio-buities nuotekos - F1 1
1236685 | 3 a | 206.904 | 9728 | Ūkio-buities nuotekos - F1 1
1237093 | 4 a V1 | 10433.9 | 8066.08 | Ūkio-buities nuotekos - F1 2
1237127 | 4 a V1 | 83.6474 | 7760.24 | Ūkio-buities nuotekos - F1 2
1237296 | 3 a | 1907.53 | 8051.75 | Ūkio-buities nuotekos - F1 2
1237308 | 3 a | 241.243 | 8127.01 | Ūkio-buities nuotekos - F1 2
1237322 | 3 a | 810.058 | 8161.65 | Ūkio-buities nuotekos - F1 2
1237370 | 3 a | 926.527 | 8346.19 | Ūkio-buities nuotekos - F1 2
1237434 | 3 a | 144.765 | 9552.62 | Ūkio-buities nuotekos - F1 2
1237443 | 3 a | 1029.44 | 8402.37 | Ūkio-buities nuotekos - F1 2
1237446 | 3 a | 983.939 | 8137.53 | Ūkio-buities nuotekos - F1 2
1237492 | 3 a | 1061.34 | 8131.21 | Ūkio-buities nuotekos - F1 2
1237505 | 3 a | 522.852 | 8112.11 | Ūkio-buities nuotekos - F1 2
1237512 | 3 a | 181.613 | 9552.62 | Ūkio-buities nuotekos - F1 2
1237538 | 3 a | 1111.04 | 8320.77 | Ūkio-buities nuotekos - F1 2
1237621 | 3 a | 1309.49 | 8140.85 | Ūkio-buities nuotekos - F1 2
1237634 | 3 a | 495.628 | 8099.38 | Ūkio-buities nuotekos - F1 2
1237643 | 3 a | 207.505 | 9729.46 | Ūkio-buities nuotekos - F1 2
1237670 | 3 a | 1370.96 | 8263.89 | Ūkio-buities nuotekos - F1 2
1237715 | 3 a | 49.1206 | 8095.59 | Ūkio-buities nuotekos - F1 2
1237928 | 3 a | 186.904 | 9728 | Ūkio-buities nuotekos - F1 2
1237971 | 3 a | 1408.34 | 8225.96 | Ūkio-buities nuotekos - F1 2
1238494 | 3 a | 8.6926 | 8082.89 | Ūkio-buities nuotekos - F1 2
1238505 | 3 a | 625.87 | 8036.42 | Ūkio-buities nuotekos - F1 2
1238514 | 3 a | 231.848 | 8086.84 | Ūkio-buities nuotekos - F1 2
1238528 | 3 a | 127.489 | 9729.46 | Ūkio-buities nuotekos - F1 2
1238598 | 3 a | 1446.53 | 8188.32 | Ūkio-buities nuotekos - F1 2
1238660 | 3 a | 408.992 | 7777.62 | Ūkio-buities nuotekos - F1 2
1238733 | 3 a | 1307.67 | 7954.14 | Ūkio-buities nuotekos - F1 2
1238792 | 3 a | 258.638 | 7796.84 | Ūkio-buities nuotekos - F1 2
1238807 | 3 a | 1702.32 | 7740.1 | Ūkio-buities nuotekos - F1 2
1238830 | 3 a | 428.915 | 7964.47 | Ūkio-buities nuotekos - F1 2
1238972 | 3 a | 1159.38 | 8094.64 | Ūkio-buities nuotekos - F1 2
1239036 | 3 a | 343.489 | 8048.54 | Ūkio-buities nuotekos - F1 2
1239045 | 3 a | 7264.91 | 7816.59 | Ūkio-buities nuotekos - F1 2
1239054 | 3 a | 1072.02 | 8059.18 | Ūkio-buities nuotekos - F1 2
1239068 | 3 a | 188.002 | 9729.46 | Ūkio-buities nuotekos - F1 2
1239104 | 3 a | 1457.38 | 8177.47 | Ūkio-buities nuotekos - F1 2
1239155 | 3 a | 1840.02 | 8051.12 | Ūkio-buities nuotekos - F1 2
1239170 | 3 a | 2883.26 | 7988.42 | Ūkio-buities nuotekos - F1 2
1239177 | 3 a | 391.88 | 8091.69 | Ūkio-buities nuotekos - F1 2
1239191 | 3 a | 87.4809 | 9729.46 | Ūkio-buities nuotekos - F1 2
1239250 | 3 a | 1438.48 | 8196.37 | Ūkio-buities nuotekos - F1 2
1239280 | 3 a | 147.493 | 9729.46 | Ūkio-buities nuotekos - F1 2
1239291 | 3 a | 1519.28 | 8115.57 | Ūkio-buities nuotekos - F1 2
1239294 | 3 a | 333.068 | 7979.29 | Ūkio-buities nuotekos - F1 2
1239322 | 3 a | 1205.9 | 7831.42 | Ūkio-buities nuotekos - F1 2
1239333 | 3 a | 378.228 | 7806.42 | Ūkio-buities nuotekos - F1 2
1239342 | 3 a | 383.417 | 7868.68 | Ūkio-buities nuotekos - F1 2
1239356 | 3 a | 187.501 | 9729.46 | Ūkio-buities nuotekos - F1 2
1239388 | 3 a | 1661.66 | 7973.19 | Ūkio-buities nuotekos - F1 2
1239491 | 3 a | 102.268 | 7871.26 | Ūkio-buities nuotekos - F1 2
1239506 | 3 a | 345.255 | 7859.31 | Ūkio-buities nuotekos - F1 2
1239513 | 3 a | 249.26 | 7877.08 | Ūkio-buities nuotekos - F1 2
1239527 | 3 a | 47.4729 | 9729.46 | Ūkio-buities nuotekos - F1 2
1239594 | 3 a | 1655.94 | 7978.91 | Ūkio-buities nuotekos - F1 2
1239623 | 3 a | 256.564 | 7881.59 | Ūkio-buities nuotekos - F1 2
1239632 | 3 a | 302.136 | 7730.58 | Ūkio-buities nuotekos - F1 2
1239686 | 3 a | 1251.75 | 8008.32 | Ūkio-buities nuotekos - F1 2
1239745 | 3 a | 720.412 | 7896.42 | Ūkio-buities nuotekos - F1 2
1239777 | 3 a | 371.876 | 7958.31 | Ūkio-buities nuotekos - F1 2
1239791 | 3 a | 107.485 | 9729.46 | Ūkio-buities nuotekos - F1 2
1239829 | 3 a | 1572.26 | 8062.59 | Ūkio-buities nuotekos - F1 2
1240176 | 3 a | 422.605 | 7870.54 | Ūkio-buities nuotekos - F1 2
1240198 | 3 a | 340.258 | 7915.87 | Ūkio-buities nuotekos - F1 2
1240207 | 3 a | 2062.53 | 7913.29 | Ūkio-buities nuotekos - F1 2
1240212 | 3 a | 67.4769 | 9729.46 | Ūkio-buities nuotekos - F1 2
1240243 | 3 a | 1615.32 | 8019.53 | Ūkio-buities nuotekos - F1 2
1240338 | 3 a | 5677.26 | 7873.74 | Ūkio-buities nuotekos - F1 2
1240357 | 3 a | 5396.62 | 7759.32 | Ūkio-buities nuotekos - F1 2
1240364 | 3 a | 844.556 | 7991.74 | Ūkio-buities nuotekos - F1 2
1240411 | 3 a | 140.303 | 8013.03 | Ūkio-buities nuotekos - F1 2
1240460 | 3 a | 1478.34 | 8137.44 | Ūkio-buities nuotekos - F1 2
1241032 | 4 a V1 | 331.805 | 3142.44 | Ūkio-buities nuotekos - F1 2
1241059 | 4 a V1 | 4365.93 | 3172.1 | Ūkio-buities nuotekos - F1 2
1241078 | 2 a | 65.2818 | 3351.53 | Ūkio-buities nuotekos - F1 2
1241191 | 2 a | 940.642 | 3521.17 | Ūkio-buities nuotekos - F1 2
1241249 | 2 a | 481.556 | 3175.17 | Ūkio-buities nuotekos - F1 2
1241260 | 2 a | 507.616 | 3154.78 | Ūkio-buities nuotekos - F1 2
1241267 | 2 a | 85.9584 | 4752.62 | Ūkio-buities nuotekos - F1 2
1241295 | 2 a | 1278.67 | 3353.14 | Ūkio-buities nuotekos - F1 2
1241326 | 2 a | 258.102 | 3235.06 | Ūkio-buities nuotekos - F1 2
1241369 | 2 a | 735.911 | 3169.37 | Ūkio-buities nuotekos - F1 2
1241378 | 2 a | 932.588 | 3244 | Ūkio-buities nuotekos - F1 2
1241418 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 2
1241466 | 2 a | 1475.35 | 3359.5 | Ūkio-buities nuotekos - F1 2
1241496 | 2 a | 180.793 | 3239.24 | Ūkio-buities nuotekos - F1 2
1241539 | 2 a | 133.022 | 3229.94 | Ūkio-buities nuotekos - F1 2
1241546 | 2 a | 47.4729 | 4929.46 | Ūkio-buities nuotekos - F1 2
1241620 | 2 a | 1495.14 | 3339.71 | Ūkio-buities nuotekos - F1 2
1241658 | 2 a | 200.709 | 3234.72 | Ūkio-buities nuotekos - F1 2
1241665 | 2 a | 471.504 | 3218.05 | Ūkio-buities nuotekos - F1 2
1241672 | 2 a | 84.6392 | 4929.46 | Ūkio-buities nuotekos - F1 2
1241718 | 2 a | 1499.27 | 3335.58 | Ūkio-buities nuotekos - F1 2
1241801 | 2 a | 460.798 | 3321.96 | Ūkio-buities nuotekos - F1 2
1241810 | 2 a | 374.191 | 3306.84 | Ūkio-buities nuotekos - F1 2
1241817 | 2 a | 36.3922 | 3336.88 | Ūkio-buities nuotekos - F1 2
1241831 | 2 a | 87.5847 | 4752.62 | Ūkio-buities nuotekos - F1 2
1241874 | 2 a | 1125.87 | 3505.94 | Ūkio-buities nuotekos - F1 2
1241903 | 2 a | 438.833 | 3382.39 | Ūkio-buities nuotekos - F1 2
1241912 | 2 a | 16.3994 | 3341.89 | Ūkio-buities nuotekos - F1 2
1241921 | 2 a | 147.493 | 4929.46 | Ūkio-buities nuotekos - F1 2
1241948 | 2 a | 1346.83 | 3488.02 | Ūkio-buities nuotekos - F1 2
1241988 | 2 a | 10.105 | 3345.6 | Ūkio-buities nuotekos - F1 2
1242038 | 2 a | 106.494 | 3318.76 | Ūkio-buities nuotekos - F1 2
1242190 | 2 a | 1058.38 | 3467.39 | Ūkio-buities nuotekos - F1 2
1242268 | 2 a | 121.472 | 3311.04 | Ūkio-buities nuotekos - F1 2
1242279 | 2 a | 443.143 | 3293.53 | Ūkio-buities nuotekos - F1 2
1242286 | 2 a | 184.773 | 4752.62 | Ūkio-buities nuotekos - F1 2
1242316 | 2 a | 1150.01 | 3481.8 | Ūkio-buities nuotekos - F1 2
1242346 | 2 a | 311.68 | 3324.68 | Ūkio-buities nuotekos - F1 2
1242355 | 2 a | 5191.85 | 3186.9 | Ūkio-buities nuotekos - F1 2
1242364 | 2 a | 529.316 | 3334.68 | Ūkio-buities nuotekos - F1 2
1242378 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 2
1242407 | 2 a | 1392.73 | 3442.12 | Ūkio-buities nuotekos - F1 2
1242437 | 2 a | 1442.54 | 3387.37 | Ūkio-buities nuotekos - F1 2
1242448 | 2 a | 187.493 | 3376.18 | Ūkio-buities nuotekos - F1 2
1242455 | 2 a | 309.228 | 3419.99 | Ūkio-buities nuotekos - F1 2
1242469 | 2 a | 83.6173 | 4929.46 | Ūkio-buities nuotekos - F1 2
1242505 | 2 a | 1311.82 | 3523.03 | Ūkio-buities nuotekos - F1 2
1242537 | 2 a | 971.644 | 3375.04 | Ūkio-buities nuotekos - F1 2
1242546 | 2 a | 303.513 | 3333.01 | Ūkio-buities nuotekos - F1 2
1242555 | 2 a | 28.8105 | 3398.24 | Ūkio-buities nuotekos - F1 2
1242569 | 2 a | 11.9322 | 3402.59 | Ūkio-buities nuotekos - F1 2
1242583 | 2 a | 111.873 | 4929.46 | Ūkio-buities nuotekos - F1 2
1242653 | 2 a | 1335.17 | 3499.68 | Ūkio-buities nuotekos - F1 2
1242842 | 2 a | 3890.11 | 3364.15 | Ūkio-buities nuotekos - F1 2
1242851 | 2 a | 291.318 | 3324.37 | Ūkio-buities nuotekos - F1 2
1242860 | 2 a | 107.485 | 4929.46 | Ūkio-buities nuotekos - F1 2
1242948 | 2 a | 1296.06 | 3538.79 | Ūkio-buities nuotekos - F1 2
1243824 | 2 a | 4993.2 | 3355.73 | Ūkio-buities nuotekos - F1 2
1243833 | 2 a | 102.43 | 3345.03 | Ūkio-buities nuotekos - F1 2
1243923 | 1 a +-152.84 | 3563.6 | 3457.83 | Ūkio-buities nuotekos - F1 2
1243997 | 1 a +-152.84 | 187.834 | 3697.42 | Ūkio-buities nuotekos - F1 2
1244011 | 1 a +-152.84 | 995.929 | 4006.06 | Ūkio-buities nuotekos - F1 2
1244040 | 2 a | 5568.81 | 4031.68 | Ūkio-buities nuotekos - F1 2
1244056 | 2 a | 50.0961 | 4164.77 | Ūkio-buities nuotekos - F1 2
1244070 | 2 a | 116.001 | 4171.78 | Ūkio-buities nuotekos - F1 2
1244117 | 2 a | 289.577 | 4342.23 | Ūkio-buities nuotekos - F1 2
1244183 | 2 a | 529.362 | 4181.6 | Ūkio-buities nuotekos - F1 2
1244198 | 2 a | 474.753 | 4151.8 | Ūkio-buities nuotekos - F1 2
1244207 | 2 a | 191.244 | 4214.48 | Ūkio-buities nuotekos - F1 2
1244289 | 2 a | 185.577 | 4340.17 | Ūkio-buities nuotekos - F1 2
1244329 | 2 a | 946.465 | 4231.7 | Ūkio-buities nuotekos - F1 2
1244394 | 2 a | 774.088 | 4196.39 | Ūkio-buities nuotekos - F1 2
1244403 | 2 a | 167.497 | 4929.46 | Ūkio-buities nuotekos - F1 2
1244449 | 2 a | 487.371 | 4347.48 | Ūkio-buities nuotekos - F1 2
1244720 | 2 a | 89.2422 | 4182.94 | Ūkio-buities nuotekos - F1 2
1244731 | 2 a | 2.64976 | 4148.93 | Ūkio-buities nuotekos - F1 2
1244812 | 2 a | 553.271 | 4281.58 | Ūkio-buities nuotekos - F1 2
1244965 | 2 a | 350.425 | 3145.96 | Ūkio-buities nuotekos - F1 1
1244976 | 4 a V1 | 217.175 | 3066.84 | Ūkio-buities nuotekos - F1 1
1244999 | 2 a | 6132.56 | 3156.74 | Ūkio-buities nuotekos - F1 1
1245206 | 2 a | 229.269 | 3283.14 | Ūkio-buities nuotekos - F1 1
1245222 | 2 a | 100.153 | 4929.46 | Ūkio-buities nuotekos - F1 1
1245252 | 2 a | 1450.27 | 3384.57 | Ūkio-buities nuotekos - F1 1
1245518 | 2 a | 200.211 | 3128.95 | Ūkio-buities nuotekos - F1 1
1245531 | 2 a | 1048.26 | 3105.14 | Ūkio-buities nuotekos - F1 1
1245538 | 2 a | 85.1392 | 4929.46 | Ūkio-buities nuotekos - F1 1
1245591 | 2 a | 1605.05 | 3229.8 | Ūkio-buities nuotekos - F1 1
1245686 | 2 a | 1040.11 | 3133.69 | Ūkio-buities nuotekos - F1 1
1245695 | 2 a | 3.82319 | 3128.57 | Ūkio-buities nuotekos - F1 1
1245708 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 1
1245781 | 2 a | 1588.52 | 3246.33 | Ūkio-buities nuotekos - F1 1
1245897 | 2 a | 2040.06 | 3148.54 | Ūkio-buities nuotekos - F1 1
1245908 | 2 a | 619.341 | 3131.11 | Ūkio-buities nuotekos - F1 1
1245985 | 2 a | 1563.83 | 3271.02 | Ūkio-buities nuotekos - F1 1
1246053 | 2 a | 247.708 | 3119.57 | Ūkio-buities nuotekos - F1 1
1246062 | 4 a V1 | 397.819 | 3074 | Ūkio-buities nuotekos - F1 1
1246125 | 2 a | 1158.95 | 3292.86 | Ūkio-buities nuotekos - F1 1
1246209 | 2 a | 204.777 | 4752.62 | Ūkio-buities nuotekos - F1 1
1246226 | 2 a | 1273.92 | 3357.89 | Ūkio-buities nuotekos - F1 1
1246229 | 2 a | 1226.72 | 3090.59 | Ūkio-buities nuotekos - F1 1
1246353 | 2 a | 249.968 | 3116.89 | Ūkio-buities nuotekos - F1 1
1246362 | 4 a V1 | 389.618 | 3086.39 | Ūkio-buities nuotekos - F1 1
1246448 | 2 a | 1257.81 | 3243.49 | Ūkio-buities nuotekos - F1 1
1246554 | 4 a V1 | 698.131 | 3106.05 | Ūkio-buities nuotekos - F1 1
1246602 | 2 a | 1582.91 | 3251.94 | Ūkio-buities nuotekos - F1 1
1246764 | 2 a | 46.9415 | 3210.44 | Ūkio-buities nuotekos - F1 1
1246775 | 4 a V1 | 278.858 | 3097.67 | Ūkio-buities nuotekos - F1 1
1246784 | 2 a | 6392.94 | 3215.15 | Ūkio-buities nuotekos - F1 1
1246798 | 2 a | 472.119 | 3346.76 | Ūkio-buities nuotekos - F1 1
1246812 | 2 a | 167.497 | 4929.46 | Ūkio-buities nuotekos - F1 1
1246859 | 2 a | 1381.8 | 3453.05 | Ūkio-buities nuotekos - F1 1
1246957 | 2 a | 3369.06 | 3217.34 | Ūkio-buities nuotekos - F1 1
1246974 | 2 a | 3539.41 | 3137.2 | Ūkio-buities nuotekos - F1 1
1247154 | 2 a | 309.102 | 3288.48 | Ūkio-buities nuotekos - F1 1
1247170 | 2 a | 168.288 | 4929.46 | Ūkio-buities nuotekos - F1 1
1247251 | 2 a | 1443.33 | 3391.51 | Ūkio-buities nuotekos - F1 1
1247315 | 2 a | 319.628 | 3219.92 | Ūkio-buities nuotekos - F1 1
1247324 | 2 a | 92.8956 | 3213.02 | Ūkio-buities nuotekos - F1 1
1247337 | 2 a | 147.493 | 4929.46 | Ūkio-buities nuotekos - F1 1
1247408 | 2 a | 1513.26 | 3321.59 | Ūkio-buities nuotekos - F1 1
1247595 | 4 a V1 | 4428.21 | 3219.3 | K1 2
1247654 | 2 a | 6791.64 | 3303.8 | K1 2
1247716 | 2 a | 108.33 | 3607.94 | K1 2
1247758 | 2 a | 215.998 | 3943.57 | K1 2
1247841 | 2 a | 320.583 | 4116.23 | K1 2
1247924 | 2 a | 1281.43 | 3947.77 | K1 2
1247937 | 2 a | 1248.62 | 3914.16 | K1 2
1247944 | 2 a | 100.078 | 4754.12 | K1 2
1247978 | 2 a | 419.849 | 4141.73 | K1 2
1248089 | 2 a | 1569.54 | 3945.3 | K1 2
1248102 | 2 a | 757.737 | 3896.2 | K1 2
1248111 | 2 a | 247.513 | 4929.46 | K1 2
1248150 | 2 a | 761.311 | 4073.54 | K1 2
1248180 | 2 a | 831.449 | 3927.34 | K1 2
1248191 | 2 a | 2815.62 | 3837.08 | K1 2
1248200 | 2 a | 9.21224 | 3947.74 | K1 2
1248252 | 2 a | 790.076 | 4044.77 | K1 2
1248289 | 2 a | 468.761 | 3333.35 | K1 2
1248300 | 2 a | 4897.17 | 3203.07 | K1 2
1248309 | 2 a | 291.86 | 3346.5 | K1 2
1248323 | 2 a | 147.493 | 4929.46 | K1 2
1248359 | 2 a | 1385.67 | 3449.18 | K1 2
1248403 | 2 a | 623.048 | 3290.78 | K1 2
1248426 | 2 a | 152.861 | 3189.64 | K1 2
1248522 | 2 a | 1434.77 | 3400.08 | K1 2
1248618 | 2 a | 5361.26 | 3293.66 | K1 2
1248627 | 2 a | 3043.63 | 3227.45 | K1 2
1248634 | 2 a | 216.593 | 4929.46 | K1 2
1248670 | 2 a | 1337.14 | 3497.71 | K1 2
1248750 | 2 a | 5189.71 | 3234.21 | K1 2
1248767 | 2 a | 237.332 | 3195.51 | K1 2
1248776 | 2 a | 742.001 | 3394.36 | K1 2
1248790 | 2 a | 127.489 | 4929.46 | K1 2
1248843 | 2 a | 1328.81 | 3506.04 | K1 2
1249033 | 2 a | 3980.45 | 3396.94 | K1 2
1249044 | 2 a | 2507.18 | 3341.76 | K1 2
1249051 | 2 a | 1134.09 | 3480.31 | K1 2
1249162 | 2 a | 9.21224 | 3506.76 | K1 2
1249219 | 2 a | 1232.26 | 3603.79 | K1 2
1249440 | 4 a V1 | 3925.3 | 3835.54 | Ūkio-buities nuotekos - F1 5
1249489 | 2 a | 3859.35 | 3859.92 | Ūkio-buities nuotekos - F1 5
1249507 | 2 a | 511.904 | 3940.87 | Ūkio-buities nuotekos - F1 5
1249521 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 5
1249556 | 2 a | 786.894 | 4047.95 | Ūkio-buities nuotekos - F1 5
1249588 | 2 a | 2868.24 | 3862.5 | Ūkio-buities nuotekos - F1 5
1249597 | 2 a | 334.932 | 3850.76 | Ūkio-buities nuotekos - F1 5
1249604 | 2 a | 4660.74 | 3923.63 | Ūkio-buities nuotekos - F1 5
1249618 | 2 a | 135.505 | 4929.46 | Ūkio-buities nuotekos - F1 5
1249656 | 2 a | 721.171 | 4113.68 | Ūkio-buities nuotekos - F1 5
1249812 | 4 a V1 | 1052.56 | 4133.32 | Ūkio-buities nuotekos - F1 6
1249821 | 4 a V1 | 3537.66 | 4057.36 | Ūkio-buities nuotekos - F1 6
1249924 | 2 a | 1677.36 | 4201.96 | Ūkio-buities nuotekos - F1 6
1249940 | 2 a | 3213.24 | 4239.27 | Ūkio-buities nuotekos - F1 6
1249954 | 2 a | 108.196 | 4929.46 | Ūkio-buities nuotekos - F1 6
1249990 | 2 a | 434.474 | 4400.38 | Ūkio-buities nuotekos - F1 6
1250079 | 2 a | 640.863 | 4118.24 | Ūkio-buities nuotekos - F1 6
1250089 | 2 a | 10.6183 | 4204.54 | Ūkio-buities nuotekos - F1 6
1250090 | 2 a | 47.6217 | 4166.45 | Ūkio-buities nuotekos - F1 6
1250094 | 2 a | 2067.99 | 4158.14 | Ūkio-buities nuotekos - F1 6
1250113 | 2 a | 107.413 | 4929.46 | Ūkio-buities nuotekos - F1 6
1250157 | 2 a | 606.944 | 4227.9 | Ūkio-buities nuotekos - F1 6
1250196 | 4 a V1 | 2915.43 | 4072.56 | Ūkio-buities nuotekos - F1 6
1250205 | 2 a | 2680.15 | 4135.9 | Ūkio-buities nuotekos - F1 6
1250251 | 2 a | 107.485 | 4929.46 | Ūkio-buities nuotekos - F1 6
1250268 | 2 a | 548.506 | 4286.34 | Ūkio-buities nuotekos - F1 6
1250344 | 4 a V1 | 916.531 | 3689.7 | Ūkio-buities nuotekos - F1 6
1250353 | 4 a V1 | 11.544 | 3916.55 | Ūkio-buities nuotekos - F1 6
1250398 | 4 a V1 | 8696.53 | -5075.79 | Ūkio-buities nuotekos - F1 6
1250643 | 4 a V1 | 191.241 | 3763.6 | Ūkio-buities nuotekos - F1 8
1250652 | 4 a V1 | 8907.66 | -5299.97 | Ūkio-buities nuotekos - F1 8
1250770 | 2 a | 3111.89 | 3771.2 | Ūkio-buities nuotekos - F1 8
1250786 | 2 a | 469.304 | 3837.2 | Ūkio-buities nuotekos - F1 8
1250845 | 2 a | 891.416 | 3943.43 | Ūkio-buities nuotekos - F1 8
1250936 | 4 a V1 | 1102.32 | 3288.23 | Ūkio-buities nuotekos - F1 12
1250945 | 4 a V1 | 4328.76 | 3196.74 | Ūkio-buities nuotekos - F1 12
1250994 | 4 a V1 | 993.323 | 3478.61 | Ūkio-buities nuotekos - F1 12
1251027 | 2 a | 351.903 | 3336.81 | Ūkio-buities nuotekos - F1 12
1251036 | 4 a V1 | 920.696 | 3265.38 | Ūkio-buities nuotekos - F1 12
1251043 | 2 a | 816.425 | 3349.55 | Ūkio-buities nuotekos - F1 12
1251057 | 2 a | 198.096 | 4752.62 | Ūkio-buities nuotekos - F1 12
1251098 | 2 a | 1097.6 | 3534.21 | Ūkio-buities nuotekos - F1 12
1251145 | 2 a | 739.949 | 3315.02 | Ūkio-buities nuotekos - F1 12
1251154 | 2 a | 852.286 | 3302.61 | Ūkio-buities nuotekos - F1 12
1251167 | 2 a | 164.369 | 4752.62 | Ūkio-buities nuotekos - F1 12
1251199 | 2 a | 1152.93 | 3478.88 | Ūkio-buities nuotekos - F1 12
1251294 | 2 a | 8.69254 | 3367.95 | Ūkio-buities nuotekos - F1 12
1251311 | 2 a | 495.268 | 3324.09 | Ūkio-buities nuotekos - F1 12
1251320 | 2 a | 911.9 | 3371.9 | Ūkio-buities nuotekos - F1 12
1251334 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 12
1251379 | 2 a | 1347.87 | 3486.98 | Ūkio-buities nuotekos - F1 12
1251411 | 2 a | 399.316 | 3338.84 | Ūkio-buities nuotekos - F1 12
1251426 | 2 a | 368.031 | 3292.43 | Ūkio-buities nuotekos - F1 12
1251435 | 2 a | 271.694 | 3350.6 | Ūkio-buities nuotekos - F1 12
1251449 | 2 a | 120.953 | 4929.46 | Ūkio-buities nuotekos - F1 12
1251487 | 2 a | 1381.97 | 3452.88 | Ūkio-buities nuotekos - F1 12
1251519 | 2 a | 239.566 | 3343.81 | Ūkio-buities nuotekos - F1 12
1251528 | 2 a | 6.18039 | 3336.25 | Ūkio-buities nuotekos - F1 12
1251541 | 2 a | 47.4729 | 4929.46 | Ūkio-buities nuotekos - F1 12
1251615 | 2 a | 1394.25 | 3440.59 | Ūkio-buities nuotekos - F1 12
1251791 | 2 a | 561.931 | 3312.02 | Ūkio-buities nuotekos - F1 12
1251802 | 4 a V1 | 134.219 | 3252.3 | Ūkio-buities nuotekos - F1 12
1251860 | 2 a | 945.217 | 3491.59 | Ūkio-buities nuotekos - F1 12
1251908 | 2 a | 124.761 | 4752.62 | Ūkio-buities nuotekos - F1 12
1251921 | 2 a | 1116.43 | 3515.38 | Ūkio-buities nuotekos - F1 12
1251924 | 2 a | 209.443 | 3263.63 | Ūkio-buities nuotekos - F1 12
1251953 | 2 a | 124.761 | 4752.62 | Ūkio-buities nuotekos - F1 12
1251964 | 2 a | 1096.02 | 3535.79 | Ūkio-buities nuotekos - F1 12
1251967 | 2 a | 883.218 | 3272.26 | Ūkio-buities nuotekos - F1 12
1252029 | 2 a | 391.596 | 3343.16 | Ūkio-buities nuotekos - F1 12
1252044 | 2 a | 742.255 | 3294.36 | Ūkio-buities nuotekos - F1 12
1252053 | 2 a | 158.43 | 3365.08 | Ūkio-buities nuotekos - F1 12
1252067 | 2 a | 150.82 | 4929.46 | Ūkio-buities nuotekos - F1 12
1252141 | 2 a | 1369.45 | 3465.4 | Ūkio-buities nuotekos - F1 12
1252173 | 2 a | 39.517 | 3366.63 | Ūkio-buities nuotekos - F1 12
1252182 | 2 a | 227.671 | 3358.07 | Ūkio-buities nuotekos - F1 12
1252195 | 2 a | 61.8367 | 3365.06 | Ūkio-buities nuotekos - F1 12
1252242 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 12
1252276 | 2 a | 1371.71 | 3463.14 | Ūkio-buities nuotekos - F1 12
1252344 | 4 a V1 | 1171.4 | 3506.1 | Ūkio-buities nuotekos - F1 12
1252353 | 4 a V1 | 75.3896 | 3259.43 | Ūkio-buities nuotekos - F1 12
1252393 | 2 a | 929.472 | 3283.45 | Ūkio-buities nuotekos - F1 12
1252404 | 4 a V1 | 3197.91 | 3185.54 | Ūkio-buities nuotekos - F1 12
1252413 | 2 a | 167.497 | 4929.46 | Ūkio-buities nuotekos - F1 12
1252447 | 2 a | 1435.97 | 3398.88 | Ūkio-buities nuotekos - F1 12
1252779 | 2 a | 56.6336 | 3354.47 | Ūkio-buities nuotekos - F1 12
1252786 | 2 a | 202.288 | 3360.65 | Ūkio-buities nuotekos - F1 12
1253265 | 2 a | 835.804 | 3999.05 | Ūkio-buities nuotekos - F1 12
1253305 | 2 a | 180.146 | 3564.98 | Ūkio-buities nuotekos - F1 12
1253314 | 2 a | 3345.33 | 3368.47 | Ūkio-buities nuotekos - F1 12
1253321 | 2 a | 1008.34 | 3839.73 | Ūkio-buities nuotekos - F1 12
1253336 | 2 a | 171.208 | 3861.35 | Ūkio-buities nuotekos - F1 12
1253452 | 2 a | 488.789 | 3206.07 | Ūkio-buities nuotekos - F1 12
1253461 | 4 a V1 | 251.5 | 3167.08 | Ūkio-buities nuotekos - F1 12
1253470 | 2 a | 3974.65 | 3219.62 | Ūkio-buities nuotekos - F1 12
1253484 | 2 a | 609.332 | 3302.87 | Ūkio-buities nuotekos - F1 12
1253498 | 2 a | 247.513 | 4929.46 | Ūkio-buities nuotekos - F1 12
1253566 | 2 a | 1422.95 | 3411.9 | Ūkio-buities nuotekos - F1 12
1253637 | 2 a | 318.716 | 3354.54 | Ūkio-buities nuotekos - F1 12
1253646 | 4 a V1 | 390.367 | 3174.92 | Ūkio-buities nuotekos - F1 12
1253655 | 2 a | 1568.99 | 3364.69 | Ūkio-buities nuotekos - F1 12
1253669 | 2 a | 131.828 | 3399.84 | Ūkio-buities nuotekos - F1 12
1253683 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 12
1253710 | 2 a | 1335.53 | 3499.32 | Ūkio-buities nuotekos - F1 12
1253742 | 2 a | 1770.54 | 3224.22 | Ūkio-buities nuotekos - F1 12
1253754 | 2 a | 55.5799 | 3357.12 | Ūkio-buities nuotekos - F1 12
1253755 | 2 a | 115.476 | 3272.43 | Ūkio-buities nuotekos - F1 12
1253759 | 2 a | 6770.71 | 3216.69 | Ūkio-buities nuotekos - F1 12
1253778 | 2 a | 429.296 | 3263.4 | Ūkio-buities nuotekos - F1 12
1253792 | 2 a | 107.485 | 4929.46 | Ūkio-buities nuotekos - F1 12
1253834 | 2 a | 1466.02 | 3368.83 | Ūkio-buities nuotekos - F1 12
1253894 | 4 a V1 | 540.332 | 3834.84 | Ūkio-buities nuotekos - F1 17
1253903 | 4 a V1 | 6135.53 | 3864.5 | Ūkio-buities nuotekos - F1 17
1253947 | 2 a | 217.379 | 3933.97 | Ūkio-buities nuotekos - F1 17
1254016 | 2 a | 345.154 | 4106.66 | Ūkio-buities nuotekos - F1 17
1254134 | 2 a | 535.253 | 3956.94 | Ūkio-buities nuotekos - F1 17
1254143 | 2 a | 797.534 | 3905.8 | Ūkio-buities nuotekos - F1 17
1254152 | 2 a | 710.827 | 4201.44 | Ūkio-buities nuotekos - F1 17
1254210 | 2 a | 122.819 | 4337.25 | Ūkio-buities nuotekos - F1 17
1254292 | 2 a | 1786.55 | 4215.07 | Ūkio-buities nuotekos - F1 17
1254301 | 2 a | 3688.7 | 4125.08 | Ūkio-buities nuotekos - F1 17
1254370 | 2 a | 486.902 | 4347.95 | Ūkio-buities nuotekos - F1 17
1254442 | 2 a | 541.134 | 3872.29 | Ūkio-buities nuotekos - F1 17
1254451 | 2 a | 615.06 | 3851.34 | Ūkio-buities nuotekos - F1 17
1254458 | 2 a | 129.796 | 4752.62 | Ūkio-buities nuotekos - F1 17
1254502 | 2 a | 580.369 | 4051.44 | Ūkio-buities nuotekos - F1 17
1254690 | 2 a | 561.382 | 3910 | Ūkio-buities nuotekos - F1 17
1254701 | 2 a | 500.783 | 3891.35 | Ūkio-buities nuotekos - F1 17
1254708 | 2 a | 105.594 | 4752.61 | Ūkio-buities nuotekos - F1 17
1254748 | 2 a | 542.241 | 4089.57 | Ūkio-buities nuotekos - F1 17
1254818 | 2 a | 561.412 | 3932.35 | Ūkio-buities nuotekos - F1 17
1254827 | 2 a | 43.6964 | 3925.23 | Ūkio-buities nuotekos - F1 17
1254834 | 2 a | 150.044 | 4752.62 | Ūkio-buities nuotekos - F1 17
1254873 | 2 a | 519.897 | 4111.91 | Ūkio-buities nuotekos - F1 17
1254946 | 2 a | 114.58 | 3937.19 | Ūkio-buities nuotekos - F1 17
1254955 | 2 a | 352.738 | 3881.48 | Ūkio-buities nuotekos - F1 17
1254964 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 17
1255031 | 2 a | 798.524 | 4036.33 | Ūkio-buities nuotekos - F1 17
1255060 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 17
1255071 | 2 a | 771.71 | 4063.14 | Ūkio-buities nuotekos - F1 17
1255074 | 2 a | 611.516 | 3922.49 | Ūkio-buities nuotekos - F1 17
1255192 | 2 a | 746.341 | 3970.57 | Ūkio-buities nuotekos - F1 17
1255207 | 2 a | 584.059 | 3942.66 | Ūkio-buities nuotekos - F1 17
1255216 | 2 a | 147.493 | 4929.46 | Ūkio-buities nuotekos - F1 17
1255259 | 2 a | 752.203 | 4082.65 | Ūkio-buities nuotekos - F1 17
1255360 | 2 a | 8.6926 | 3965.32 | Ūkio-buities nuotekos - F1 17
1255371 | 2 a | 30.4558 | 3930.55 | Ūkio-buities nuotekos - F1 17
1255380 | 2 a | 341.794 | 3969.26 | Ūkio-buities nuotekos - F1 17
1255439 | 2 a | 762.1 | 4072.75 | Ūkio-buities nuotekos - F1 17
1255733 | 2 a | 1476.03 | 4050.89 | Ūkio-buities nuotekos - F1 17
1255742 | 2 a | 3070.63 | 3972.05 | Ūkio-buities nuotekos - F1 17
1255813 | 2 a | 291.599 | 4177.25 | Ūkio-buities nuotekos - F1 17
1255896 | 2 a | 2066.6 | 4061.76 | Ūkio-buities nuotekos - F1 17
1255907 | 2 a | 413.642 | 4036.06 | Ūkio-buities nuotekos - F1 17
1255987 | 2 a | 278.913 | 4199.94 | Ūkio-buities nuotekos - F1 17
1256085 | 2 a | 225.703 | 4121.16 | Ūkio-buities nuotekos - F1 17
1256098 | 2 a | 2840.1 | 4046.93 | Ūkio-buities nuotekos - F1 17
1256107 | 2 a | 71.8162 | 4129.45 | Ūkio-buities nuotekos - F1 17
1256121 | 2 a | 134.191 | 4929.46 | Ūkio-buities nuotekos - F1 17
1256194 | 2 a | 607.117 | 4227.73 | Ūkio-buities nuotekos - F1 17
1256223 | 2 a | 1466.14 | 4139.91 | Ūkio-buities nuotekos - F1 17
1256232 | 2 a | 807.315 | 4106.33 | Ūkio-buities nuotekos - F1 17
1256336 | 2 a | 217.775 | 4266.07 | Ūkio-buities nuotekos - F1 17
1256571 | 4 a V1 | 273.555 | 3555.57 | Ūkio-buities nuotekos - F1 18
1256580 | 4 a V1 | 8724.18 | 3585.53 | Ūkio-buities nuotekos - F1 18
1256668 | 2 a | 1013.88 | 3632.6 | Ūkio-buities nuotekos - F1 18
1256760 | 2 a | 639.991 | 3821.51 | Ūkio-buities nuotekos - F1 18
1256794 | 2 a | 241.697 | 3613.09 | Ūkio-buities nuotekos - F1 18
1256805 | 2 a | 135.063 | 3603.74 | Ūkio-buities nuotekos - F1 18
1256856 | 2 a | 197.379 | 3786.55 | Ūkio-buities nuotekos - F1 18
1256870 | 2 a | 343.919 | 4110.19 | Ūkio-buities nuotekos - F1 18
1257140 | 2 a | 346.408 | 4285.4 | Ūkio-buities nuotekos - F1 18
1257182 | 2 a | 210.767 | 3610.34 | Ūkio-buities nuotekos - F1 18
1257195 | 2 a | 151.399 | 3596.27 | Ūkio-buities nuotekos - F1 18
1257234 | 2 a | 231.49 | 3783.19 | Ūkio-buities nuotekos - F1 18
1257248 | 2 a | 365.282 | 4141.36 | Ūkio-buities nuotekos - F1 18
1257966 | 2 a | 104.757 | 4752.62 | Ūkio-buities nuotekos - F1 18
1257977 | 2 a | 314.809 | 4317 | Ūkio-buities nuotekos - F1 18
1258006 | 2 a | 480.416 | 3623.01 | Ūkio-buities nuotekos - F1 18
1258015 | 2 a | 129.67 | 3610.88 | Ūkio-buities nuotekos - F1 18
1258028 | 2 a | 144.445 | 4752.62 | Ūkio-buities nuotekos - F1 18
1258090 | 2 a | 840.035 | 3791.78 | Ūkio-buities nuotekos - F1 18
1258190 | 2 a | 481.29 | 3600.47 | Ūkio-buities nuotekos - F1 18
1258203 | 2 a | 559.825 | 3580.63 | Ūkio-buities nuotekos - F1 18
1258210 | 2 a | 144.606 | 4752.62 | Ūkio-buities nuotekos - F1 18
1258246 | 2 a | 853.079 | 3778.73 | Ūkio-buities nuotekos - F1 18
1258397 | 2 a | 749.392 | 3611.78 | Ūkio-buities nuotekos - F1 18
1258412 | 2 a | 554.153 | 3566.74 | Ūkio-buities nuotekos - F1 18
1258421 | 2 a | 207.505 | 4929.46 | Ūkio-buities nuotekos - F1 18
1258456 | 2 a | 1110.94 | 3723.91 | Ūkio-buities nuotekos - F1 18
1258487 | 2 a | 523.251 | 3668.26 | Ūkio-buities nuotekos - F1 18
1258498 | 2 a | 593.355 | 3617.92 | Ūkio-buities nuotekos - F1 18
1258507 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 18
1258551 | 2 a | 1059.27 | 3775.58 | Ūkio-buities nuotekos - F1 18
1258612 | 2 a | 642.376 | 3670.84 | Ūkio-buities nuotekos - F1 18
1258621 | 2 a | 102.823 | 3663.74 | Ūkio-buities nuotekos - F1 18
1258628 | 2 a | 369.284 | 3687.46 | Ūkio-buities nuotekos - F1 18
1258642 | 2 a | 113.576 | 4929.46 | Ūkio-buities nuotekos - F1 18
1258686 | 2 a | 1043.15 | 3791.7 | Ūkio-buities nuotekos - F1 18
1258717 | 2 a | 586.645 | 4141.33 | Ūkio-buities nuotekos - F1 18
1258732 | 2 a | 131.787 | 4104.74 | Ūkio-buities nuotekos - F1 18
1258741 | 2 a | 658.975 | 4184.74 | Ūkio-buities nuotekos - F1 18
1258753 | 2 a | 247.513 | 4929.46 | Ūkio-buities nuotekos - F1 18
1258796 | 2 a | 540.084 | 4294.76 | Ūkio-buities nuotekos - F1 18
1258825 | 2 a | 564.068 | 4172.39 | Ūkio-buities nuotekos - F1 18
1258846 | 2 a | 153.11 | 4135.49 | Ūkio-buities nuotekos - F1 18
1258855 | 2 a | 2189.51 | 4185.23 | Ūkio-buities nuotekos - F1 18
1258867 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 18
1258923 | 2 a | 508.988 | 4325.86 | Ūkio-buities nuotekos - F1 18
1259181 | 2 a | 55.5469 | 4187.32 | Ūkio-buities nuotekos - F1 18
1259192 | 2 a | 1382.64 | 4154.63 | Ūkio-buities nuotekos - F1 18
1259199 | 2 a | 3047.16 | 4189.99 | Ūkio-buities nuotekos - F1 18
1259244 | 2 a | 492.088 | 4254.7 | Ūkio-buities nuotekos - F1 18
1259258 | 2 a | 114.64 | 4929.44 | Ūkio-buities nuotekos - F1 18
1259300 | 2 a | 473.455 | 4361.39 | Ūkio-buities nuotekos - F1 18
1259770 | 2 a | 223.334 | 3289.96 | Ūkio-buities nuotekos - F1 13
1259787 | 2 a | 170.912 | 3149.21 | Ūkio-buities nuotekos - F1 13
1259880 | 4 a V1 | 8256.4 | -5299.97 | Ūkio-buities nuotekos - F1 13
1260080 | 2 a | 160.985 | 4743.91 | Ūkio-buities nuotekos - F1 13
1260091 | 2 a | 1100.47 | 3529.14 | Ūkio-buities nuotekos - F1 13
1260094 | 2 a | 66.309 | 3284.19 | Ūkio-buities nuotekos - F1 13
1260528 | 2 a | 779.372 | 3303.72 | Ūkio-buities nuotekos - F1 13
1260537 | 2 a | 490.074 | 3270.91 | Ūkio-buities nuotekos - F1 13
1260669 | 2 a | 198.288 | 3323.71 | Ūkio-buities nuotekos - F1 13
1260768 | 2 a | 1010.8 | 3449.27 | Ūkio-buities nuotekos - F1 13
1260874 | 2 a | 1589.47 | 3302.06 | Ūkio-buities nuotekos - F1 13
1260883 | 2 a | 761.511 | 3252.87 | Ūkio-buities nuotekos - F1 13
1260906 | 2 a | 72.4839 | 4929.46 | Ūkio-buities nuotekos - F1 13
1260979 | 2 a | 1404.16 | 3430.69 | Ūkio-buities nuotekos - F1 13
1261058 | 2 a | 113.887 | 4752.03 | Ūkio-buities nuotekos - F1 13
1261067 | 2 a | 1139.48 | 3490.18 | Ūkio-buities nuotekos - F1 13
1261070 | 2 a | 2242.08 | 3203.6 | Ūkio-buities nuotekos - F1 13
1261098 | 2 a | 488.914 | 3189.37 | Ūkio-buities nuotekos - F1 13
1261111 | 2 a | 1378.43 | 3157.94 | Ūkio-buities nuotekos - F1 13
1261134 | 2 a | 779.439 | 3202.92 | Ūkio-buities nuotekos - F1 13
1261148 | 2 a | 959.856 | 3221.16 | Ūkio-buities nuotekos - F1 13
1261162 | 2 a | 11.8122 | 3244.13 | Ūkio-buities nuotekos - F1 13
1261176 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 13
1261232 | 2 a | 1493.64 | 3341.21 | Ūkio-buities nuotekos - F1 13
1261307 | 2 a | 384.551 | 3220.97 | Ūkio-buities nuotekos - F1 13
1261317 | 2 a | 1132.39 | 3232.43 | Ūkio-buities nuotekos - F1 13
1261490 | 2 a | 120.398 | 3259.04 | Ūkio-buities nuotekos - F1 13
1261496 | 2 a | 47.4729 | 4929.46 | Ūkio-buities nuotekos - F1 13
1261573 | 2 a | 1476.56 | 3358.29 | Ūkio-buities nuotekos - F1 13
1261725 | 2 a | 3473.13 | -4475.52 | Ūkio-buities nuotekos - F1 69
1261863 | 2 a | 6244.33 | 3462.96 | Ūkio-buities nuotekos - F1 69
1261925 | 2 a | 1064.64 | 3572.75 | Ūkio-buities nuotekos - F1 69
1261949 | 2 a | 688.023 | 3762.38 | Ūkio-buities nuotekos - F1 69
1261995 | 2 a | 491.339 | 3439.98 | Ūkio-buities nuotekos - F1 69
1262005 | 2 a | 59.8084 | 3574.65 | Ūkio-buities nuotekos - F1 69
1262006 | 2 a | 91.2036 | 3505.09 | Ūkio-buities nuotekos - F1 69
1262010 | 2 a | 2005.48 | 3528.2 | Ūkio-buities nuotekos - F1 69
1262037 | 2 a | 770.199 | 3474.15 | Ūkio-buities nuotekos - F1 69
1262051 | 2 a | 107.571 | 4752.62 | Ūkio-buities nuotekos - F1 69
1262088 | 2 a | 973.927 | 3657.89 | Ūkio-buities nuotekos - F1 69
1262532 | 2 a | 818.693 | 3681.31 | Ūkio-buities nuotekos - F1 69
1262541 | 2 a | 357.405 | 3463.52 | Ūkio-buities nuotekos - F1 69
1262781 | 2 a | 1069.44 | 3495.88 | Ūkio-buities nuotekos - F1 69
1262826 | 2 a | 260.761 | 3455.5 | Ūkio-buities nuotekos - F1 69
1262835 | 2 a | 127.489 | 4929.46 | Ūkio-buities nuotekos - F1 69
1262945 | 2 a | 1220.74 | 3614.11 | Ūkio-buities nuotekos - F1 69
1263036 | 2 a | 328.386 | 3476.73 | Ūkio-buities nuotekos - F1 69
1263055 | 2 a | 273.561 | 3431.69 | Ūkio-buities nuotekos - F1 69
1263064 | 2 a | 129.236 | 3487.08 | Ūkio-buities nuotekos - F1 69
1263078 | 2 a | 55.5986 | 4929.46 | Ūkio-buities nuotekos - F1 69
1263127 | 2 a | 1248.34 | 3586.51 | Ūkio-buities nuotekos - F1 69
1263207 | 2 a | 602.368 | 3479.31 | Ūkio-buities nuotekos - F1 69
1263254 | 2 a | 157.349 | 3471.12 | Ūkio-buities nuotekos - F1 69
1263261 | 2 a | 189.248 | 3495.13 | Ūkio-buities nuotekos - F1 69
1263275 | 2 a | 80.1486 | 4929.46 | Ūkio-buities nuotekos - F1 69
1263313 | 2 a | 1239.08 | 3595.77 | Ūkio-buities nuotekos - F1 69
1263360 | 2 a | 129.818 | 3559.35 | Ūkio-buities nuotekos - F1 69
1263369 | 2 a | 4610.56 | 3433.2 | Ūkio-buities nuotekos - F1 69
1263425 | 2 a | 23.8979 | 3658.79 | Ūkio-buities nuotekos - F1 69
1264048 | 2 a | 4855.71 | 3777.3 | Ūkio-buities nuotekos - F1 69
1264149 | 2 a | 863.609 | 3971.24 | Ūkio-buities nuotekos - F1 69
1264237 | 2 a | 6179.95 | 3776.14 | Ūkio-buities nuotekos - F1 71
1264295 | 2 a | 511.428 | 3825.47 | Ūkio-buities nuotekos - F1 71
1264304 | 2 a | 444.073 | 3109.86 | Ūkio-buities nuotekos - F1 71
1264311 | 2 a | 513.53 | 4004.04 | Ūkio-buities nuotekos - F1 71
1264415 | 2 a | 313.504 | 3820.92 | Ūkio-buities nuotekos - F1 71
1264435 | 2 a | 761.781 | 3912.12 | Ūkio-buities nuotekos - F1 71
1264479 | 2 a | 536.124 | 4095.69 | Ūkio-buities nuotekos - F1 71
1264493 | 2 a | 61.6696 | 4752.62 | Ūkio-buities nuotekos - F1 71
1264647 | 2 a | 3290.65 | 3746.48 | Ūkio-buities nuotekos - F1 71
1264672 | 2 a | 741.676 | 3862.09 | Ūkio-buities nuotekos - F1 71
1264685 | 2 a | 1049.83 | 3860.29 | Ūkio-buities nuotekos - F1 71
1264704 | 2 a | 586.548 | 4045.26 | Ūkio-buities nuotekos - F1 71
1264718 | 2 a | 124.761 | 4752.59 | Ūkio-buities nuotekos - F1 71
1265021 | 2 a | 510.205 | 3906.39 | Ūkio-buities nuotekos - F1 71
1265048 | 2 a | 362.597 | 3884.77 | Ūkio-buities nuotekos - F1 71
1265074 | 2 a | 461.809 | 4038.18 | Ūkio-buities nuotekos - F1 71
1265280 | 2 a | 444.641 | 3847.49 | Ūkio-buities nuotekos - F1 71
1265303 | 2 a | 72.0221 | 3830.67 | Ūkio-buities nuotekos - F1 71
1265325 | 2 a | 134.276 | 3866.07 | Ūkio-buities nuotekos - F1 71
1265336 | 2 a | 1046.58 | 3834.92 | Ūkio-buities nuotekos - F1 71
1265607 | 2 a | 91.8077 | 3872.53 | Ūkio-buities nuotekos - F1 71
1265621 | 2 a | 187.501 | 4929.46 | Ūkio-buities nuotekos - F1 71
1265707 | 2 a | 863.638 | 3971.21 | Ūkio-buities nuotekos - F1 71
1265874 | 2 a | 50.5676 | 3942.79 | Ūkio-buities nuotekos - F1 71
1265883 | 2 a | 579.392 | 3894.83 | Ūkio-buities nuotekos - F1 71
1265892 | 2 a | 665.448 | 3954.05 | Ūkio-buities nuotekos - F1 71
1265906 | 2 a | 206.199 | 4929.46 | Ūkio-buities nuotekos - F1 71
1265977 | 2 a | 770.94 | 4063.91 | Ūkio-buities nuotekos - F1 71
1266012 | 2 a | 359.584 | 3958.93 | Ūkio-buities nuotekos - F1 71
1266023 | 2 a | 200.672 | 3947.58 | Ūkio-buities nuotekos - F1 71
1266036 | 2 a | 87.4809 | 4929.46 | Ūkio-buities nuotekos - F1 71
1266157 | 2 a | 778.997 | 4055.85 | Ūkio-buities nuotekos - F1 71
1266251 | 2 a | 562.36 | 3945.37 | Ūkio-buities nuotekos - F1 71
1266262 | 2 a | 135.409 | 3937.62 | Ūkio-buities nuotekos - F1 71
1266269 | 2 a | 788.955 | 3960.39 | Ūkio-buities nuotekos - F1 71
1266283 | 2 a | 11.9242 | 3979.94 | Ūkio-buities nuotekos - F1 71
1266297 | 2 a | 167.497 | 4929.46 | Ūkio-buities nuotekos - F1 71
1266367 | 2 a | 757.821 | 4077.03 | Ūkio-buities nuotekos - F1 71
1266556 | 2 a | 6841.56 | 3940.2 | Ūkio-buities nuotekos - F1 71
1266579 | 2 a | 458.89 | 3925.97 | Ūkio-buities nuotekos - F1 71
