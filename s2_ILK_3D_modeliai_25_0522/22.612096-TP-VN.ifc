Properties of the parts of a building model (IFC2X3), part 44 of 57

# IfcFlowFitting: PIF_Tigris_Super_Tee_Wavin:Standard SuperTee (1063)
Name (PIF_Tigris_Super_Tee_Wavin:Standard SuperTee:...) | In | Material | Group
1357953 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358045 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358166 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358281 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358347 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358632 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358816 | 3 a | <Unnamed>, PE-X, White, RAL 9100, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1358965 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1359052 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1359139 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1359257 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1359475 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1359531 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1359852 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1360034 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1360546 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1360717 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1360858 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1360935 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361038 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361107 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361174 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361261 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361361 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361745 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361858 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1361961 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1362330 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1362410 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1362487 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1362702 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1362875 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1362947 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363053 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363140 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363219 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363727 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363819 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363897 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1363954 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1364067 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1364161 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1364297 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1364620 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1364710 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1364804 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365040 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365124 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365271 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365355 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365448 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365539 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365596 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365812 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1365916 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366039 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366154 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366227 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366474 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366545 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366728 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366894 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1366939 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo šaltas - V1 2
1367082 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1367191 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1367288 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1367679 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1367753 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1367921 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368131 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368335 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368495 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368568 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368664 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368743 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368832 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1368931 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1369276 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1369445 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1369614 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1369715 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1369798 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1370045 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1370200 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1370303 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1370369 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1370487 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1370921 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1371013 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1371542 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1371934 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1372463 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1372772 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1372844 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1372960 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373086 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373229 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373375 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373449 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373565 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373644 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1373935 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375388 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375527 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375605 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375722 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375787 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375857 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1375915 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376074 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376133 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376239 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376329 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376391 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376454 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376529 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376625 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376697 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376771 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1376839 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377090 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377153 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377246 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377378 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377464 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377543 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377654 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377860 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1377932 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378007 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378198 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378264 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378331 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378405 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378536 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378594 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378672 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378738 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378803 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1378880 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379209 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379298 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379367 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379517 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379584 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379670 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379748 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379816 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379891 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1379956 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380020 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380123 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380248 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380392 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380449 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380551 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380624 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380706 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380817 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1380974 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381058 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381173 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381250 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381324 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381397 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381489 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381561 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381631 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381716 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1381811 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo šaltas - V1 2
1382227 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382317 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382480 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382561 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382638 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382721 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382784 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382864 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1382926 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1383504 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1383635 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1383729 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1383797 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1383882 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384021 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384105 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384184 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384279 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384363 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384451 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384539 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384615 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384653 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384763 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384849 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1384998 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1385061 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1385119 | 2 a | <Unnamed>, PE-X, White, RAL 9100, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1385256 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1385418 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1385507 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1385887 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1386029 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1386746 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1386839 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1386903 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387020 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387124 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387197 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387294 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387470 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387574 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387642 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1387815 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388082 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388164 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388234 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388303 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388379 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388514 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388585 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388672 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388836 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1388931 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389006 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389089 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389182 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389277 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389631 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389833 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389920 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1389991 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390106 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390218 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390332 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390434 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390517 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390601 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1390909 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391212 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391290 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391384 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391454 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391576 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391628 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391710 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391813 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391923 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1391992 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1392101 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1392746 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1392961 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1393114 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1393233 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394221 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394317 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394382 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394458 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394532 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394605 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394674 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394779 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394869 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1394946 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1395360 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1395524 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1395615 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1395862 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1396074 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1396472 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1396543 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397018 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397108 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397541 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397611 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397708 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397793 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397872 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1397935 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398021 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398244 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398387 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398453 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398570 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398731 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398853 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1398938 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399087 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399210 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399342 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399426 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399500 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399567 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1399640 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1400117 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1400243 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1400581 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1400671 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1400793 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1401086 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1401147 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1401233 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1401425 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1401711 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402151 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402229 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402304 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402367 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402727 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402812 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1402891 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403018 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403101 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403351 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403426 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403511 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403811 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403876 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1403967 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1404036 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1404260 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1404331 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1404473 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1404975 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405315 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405397 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405485 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405550 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405664 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405783 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405868 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1405976 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406085 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406169 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406302 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406452 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406543 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406617 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406710 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406783 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406885 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1406960 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407035 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407153 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407247 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407442 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407698 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407761 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1407824 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1408134 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1408367 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1408465 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1408530 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1408589 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1409272 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1410081 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1411528 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1420463 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1420639 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1421692 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1421826 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1422611 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1422857 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1423675 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1423824 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424454 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424502 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424550 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424587 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424628 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424717 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424765 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424817 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424841 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424867 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424917 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424957 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1424987 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425037 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425099 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425186 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425218 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425319 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425418 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425443 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425467 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425491 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425515 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425557 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425596 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425708 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425745 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1425936 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1426660 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1426716 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1426722 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1426770 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1426879 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1427135 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1427881 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1428066 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 3
1429362 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1430491 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1430582 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1430997 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1431131 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1432171 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1432274 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1432499 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1432682 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1432730 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1432736 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1432794 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1432865 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1433742 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1434003 | 0 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1434343 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1434521 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1434609 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1434722 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1434835 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1434942 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1435053 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1435414 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1435572 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1435865 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1435948 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1436024 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1436168 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1436351 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1436706 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1436777 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1436927 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1437149 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1437237 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1437348 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1437667 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1437785 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1437996 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1438117 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1438237 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1438337 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1438518 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1438613 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1438771 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1439370 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1439612 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1439849 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1439929 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1439998 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1440679 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1440773 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1440895 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1441259 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1441526 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1441632 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1441719 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1441891 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1442096 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1442167 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1442444 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1442528 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1442729 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1442837 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1442943 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1443104 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1443339 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1443462 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1443620 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1443773 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1443808 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1444072 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1444231 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1444310 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1444393 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1444494 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1444602 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1444728 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1444862 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1445009 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1445047 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1445151 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1445791 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1445898 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1445981 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1446083 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1446221 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1446483 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 7
1446574 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1446888 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1446998 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1447107 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1447231 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1447308 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1447412 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1447497 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1448009 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 10
1448156 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1448748 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1448846 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1448917 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1449065 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1449176 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1449283 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1449370 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1449477 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1449821 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1450199 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1450381 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1450429 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1450511 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1450655 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1450754 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1450911 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1451008 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1451076 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1451189 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo karštas tiekiamasis - T3 1
1451727 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1451957 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452135 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452346 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452433 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452536 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452607 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452685 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1452755 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1453131 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1453336 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1453367 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1; vanduo karštas apytakinis - T4 1
1453707 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1453805 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1453893 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1453975 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454061 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454141 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454238 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454311 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454388 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454460 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454613 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454692 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454794 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454845 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1454994 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455065 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455124 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455221 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455289 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455362 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455457 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455523 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1455602 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455688 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455766 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455836 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1455925 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456032 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456111 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456193 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456273 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456356 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456441 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456525 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456600 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456670 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456780 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1456853 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
