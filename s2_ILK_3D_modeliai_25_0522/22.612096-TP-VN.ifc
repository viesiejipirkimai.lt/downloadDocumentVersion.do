Properties of the parts of a building model (IFC2X3), part 5 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1195224_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195168_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195169_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195168_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195176_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195176_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195293_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195182_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195263_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195182_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195222_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195224_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195222_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195263_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195284_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195324_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195602_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195292_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195600_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195602_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195600_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195610_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195610_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195654_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195662_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195654_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195676_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195662_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195663_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195670_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195670_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195752_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195684_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195758_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195750_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195752_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1195758_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 8
Port_1196277_0 | SOURCEANDSINK | K1 2
Port_1196391_2 | SOURCEANDSINK | K1 2
Port_1196277_1 | SOURCEANDSINK | K1 2
Port_1196301_2 | SOURCEANDSINK | K1 2
Port_1196285_1 | SOURCEANDSINK | K1 2
Port_1196286_1 | SOURCEANDSINK | K1 2
Port_1196285_3 | SOURCEANDSINK | K1 2
Port_1196392_0 | SOURCEANDSINK | K1 2
Port_1196295_0 | SOURCEANDSINK | K1 2
Port_1196301_1 | SOURCEANDSINK | K1 2
Port_1196295_1 | SOURCEANDSINK | K1 2
Port_1196354_1 | SOURCEANDSINK | K1 2
Port_1196309_0 | SOURCEANDSINK | K1 2
Port_1196360_2 | SOURCEANDSINK | K1 2
Port_1196309_1 | SOURCEANDSINK | K1 2
Port_1196352_0 | SOURCEANDSINK | K1 2
Port_1196354_2 | SOURCEANDSINK | K1 2
Port_1196352_1 | SOURCEANDSINK | K1 2
Port_1196360_1 | SOURCEANDSINK | K1 2
Port_1196381_0 | SOURCEANDSINK | K1 2
Port_1196391_3 | SOURCEANDSINK | K1 2
Port_1196381_1 | SOURCEANDSINK | K1 2
Port_1196405_2 | SOURCEANDSINK | K1 2
Port_1196391_1 | SOURCEANDSINK | K1 2
Port_1196392_1 | SOURCEANDSINK | K1 2
Port_1196399_0 | SOURCEANDSINK | K1 2
Port_1196405_1 | SOURCEANDSINK | K1 2
Port_1196399_1 | SOURCEANDSINK | K1 2
Port_1196461_1 | SOURCEANDSINK | K1 2
Port_1196413_0 | SOURCEANDSINK | K1 2
Port_1196469_2 | SOURCEANDSINK | K1 2
Port_1196413_1 | SOURCEANDSINK | K1 2
Port_1196459_0 | SOURCEANDSINK | K1 2
Port_1196461_2 | SOURCEANDSINK | K1 2
Port_1196459_1 | SOURCEANDSINK | K1 2
Port_1196469_1 | SOURCEANDSINK | K1 2
Port_1196505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196519_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196513_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196519_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196513_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196527_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196585_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196527_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196577_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196577_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196585_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196777_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196891_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196777_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196852_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196808_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196892_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196816_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196858_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196850_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196852_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196858_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196879_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196891_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196879_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196891_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196962_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196956_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196962_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196956_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197034_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196970_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197040_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1196970_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197032_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197034_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197040_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1197238_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197239_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197238_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197248_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197326_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197320_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197320_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197374_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197334_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197382_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197334_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197372_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197374_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197372_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 7
Port_1197457_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197469_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197499_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197469_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1856006_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197469_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197493_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197499_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197493_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197548_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197507_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197556_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197507_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197546_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197548_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197556_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 10
Port_1197599_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197611_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197611_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197657_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197649_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197651_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197649_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197657_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197890_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197892_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197890_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1197892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198088_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199119_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198088_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198112_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198122_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198796_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198248_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198805_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198248_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198264_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198367_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198264_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198368_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198278_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198284_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198328_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198292_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198336_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198292_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198326_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198328_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198357_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198367_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198403_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198367_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198368_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198375_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198411_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198375_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198401_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198403_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198401_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198441_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198834_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198441_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198805_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198448_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198448_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198795_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198796_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198795_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199120_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198795_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198835_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198826_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198834_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198826_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198834_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198835_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198842_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198884_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198842_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198874_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199454_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198874_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198884_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1198876_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199455_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199111_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199119_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199111_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199181_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199120_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199272_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199272_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199335_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199333_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199335_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199333_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199343_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199343_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199454_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199454_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199920_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199920_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199934_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199928_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199942_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199948_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199942_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199962_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199956_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199962_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1199956_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200057_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200055_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200057_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200055_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200065_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200065_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200117_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200118_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200117_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200327_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200141_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200326_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200141_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200236_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200234_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200236_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200234_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200312_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200326_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200312_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200342_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200327_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200336_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200449_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200356_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200342_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200450_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200350_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200350_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200394_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200364_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200400_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200364_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200392_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200394_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200392_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200400_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200439_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200457_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200469_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200449_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200463_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200469_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200463_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200545_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200510_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200553_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200510_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200543_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200545_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200543_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1200553_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
OutPort_1200604_1 | SOURCE
Port_1200644_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200652_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200668_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200862_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200856_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200862_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200856_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200870_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200914_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200870_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200904_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200906_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200904_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1200914_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201023_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201031_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201023_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201077_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201079_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201077_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201145_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201161_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201145_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201153_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201153_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201253_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201153_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201161_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201167_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201223_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201205_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201207_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201205_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201223_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201244_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201260_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201252_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201252_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201350_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201252_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201266_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201316_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201266_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201298_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201298_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201316_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201337_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201349_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201387_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201349_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201350_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201385_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201387_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
OutPort_1201443_1 | SOURCE
OutPort_1201455_1 | SOURCE
Port_1201469_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202363_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
OutPort_1201505_1 | SOURCE
Port_1201521_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202901_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1201539_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204764_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1201551_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204599_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1201567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203918_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1201603_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201611_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201603_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201637_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201645_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201659_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201645_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201646_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201645_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201763_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201653_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201659_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201653_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201717_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201675_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201723_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201675_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201715_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201717_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201723_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201760_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201762_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201760_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201762_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201763_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201810_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201820_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201810_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201836_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201820_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201821_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201988_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201830_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201836_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201844_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201850_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201844_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201933_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201920_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201939_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201920_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201931_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201933_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201931_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201939_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201978_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201988_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201978_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202004_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201988_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201989_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201989_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202337_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201998_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202004_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1201998_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202052_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202012_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202058_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202012_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202050_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202052_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202050_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202058_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202325_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202337_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202325_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202373_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202338_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202338_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202684_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202347_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202365_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202347_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202373_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202363_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202365_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202397_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202407_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202397_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202423_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202408_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202407_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202685_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202417_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202423_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202437_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202431_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202437_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202431_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202477_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202445_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202483_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202445_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202475_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202477_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202475_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202483_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202504_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 41
Port_1202504_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 41
Port_1202676_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202684_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202700_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202694_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202700_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202694_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202708_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202746_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202708_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202738_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202740_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202738_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202746_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 13
Port_1202837_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202845_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202837_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202861_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202883_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202995_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202883_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202940_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202903_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202996_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202941_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202941_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203099_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202981_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202995_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202981_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203011_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202995_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1202996_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203005_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203011_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203064_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203019_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203070_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203019_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203062_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203064_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203062_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203070_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203091_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203099_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203146_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203099_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203100_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203100_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203530_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203107_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203154_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203107_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203144_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203146_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203144_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203205_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203213_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203205_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203227_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203213_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203214_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203213_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203309_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203214_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203719_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203221_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203227_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203221_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203269_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203235_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203275_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203235_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203267_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203269_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203267_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203275_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203296_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203406_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203296_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203324_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203308_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203531_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203308_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203318_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203324_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203318_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203332_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203377_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203371_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203377_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203398_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203406_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203398_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203420_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203406_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203414_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203420_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203414_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203428_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203501_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203428_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203493_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203495_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203493_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203501_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203522_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203530_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203522_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203573_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203530_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203531_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203540_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203540_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203571_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203573_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203571_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203601_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203623_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203601_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203635_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203615_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203616_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203615_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203720_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203615_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203623_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203629_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203635_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203651_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203684_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203651_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203676_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203678_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203705_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203719_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203705_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203735_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203719_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203729_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203735_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203729_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203777_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203743_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203783_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203743_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203775_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203777_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203783_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 14
Port_1203843_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203851_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203843_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203876_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203920_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203928_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203918_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203920_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203929_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203928_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204054_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203969_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203971_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1203969_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204031_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204053_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204031_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204083_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204053_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204077_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204083_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204077_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204091_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204133_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204091_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204125_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204127_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204125_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204133_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204162_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204181_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204162_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204171_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204173_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204171_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204181_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204173_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204174_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204262_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204270_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204262_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204300_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204270_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204610_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204270_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204271_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204300_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204341_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204413_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204341_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204405_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204407_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204405_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204413_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204565_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204601_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204565_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204609_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204574_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204609_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204601_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204609_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204610_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204685_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204685_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204695_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204800_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204695_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204740_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204734_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204740_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204734_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204774_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204748_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204766_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204748_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204764_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204766_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204790_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204800_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204790_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204915_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204800_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204801_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204913_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204915_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204913_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204921_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204921_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1204954_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 43
Port_1204954_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 43
Port_1205019_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205107_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205107_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205144_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205115_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205183_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205115_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205142_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205144_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205302_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205339_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205302_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205303_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205303_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205435_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205310_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205347_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205310_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205337_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205339_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205347_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205427_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205435_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205427_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205449_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205435_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205436_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205443_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205449_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205443_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205530_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205457_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205536_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205528_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205530_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205536_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1205628_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205636_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205674_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205644_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205713_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205672_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205674_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205713_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205795_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205803_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205795_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205834_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205803_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205811_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205840_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205832_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205834_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205832_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205840_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205958_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205966_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206010_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205967_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205974_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206016_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1205974_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206008_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206010_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206008_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206016_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 19
Port_1206085_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206093_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206085_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206135_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206133_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206135_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206133_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206143_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206143_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 20
Port_1206179_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206187_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206179_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206220_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206195_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206228_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206195_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206218_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206220_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206228_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206261_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206273_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206287_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206273_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206274_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206281_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206287_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206281_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206457_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206446_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206463_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206455_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206457_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206455_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206463_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206484_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206492_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206561_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206492_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206493_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206500_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206567_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206500_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206559_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206561_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206559_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206624_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206632_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206624_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206640_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206682_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206640_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206674_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206676_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206674_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206682_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206727_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206735_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206771_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206735_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206736_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206735_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1207023_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206769_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206771_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206769_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206779_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206779_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206819_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206825_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206819_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206968_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206957_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206974_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206957_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206966_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206968_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
Port_1206966_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 18
