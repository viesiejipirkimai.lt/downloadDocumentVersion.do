Properties of the parts of a building model (IFC2X3), part 24 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1414585_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414591_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414585_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414599_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414684_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414676_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414678_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414676_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414684_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414789_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414960_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414789_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414875_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414815_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414914_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414815_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414914_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414961_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414952_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414960_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414952_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414960_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1414961_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1415019_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1415033_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1415019_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1415097_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415105_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415097_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415248_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415788_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415248_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415361_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415256_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415257_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415256_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415926_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415329_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415361_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415329_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415375_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415369_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415375_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415369_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415509_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415383_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415509_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415383_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415519_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415513_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415519_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415513_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415613_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415596_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415619_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415596_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415611_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415613_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415611_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415619_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415778_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415798_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415778_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415891_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415788_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415789_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415788_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415798_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415789_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415925_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415804_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415855_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415804_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415891_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415853_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415855_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415925_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415926_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415925_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415979_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415981_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415979_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415987_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415981_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1415987_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 1
Port_1416111_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416119_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416111_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416149_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416141_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416737_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416141_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416149_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416738_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416272_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416273_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416272_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416542_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416296_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416541_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416296_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416314_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416308_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416314_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416308_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416431_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416322_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416437_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416322_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416429_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416431_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416429_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416437_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416531_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416541_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416531_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416663_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416541_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416542_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416549_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416669_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416549_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416661_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416663_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416661_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416669_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416723_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416874_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416723_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416829_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416737_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416738_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416737_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416875_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416743_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416802_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416743_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416829_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416794_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416796_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416796_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416802_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416862_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1503661_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416862_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416894_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416874_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416875_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416874_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416882_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416882_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417014_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416888_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416894_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1416888_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417094_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417005_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417013_3 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417005_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417060_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417013_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417014_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417013_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1503662_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417052_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417060_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417052_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417086_0 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417094_2 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417086_1 | SOURCEANDSINK | nuotekos ūkio-buities - F1 4
Port_1417230_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417230_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417251_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417865_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417286_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417259_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417259_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417866_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417278_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417286_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417278_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417778_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417813_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417470_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417438_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417456_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417438_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417470_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417454_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417456_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417693_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417703_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417704_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417703_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417814_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417704_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417805_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417813_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417805_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417827_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417813_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417814_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417821_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417827_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417821_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417849_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417865_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417849_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417901_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417865_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417866_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417875_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418045_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417891_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417893_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417893_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418805_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417918_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417940_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1417918_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1504082_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418037_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418118_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418037_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418045_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418046_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418045_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418046_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418804_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418082_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418118_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418082_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418158_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418118_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418119_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418119_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418406_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418152_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418158_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418152_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418396_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418406_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418396_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418422_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418406_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418416_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418416_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418794_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418804_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418794_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418816_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418804_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418805_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418810_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418816_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418810_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 16
Port_1418837_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418845_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418837_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418875_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418845_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418846_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418869_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418869_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1419005_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418989_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1419005_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1418989_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 75
Port_1419044_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1859643_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1419044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1419052_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1858417_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1419153_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 84
Port_1419218_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1502244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1419218_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1419240_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1502245_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 87
Port_1419328_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1419336_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1419328_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 6
Port_1419468_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862253_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1419468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1419476_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862254_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1419560_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1859543_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1419560_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1419566_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1506134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 12
Port_1419836_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420463_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1419836_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1419892_0 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1420210_2 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419892_1 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1420349_1 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419923_0 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419947_2 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419923_1 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419941_0 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1420210_1 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419941_1 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1419947_1 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1420349_2 | SOURCEANDSINK | vanduo šaltas - V1 6
Port_1420369_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423005_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424091_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420428_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420429_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420428_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420640_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420463_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420485_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420463_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420464_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420464_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420639_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420479_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420485_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420479_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420496_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420490_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420490_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420500_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420565_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420500_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420559_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420561_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420559_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420631_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420639_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420631_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420661_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420639_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420640_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420655_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420655_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420671_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420665_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420671_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420665_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420745_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420676_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420750_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420743_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420745_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420743_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420750_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420774_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420786_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420774_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420900_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420786_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420940_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420786_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420787_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424090_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420830_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420902_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420898_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420900_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420898_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420902_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420921_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420939_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420939_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421051_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420939_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420940_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420947_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421023_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1420947_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421019_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421021_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421019_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421023_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421038_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421050_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421050_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421147_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421050_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421051_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421058_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421117_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421058_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421113_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421115_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421113_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421117_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421132_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421146_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421132_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421160_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421146_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421146_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421147_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421154_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421160_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421154_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421164_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421226_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421164_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421220_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421222_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421220_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421226_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421253_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421267_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421253_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421267_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421361_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421267_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421275_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421335_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421275_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421331_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421333_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421331_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421335_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421350_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421360_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421350_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421374_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421496_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421360_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421368_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421368_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421462_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421378_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421466_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421378_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421460_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421462_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421460_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421481_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421692_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421481_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421509_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421495_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424160_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421495_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421496_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421495_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421827_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421503_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421509_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421503_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421513_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421603_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421513_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421599_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421601_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421599_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421603_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421684_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421692_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421684_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421795_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421692_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421693_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421693_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421826_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421708_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421799_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421708_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421793_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421795_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421793_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421799_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421816_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421826_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421826_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421827_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421830_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421908_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421902_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421904_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421902_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421908_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421923_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421931_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421923_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422013_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421931_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424202_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421931_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421932_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421932_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424159_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421939_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422017_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1421939_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422011_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422013_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422011_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422017_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422032_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422048_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422032_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422135_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422048_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422172_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422048_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422049_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422049_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424201_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422056_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422139_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422056_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422133_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422135_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422133_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422139_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422163_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422171_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422163_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422187_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422171_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422282_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422171_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422172_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422179_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422187_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422189_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422247_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422189_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422241_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422243_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422241_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422247_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422269_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422281_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422269_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422281_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424302_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422281_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422282_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422289_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422355_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422289_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422349_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422351_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422349_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422375_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422611_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422375_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422409_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422393_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422736_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422393_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422394_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422393_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422612_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422394_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424301_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422401_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422409_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422467_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422411_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422469_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422411_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422465_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422467_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422465_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422469_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422603_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422611_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422603_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422621_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422611_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422612_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422615_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422621_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422699_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422623_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422703_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422623_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422697_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422699_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422697_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422703_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422723_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422857_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422723_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422751_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422735_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424455_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422735_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422736_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422735_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422858_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422743_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422751_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422743_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422809_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422753_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422811_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422753_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422807_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422809_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422811_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422849_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422857_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422849_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422857_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422858_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422947_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422869_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422951_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422945_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422947_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422945_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422951_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422987_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423005_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1422987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423021_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423005_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423006_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423013_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423021_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423013_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423071_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423023_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423075_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423023_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423069_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423071_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423069_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423075_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423141_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423195_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423141_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423169_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423195_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423357_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423195_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423196_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423196_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423532_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423210_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423222_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423210_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423232_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423224_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423232_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423305_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423234_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423307_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423303_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423305_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423303_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423356_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424410_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423356_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423356_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423364_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423364_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423406_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423400_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423406_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423469_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423408_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423473_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423408_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423467_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423469_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423467_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423473_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423520_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423532_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423520_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423549_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423532_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423540_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423540_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423612_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423551_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423614_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423610_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423612_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423610_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423614_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423661_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423777_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423661_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423685_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423675_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423675_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423825_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423679_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1426790_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423679_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423695_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423685_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1426790_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423687_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423695_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423687_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423738_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423777_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423738_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423777_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423778_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423778_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423824_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423799_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423824_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423799_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423838_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423824_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423825_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423828_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423838_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423846_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423846_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1423840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424019_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424033_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424019_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424033_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424034_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424076_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424090_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424076_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424090_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424143_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424159_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424143_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424159_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424160_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424185_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424201_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424185_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424243_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424201_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424207_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424207_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424245_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424251_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424245_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424261_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424253_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424261_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424253_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424277_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424301_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424277_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424315_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424301_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424307_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424315_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424323_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424317_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424323_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424349_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424357_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424349_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424369_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424357_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424358_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424358_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424409_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424363_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424369_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424363_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424379_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424371_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424379_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424387_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424381_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424387_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424381_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424401_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424409_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424401_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424423_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424409_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424410_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424415_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424423_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424415_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424448_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424454_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424448_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424466_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424454_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424455_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424458_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424466_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424458_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424474_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424468_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424474_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424468_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424488_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424502_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424502_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424551_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424502_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424503_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424506_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424518_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424506_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424536_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424550_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424562_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424550_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424588_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424550_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424551_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424554_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424562_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424554_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424579_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424587_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424579_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424629_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424587_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424588_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424591_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424601_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424591_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424628_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425746_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424628_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424629_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424628_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424694_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424686_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424694_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424686_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424717_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424718_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424717_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424721_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424718_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425745_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424721_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424735_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424727_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424735_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424727_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424748_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424748_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424781_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424763_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424765_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424763_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424769_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424765_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424766_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424766_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424917_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424769_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424868_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424773_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424781_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424773_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424789_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424783_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424789_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424783_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424805_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424817_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424805_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424817_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424818_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424841_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424833_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424841_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424833_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424841_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424842_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424842_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424867_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424859_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424867_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424859_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424877_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424867_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424868_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424871_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424877_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424871_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424891_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424891_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424931_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424917_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424917_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425187_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424921_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424931_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424949_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424957_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424949_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424957_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424958_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424958_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424987_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424987_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424987_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424988_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1424988_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425037_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425029_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425037_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425029_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425037_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425038_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425099_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425091_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425099_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425091_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425099_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425100_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425100_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425186_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425103_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425109_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425103_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425174_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425186_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425186_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425187_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425202_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425218_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1448847_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425218_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425298_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425418_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425298_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425317_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425319_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425323_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425319_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425320_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425323_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425516_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425327_0 | SOURCEANDSINK | V1 1
Port_1425327_1 | SOURCEANDSINK | V1 1
Port_1425410_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425418_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425410_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425418_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425419_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425419_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425443_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425435_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425443_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425443_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425444_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425467_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425459_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425467_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425459_1 | SOURCEANDSINK | vanduo šaltas - V1 2
