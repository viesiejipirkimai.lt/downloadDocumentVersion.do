Properties of the parts of a building model (IFC2X3), part 46 of 57

# IfcFlowFitting: Z_PIF_AS+_Bend_Wavin_(nested):socket_end (3905)
Name (Z_PIF_AS+_Bend_Wavin_(nested):socket_end:...) | In
1159015 | 4 a V1
1159108 | 4 a V1
1159110 | 4 a V1
1159161 | 4 a V1
1159163 | 4 a V1
1159167 | 4 a V1
1159169 | 4 a V1
1159188 | 4 a V1
1159190 | 4 a V1
1159592 | 4 a V1
1159594 | 4 a V1
1159638 | 4 a V1
1159640 | 4 a V1
1159750 | 4 a V1
1159752 | 4 a V1
1159800 | 4 a V1
1159802 | 4 a V1
1159806 | 4 a V1
1159808 | 4 a V1
1159973 | 4 a V1
1159975 | 4 a V1
1159979 | 4 a V1
1159981 | 4 a V1
1160055 | 4 a V1
1160057 | 4 a V1
1160133 | 4 a V1
1160135 | 4 a V1
1160139 | 4 a V1
1160141 | 4 a V1
1160334 | 4 a V1
1160336 | 4 a V1
1160393 | 4 a V1
1160395 | 4 a V1
1160399 | 4 a V1
1160401 | 4 a V1
1160520 | 4 a V1
1160522 | 4 a V1
1160528 | 4 a V1
1160530 | 4 a V1
1160629 | 4 a V1
1160631 | 4 a V1
1160684 | 4 a V1
1160686 | 4 a V1
1160690 | 4 a V1
1160692 | 4 a V1
1160865 | 4 a V1
1160867 | 4 a V1
1160873 | 4 a V1
1160875 | 4 a V1
1160920 | 4 a V1
1160922 | 4 a V1
1161012 | 4 a V1
1161014 | 4 a V1
1161018 | 4 a V1
1161020 | 4 a V1
1161534 | 4 a V1
1161536 | 4 a V1
1161709 | 4 a V1
1161711 | 4 a V1
1161750 | 5 a V1
1161752 | 5 a V1
1161984 | 5 a V1
1161986 | 5 a V1
1162134 | 4 a V1
1162136 | 4 a V1
1162143 | 5 a V1
1162145 | 5 a V1
1162151 | 5 a V1
1162153 | 5 a V1
1162301 | 0 a
1162303 | 0 a
1162330 | 0 a
1162332 | 0 a
1162509 | 5 a V1
1162511 | 5 a V1
1162562 | 5 a V1
1162564 | 5 a V1
1162714 | 0 a
1162716 | 0 a
1162722 | 5 a V1
1162724 | 5 a V1
1162730 | 5 a V1
1162732 | 5 a V1
1163234 | 4 a V1
1163236 | 4 a V1
1163242 | 4 a V1
1163244 | 4 a V1
1163480 | 4 a V1
1163482 | 4 a V1
1163594 | 4 a V1
1163596 | 4 a V1
1163602 | 4 a V1
1163604 | 4 a V1
1165598 | 4 a V1
1165600 | 4 a V1
1165613 | 4 a V1
1165615 | 4 a V1
1166092 | 4 a V1
1166094 | 4 a V1
1166171 | 4 a V1
1166173 | 4 a V1
1166453 | 4 a V1
1166455 | 4 a V1
1166459 | 4 a V1
1166461 | 4 a V1
1166794 | 4 a V1
1166796 | 4 a V1
1166847 | 4 a V1
1166849 | 4 a V1
1166855 | 4 a V1
1166857 | 4 a V1
1167179 | 4 a V1
1167181 | 4 a V1
1167326 | 4 a V1
1167328 | 4 a V1
1167494 | 4 a V1
1167496 | 4 a V1
1167500 | 4 a V1
1167502 | 4 a V1
1167738 | 4 a V1
1167740 | 4 a V1
1167864 | 4 a V1
1167866 | 4 a V1
1167917 | 4 a V1
1167919 | 4 a V1
1167925 | 4 a V1
1167927 | 4 a V1
1167946 | 4 a V1
1167948 | 4 a V1
1168503 | 4 a V1
1168505 | 4 a V1
1168646 | 4 a V1
1168648 | 4 a V1
1168873 | 4 a V1
1168875 | 4 a V1
1169192 | 5 a V1
1169194 | 5 a V1
1169268 | 4 a V1
1169270 | 4 a V1
1169284 | 5 a V1
1169286 | 5 a V1
1169290 | 5 a V1
1169292 | 5 a V1
1169414 | 5 a V1
1169416 | 5 a V1
1169428 | 4 a V1
1169430 | 4 a V1
1169482 | 4 a V1
1169484 | 4 a V1
1169663 | 4 a V1
1169665 | 4 a V1
1169669 | 4 a V1
1169671 | 4 a V1
1169798 | 4 a V1
1169800 | 4 a V1
1169854 | 4 a V1
1169856 | 4 a V1
1169862 | 4 a V1
1169864 | 4 a V1
1170255 | 4 a V1
1170257 | 4 a V1
1170548 | 4 a V1
1170550 | 4 a V1
1170554 | 4 a V1
1170556 | 4 a V1
1170668 | 4 a V1
1170670 | 4 a V1
1170768 | 4 a V1
1170770 | 4 a V1
1170829 | 4 a V1
1170831 | 4 a V1
1170837 | 4 a V1
1170839 | 4 a V1
1171042 | 4 a V1
1171044 | 4 a V1
1171048 | 4 a V1
1171050 | 4 a V1
1171185 | 4 a V1
1171187 | 4 a V1
1171283 | 4 a V1
1171285 | 4 a V1
1171291 | 4 a V1
1171293 | 4 a V1
1171312 | 4 a V1
1171314 | 4 a V1
1171354 | 4 a V1
1171356 | 4 a V1
1171413 | 4 a V1
1171415 | 4 a V1
1171419 | 4 a V1
1171421 | 4 a V1
1171532 | 4 a V1
1171534 | 4 a V1
1171633 | 4 a V1
1171635 | 4 a V1
1171641 | 4 a V1
1171643 | 4 a V1
1171668 | 4 a V1
1171670 | 4 a V1
1171931 | 4 a V1
1171933 | 4 a V1
1172080 | 4 a V1
1172082 | 4 a V1
1172349 | 4 a V1
1172351 | 4 a V1
1172364 | 4 a V1
1172366 | 4 a V1
1172486 | 4 a V1
1172488 | 4 a V1
1172653 | 4 a V1
1172655 | 4 a V1
1172659 | 4 a V1
1172661 | 4 a V1
1172768 | 4 a V1
1172770 | 4 a V1
1172891 | 4 a V1
1172893 | 4 a V1
1172910 | 4 a V1
1172912 | 4 a V1
1172931 | 4 a V1
1172933 | 4 a V1
1173233 | 4 a V1
1173235 | 4 a V1
1173316 | 4 a V1
1173318 | 4 a V1
1173331 | 4 a V1
1173333 | 4 a V1
1173413 | 4 a V1
1173415 | 4 a V1
1173557 | 4 a V1
1173559 | 4 a V1
1173564 | 4 a V1
1173566 | 4 a V1
1173639 | 4 a V1
1173641 | 4 a V1
1173653 | 4 a V1
1173655 | 4 a V1
1173708 | 4 a V1
1173710 | 4 a V1
1173716 | 4 a V1
1173718 | 4 a V1
1173737 | 4 a V1
1173739 | 4 a V1
1173783 | 4 a V1
1173785 | 4 a V1
1173846 | 4 a V1
1173848 | 4 a V1
1173981 | 4 a V1
1173983 | 4 a V1
1173987 | 4 a V1
1173989 | 4 a V1
1174056 | 4 a V1
1174058 | 4 a V1
1174147 | 4 a V1
1174149 | 4 a V1
1174155 | 4 a V1
1174157 | 4 a V1
1174262 | 4 a V1
1174264 | 4 a V1
1174424 | 4 a V1
1174426 | 4 a V1
1174583 | 4 a V1
1174585 | 4 a V1
1174589 | 4 a V1
1174591 | 4 a V1
1174734 | 4 a V1
1174736 | 4 a V1
1174782 | 4 a V1
1174784 | 4 a V1
1174790 | 4 a V1
1174792 | 4 a V1
1175097 | 4 a V1
1175099 | 4 a V1
1175105 | 4 a V1
1175107 | 4 a V1
1175259 | 4 a V1
1175261 | 4 a V1
1175265 | 4 a V1
1175267 | 4 a V1
1175491 | 0 a
1175493 | 0 a
1175505 | 5 a V1
1175507 | 5 a V1
1175542 | 5 a V1
1175544 | 5 a V1
1175815 | 0 a
1175817 | 0 a
1175862 | 5 a V1
1175864 | 5 a V1
1175900 | 5 a V1
1175902 | 5 a V1
1176014 | 0 a
1176016 | 0 a
1176022 | 4 a V1
1176024 | 4 a V1
1176391 | 4 a V1
1176393 | 4 a V1
1176405 | 5 a V1
1176407 | 5 a V1
1176497 | 5 a V1
1176499 | 5 a V1
1176754 | 5 a V1
1176756 | 5 a V1
1176786 | 5 a V1
1176788 | 5 a V1
1176814 | 4 a V1
1176816 | 4 a V1
1177210 | 4 a V1
1177212 | 4 a V1
1177350 | 4 a V1
1177352 | 4 a V1
1177356 | 4 a V1
1177358 | 4 a V1
1177603 | 4 a V1
1177605 | 4 a V1
1177660 | 4 a V1
1177662 | 4 a V1
1177668 | 4 a V1
1177670 | 4 a V1
1177719 | 4 a V1
1177721 | 4 a V1
1178034 | 4 a V1
1178036 | 4 a V1
1178291 | 4 a V1
1178293 | 4 a V1
1178459 | 4 a V1
1178461 | 4 a V1
1178465 | 4 a V1
1178467 | 4 a V1
1178600 | 4 a V1
1178602 | 4 a V1
1178829 | 4 a V1
1178831 | 4 a V1
1178837 | 4 a V1
1178839 | 4 a V1
1178958 | 4 a V1
1178960 | 4 a V1
1179201 | 4 a V1
1179203 | 4 a V1
1179481 | 4 a V1
1179483 | 4 a V1
1179860 | 4 a V1
1179862 | 4 a V1
1179952 | 4 a V1
1179954 | 4 a V1
1179958 | 4 a V1
1179960 | 4 a V1
1180144 | 4 a V1
1180146 | 4 a V1
1180203 | 4 a V1
1180205 | 4 a V1
1180211 | 4 a V1
1180213 | 4 a V1
1180492 | 4 a V1
1180494 | 4 a V1
1180752 | 4 a V1
1180754 | 4 a V1
1180884 | 4 a V1
1180886 | 4 a V1
1180949 | 4 a V1
1180951 | 4 a V1
1180957 | 4 a V1
1180959 | 4 a V1
1181161 | 4 a V1
1181163 | 4 a V1
1181273 | 4 a V1
1181275 | 4 a V1
1181287 | 5 a V1
1181289 | 5 a V1
1181384 | 5 a V1
1181386 | 5 a V1
1181717 | 5 a V1
1181719 | 5 a V1
1181830 | 5 a V1
1182051 | 4 a V1
1182179 | 4 a V1
1182181 | 4 a V1
1182342 | 4 a V1
1182344 | 4 a V1
1182423 | 0 a
1182425 | 0 a
1182633 | 5 a V1
1182635 | 5 a V1
1182729 | 5 a V1
1182731 | 5 a V1
1183025 | 5 a V1
1183403 | 5 a V1
1183405 | 5 a V1
1183499 | 4 a V1
1183501 | 4 a V1
1183553 | 4 a V1
1183555 | 4 a V1
1183561 | 4 a V1
1183563 | 4 a V1
1183579 | 4 a V1
1183581 | 4 a V1
1183794 | 4 a V1
1183796 | 4 a V1
1184010 | 4 a V1
1184012 | 4 a V1
1184074 | 4 a V1
1184076 | 4 a V1
1184145 | 4 a V1
1184147 | 4 a V1
1184153 | 4 a V1
1184155 | 4 a V1
1184170 | 4 a V1
1184172 | 4 a V1
1184387 | 4 a V1
1184389 | 4 a V1
1185479 | 4 a V1
1185481 | 4 a V1
1185504 | 4 a V1
1185506 | 4 a V1
1185518 | 4 a V1
1185520 | 4 a V1
1185755 | 4 a V1
1185757 | 4 a V1
1185763 | 4 a V1
1185765 | 4 a V1
1186187 | 4 a V1
1186189 | 4 a V1
1186278 | 4 a V1
1186280 | 4 a V1
1186295 | 4 a V1
1186297 | 4 a V1
1186424 | 4 a V1
1186426 | 4 a V1
1186502 | 4 a V1
1186504 | 4 a V1
1186508 | 4 a V1
1186510 | 4 a V1
1186577 | 4 a V1
1186579 | 4 a V1
1186591 | 4 a V1
1186593 | 4 a V1
1186626 | 4 a V1
1186628 | 4 a V1
1186632 | 4 a V1
1186634 | 4 a V1
1186703 | 4 a V1
1186705 | 4 a V1
1186757 | 4 a V1
1186759 | 4 a V1
1186763 | 4 a V1
1186765 | 4 a V1
1186907 | 4 a V1
1186909 | 4 a V1
1186958 | 4 a V1
1186960 | 4 a V1
1186964 | 4 a V1
1186966 | 4 a V1
1187168 | 4 a V1
1187170 | 4 a V1
1187220 | 4 a V1
1187222 | 4 a V1
1187228 | 4 a V1
1187230 | 4 a V1
1187300 | 4 a V1
1187302 | 4 a V1
1187349 | 4 a V1
1187351 | 4 a V1
1187355 | 4 a V1
1187357 | 4 a V1
1187514 | 4 a V1
1187516 | 4 a V1
1187539 | 4 a V1
1187541 | 4 a V1
1187581 | 4 a V1
1187583 | 4 a V1
1187587 | 4 a V1
1187589 | 4 a V1
1187630 | 4 a V1
1187632 | 4 a V1
1187668 | 4 a V1
1187670 | 4 a V1
1187674 | 4 a V1
1187676 | 4 a V1
1187852 | 4 a V1
1187854 | 4 a V1
1187979 | 4 a V1
1187981 | 4 a V1
1188144 | 4 a V1
1188146 | 4 a V1
1188284 | 4 a V1
1188286 | 4 a V1
1188354 | 4 a V1
1188356 | 4 a V1
1188362 | 4 a V1
1188364 | 4 a V1
1188446 | 4 a V1
1188448 | 4 a V1
1188623 | 4 a V1
1188625 | 4 a V1
1188629 | 4 a V1
1188631 | 4 a V1
1188722 | 4 a V1
1188724 | 4 a V1
1188804 | 4 a V1
1188806 | 4 a V1
1188810 | 4 a V1
1188812 | 4 a V1
1188863 | 4 a V1
1188865 | 4 a V1
1188877 | 4 a V1
1188879 | 4 a V1
1188930 | 4 a V1
1188932 | 4 a V1
1188936 | 4 a V1
1188938 | 4 a V1
1189320 | 4 a V1
1189322 | 4 a V1
1189326 | 4 a V1
1189328 | 4 a V1
1189425 | 4 a V1
1189427 | 4 a V1
1189444 | 4 a V1
1189446 | 4 a V1
1189450 | 4 a V1
1189452 | 4 a V1
1189516 | 4 a V1
1189518 | 4 a V1
1189559 | 4 a V1
1189561 | 4 a V1
1189565 | 4 a V1
1189567 | 4 a V1
1189742 | 4 a V1
1189744 | 4 a V1
1189750 | 4 a V1
1189752 | 4 a V1
1189941 | 4 a V1
1189943 | 4 a V1
1190107 | 4 a V1
1190109 | 4 a V1
1190115 | 4 a V1
1190117 | 4 a V1
1190345 | 4 a V1
1190347 | 4 a V1
1190359 | 4 a V1
1190361 | 4 a V1
1190567 | 4 a V1
1190569 | 4 a V1
1190689 | 4 a V1
1190691 | 4 a V1
1190695 | 4 a V1
1190697 | 4 a V1
1190882 | 4 a V1
1190884 | 4 a V1
1190952 | 4 a V1
1190954 | 4 a V1
1191035 | 4 a V1
1191037 | 4 a V1
1191043 | 4 a V1
1191045 | 4 a V1
1191215 | 4 a V1
1191217 | 4 a V1
1191221 | 4 a V1
1191223 | 4 a V1
1191360 | 4 a V1
1191383 | 4 a V1
1191452 | 4 a V1
1191454 | 4 a V1
1191458 | 4 a V1
1191460 | 4 a V1
1191513 | 4 a V1
1191515 | 4 a V1
1191555 | 4 a V1
1191557 | 4 a V1
1191561 | 4 a V1
1191563 | 4 a V1
1191702 | 4 a V1
1191704 | 4 a V1
1191742 | 4 a V1
1191744 | 4 a V1
1191748 | 4 a V1
1191750 | 4 a V1
1191824 | 4 a V1
1191826 | 4 a V1
1191959 | 4 a V1
1191961 | 4 a V1
1191967 | 4 a V1
1191969 | 4 a V1
1192075 | 4 a V1
1192077 | 4 a V1
1192083 | 4 a V1
1192085 | 4 a V1
1192159 | 4 a V1
1192171 | 4 a V1
1192183 | 4 a V1
1192185 | 4 a V1
1192228 | 4 a V1
1192230 | 4 a V1
1192234 | 4 a V1
1192236 | 4 a V1
1192298 | 4 a V1
1192300 | 4 a V1
1192448 | 4 a V1
1192450 | 4 a V1
1192454 | 4 a V1
1192456 | 4 a V1
1192584 | 4 a V1
1192586 | 4 a V1
1192601 | 4 a V1
1192603 | 4 a V1
1192768 | 4 a V1
1192770 | 4 a V1
1192774 | 4 a V1
1192776 | 4 a V1
1193105 | 4 a V1
1193107 | 4 a V1
1193122 | 4 a V1
1193124 | 4 a V1
1193241 | 4 a V1
1193243 | 4 a V1
1193288 | 4 a V1
1193312 | 4 a V1
1193314 | 4 a V1
1193360 | 4 a V1
1193362 | 4 a V1
1193366 | 4 a V1
1193368 | 4 a V1
1193406 | 4 a V1
1193408 | 4 a V1
1193780 | 4 a V1
1193855 | 4 a V1
1193857 | 4 a V1
1193861 | 4 a V1
1193863 | 4 a V1
1193906 | 4 a V1
1193908 | 4 a V1
1193989 | 4 a V1
1193991 | 4 a V1
1193995 | 4 a V1
1193997 | 4 a V1
1194118 | 4 a V1
1194120 | 4 a V1
1194132 | 4 a V1
1194134 | 4 a V1
1194216 | 4 a V1
1194218 | 4 a V1
1194222 | 4 a V1
1194224 | 4 a V1
1194488 | 4 a V1
1194490 | 4 a V1
1194494 | 4 a V1
1194496 | 4 a V1
1194597 | 4 a V1
1194599 | 4 a V1
1194681 | 4 a V1
1194683 | 4 a V1
1194687 | 4 a V1
1194689 | 4 a V1
1194738 | 4 a V1
1194740 | 4 a V1
1194752 | 4 a V1
1194754 | 4 a V1
1194817 | 4 a V1
1194819 | 4 a V1
1194823 | 4 a V1
1194825 | 4 a V1
1194932 | 4 a V1
1194934 | 4 a V1
1194938 | 4 a V1
1194940 | 4 a V1
1195097 | 4 a V1
1195099 | 4 a V1
1195135 | 4 a V1
1195137 | 4 a V1
1195141 | 4 a V1
1195143 | 4 a V1
1195248 | 4 a V1
1195250 | 4 a V1
1195265 | 4 a V1
1195267 | 4 a V1
1195604 | 4 a V1
1195606 | 4 a V1
1195612 | 4 a V1
1195614 | 4 a V1
1195678 | 4 a V1
1195680 | 4 a V1
1195754 | 4 a V1
1195756 | 4 a V1
1195760 | 4 a V1
1195762 | 4 a V1
1196303 | 5 a V1
1196305 | 5 a V1
1196356 | 5 a V1
1196358 | 5 a V1
1196362 | 5 a V1
1196364 | 5 a V1
1196407 | 5 a V1
1196409 | 5 a V1
1196463 | 5 a V1
1196465 | 5 a V1
1196471 | 5 a V1
1196473 | 5 a V1
1196521 | 5 a V1
1196523 | 5 a V1
1196581 | 5 a V1
1196583 | 5 a V1
1196587 | 5 a V1
1196589 | 5 a V1
1196810 | 4 a V1
1196812 | 4 a V1
1196854 | 5 a V1
1196856 | 5 a V1
1196860 | 5 a V1
1196862 | 5 a V1
1196964 | 5 a V1
1196966 | 5 a V1
1197036 | 5 a V1
1197038 | 5 a V1
1197042 | 5 a V1
1197044 | 5 a V1
1197328 | 5 a V1
1197330 | 5 a V1
1197376 | 5 a V1
1197378 | 5 a V1
1197384 | 5 a V1
1197386 | 5 a V1
1197501 | 5 a V1
1197503 | 5 a V1
1197550 | 5 a V1
1197552 | 5 a V1
1197558 | 5 a V1
1197560 | 5 a V1
1197653 | 4 a V1
1197655 | 4 a V1
1197659 | 4 a V1
1197661 | 4 a V1
1197894 | 4 a V1
1197896 | 4 a V1
1198124 | 4 a V1
1198126 | 4 a V1
1198272 | 4 a V1
1198274 | 4 a V1
1198286 | 4 a V1
1198288 | 4 a V1
1198330 | 4 a V1
1198332 | 4 a V1
1198338 | 4 a V1
1198340 | 4 a V1
1198405 | 4 a V1
1198407 | 4 a V1
1198413 | 4 a V1
1198415 | 4 a V1
1198807 | 4 a V1
1198809 | 4 a V1
1198878 | 4 a V1
1198880 | 4 a V1
1198886 | 4 a V1
1198888 | 4 a V1
1199183 | 4 a V1
1199185 | 4 a V1
1199337 | 4 a V1
1199339 | 4 a V1
1199345 | 4 a V1
1199347 | 4 a V1
1199936 | 4 a V1
1199938 | 4 a V1
1199950 | 4 a V1
1199952 | 4 a V1
1199964 | 4 a V1
1199966 | 4 a V1
1200059 | 4 a V1
1200061 | 4 a V1
1200067 | 4 a V1
1200069 | 4 a V1
1200238 | 4 a V1
1200240 | 4 a V1
1200344 | 4 a V1
1200346 | 4 a V1
1200358 | 4 a V1
1200360 | 4 a V1
1200396 | 4 a V1
1200398 | 4 a V1
1200402 | 4 a V1
1200404 | 4 a V1
1200493 | 4 a V1
1200495 | 4 a V1
1200547 | 4 a V1
1200549 | 4 a V1
1200555 | 4 a V1
1200557 | 4 a V1
1200654 | 4 a V1
1200656 | 4 a V1
1200864 | 4 a V1
1200866 | 4 a V1
1200908 | 4 a V1
1200910 | 4 a V1
1200916 | 4 a V1
1200918 | 4 a V1
1201081 | 4 a V1
1201083 | 4 a V1
1201216 | 4 a V1
1201218 | 4 a V1
1201225 | 4 a V1
1201227 | 4 a V1
1201309 | 4 a V1
1201311 | 4 a V1
1201318 | 4 a V1
1201320 | 4 a V1
1201389 | 4 a V1
1201391 | 4 a V1
1201613 | 4 a V1
1201615 | 4 a V1
1201668 | 4 a V1
1201670 | 4 a V1
1201719 | 4 a V1
1201721 | 4 a V1
1201725 | 4 a V1
1201727 | 4 a V1
1201838 | 4 a V1
1201840 | 4 a V1
1201852 | 4 a V1
1201854 | 4 a V1
1201935 | 4 a V1
1201937 | 4 a V1
1201941 | 4 a V1
1201943 | 4 a V1
1202006 | 4 a V1
1202008 | 4 a V1
1202054 | 4 a V1
1202056 | 4 a V1
1202060 | 4 a V1
1202062 | 4 a V1
1202367 | 4 a V1
1202369 | 4 a V1
1202375 | 4 a V1
1202377 | 4 a V1
1202425 | 4 a V1
1202427 | 4 a V1
1202439 | 4 a V1
1202441 | 4 a V1
1202479 | 4 a V1
1202481 | 4 a V1
1202485 | 4 a V1
1202487 | 4 a V1
1202506 | 4 a V1
1202508 | 4 a V1
1202702 | 4 a V1
1202704 | 4 a V1
1202742 | 4 a V1
1202744 | 4 a V1
1202748 | 4 a V1
1202750 | 4 a V1
1202847 | 4 a V1
1202849 | 4 a V1
1202905 | 4 a V1
1202907 | 4 a V1
1203013 | 4 a V1
1203015 | 4 a V1
1203066 | 4 a V1
1203068 | 4 a V1
1203072 | 4 a V1
1203074 | 4 a V1
1203148 | 4 a V1
1203150 | 4 a V1
1203156 | 4 a V1
1203158 | 4 a V1
1203229 | 4 a V1
1203231 | 4 a V1
1203271 | 4 a V1
1203273 | 4 a V1
1203277 | 4 a V1
1203279 | 4 a V1
1203326 | 4 a V1
1203328 | 4 a V1
1203373 | 4 a V1
1203375 | 4 a V1
1203379 | 4 a V1
1203381 | 4 a V1
1203422 | 4 a V1
1203424 | 4 a V1
1203497 | 4 a V1
1203499 | 4 a V1
1203503 | 4 a V1
1203505 | 4 a V1
1203575 | 4 a V1
1203577 | 4 a V1
1203581 | 4 a V1
1203583 | 4 a V1
1203644 | 4 a V1
1203646 | 4 a V1
1203680 | 4 a V1
1203682 | 4 a V1
1203686 | 4 a V1
1203688 | 4 a V1
1203737 | 4 a V1
1203739 | 4 a V1
1203779 | 4 a V1
1203781 | 4 a V1
1203785 | 4 a V1
1203787 | 4 a V1
1203853 | 5 a V1
1203855 | 5 a V1
1203922 | 4 a V1
1203924 | 4 a V1
1203980 | 4 a V1
1203982 | 4 a V1
1204085 | 4 a V1
1204087 | 4 a V1
1204129 | 4 a V1
1204131 | 4 a V1
1204135 | 4 a V1
1204137 | 4 a V1
1204183 | 4 a V1
1204185 | 4 a V1
1204324 | 4 a V1
1204326 | 4 a V1
1204409 | 4 a V1
1204411 | 4 a V1
1204415 | 4 a V1
1204417 | 4 a V1
1204603 | 4 a V1
1204605 | 4 a V1
1204742 | 4 a V1
1204744 | 4 a V1
1204768 | 4 a V1
1204770 | 4 a V1
1204776 | 4 a V1
1204778 | 4 a V1
1204917 | 4 a V1
1204919 | 4 a V1
1204923 | 4 a V1
1204925 | 4 a V1
1204956 | 4 a V1
1204958 | 4 a V1
1205021 | 4 a V1
1205023 | 4 a V1
1205168 | 4 a V1
1205170 | 4 a V1
1205185 | 4 a V1
1205187 | 4 a V1
1205341 | 4 a V1
1205343 | 4 a V1
1205349 | 4 a V1
1205351 | 4 a V1
1205451 | 4 a V1
1205453 | 4 a V1
1205532 | 4 a V1
1205534 | 4 a V1
1205538 | 4 a V1
1205540 | 4 a V1
1205638 | 4 a V1
1205640 | 4 a V1
1205698 | 4 a V1
1205700 | 4 a V1
1205715 | 4 a V1
1205717 | 4 a V1
1205836 | 4 a V1
1205838 | 4 a V1
1205842 | 4 a V1
1205844 | 4 a V1
1206012 | 4 a V1
1206014 | 4 a V1
1206018 | 4 a V1
1206020 | 4 a V1
1206095 | 4 a V1
1206097 | 4 a V1
1206137 | 4 a V1
1206139 | 4 a V1
1206145 | 4 a V1
1206147 | 4 a V1
1206189 | 4 a V1
1206191 | 4 a V1
1206222 | 4 a V1
1206224 | 4 a V1
1206230 | 4 a V1
1206232 | 4 a V1
1206289 | 4 a V1
1206291 | 4 a V1
1206459 | 4 a V1
1206461 | 4 a V1
1206465 | 4 a V1
1206467 | 4 a V1
1206563 | 4 a V1
1206565 | 4 a V1
1206569 | 4 a V1
1206571 | 4 a V1
1206634 | 4 a V1
1206636 | 4 a V1
1206678 | 4 a V1
1206680 | 4 a V1
1206684 | 4 a V1
1206686 | 4 a V1
1206773 | 4 a V1
1206775 | 4 a V1
1206781 | 4 a V1
1206783 | 4 a V1
1206827 | 4 a V1
1206829 | 4 a V1
1206970 | 4 a V1
1206972 | 4 a V1
1206976 | 4 a V1
1206978 | 4 a V1
1207038 | 4 a V1
1207040 | 4 a V1
1207121 | 4 a V1
1207123 | 4 a V1
1207127 | 4 a V1
1207129 | 4 a V1
1208449 | 4 a V1
1208451 | 4 a V1
1209136 | 4 a V1
1209138 | 4 a V1
1209223 | 4 a V1
1209225 | 4 a V1
1209418 | 4 a V1
1209420 | 4 a V1
1209426 | 4 a V1
1209428 | 4 a V1
1209742 | 4 a V1
1209744 | 4 a V1
1209756 | 3 a
1209758 | 3 a
1209831 | 3 a
1209833 | 3 a
1209837 | 3 a
1209839 | 3 a
1210602 | 3 a
1210604 | 3 a
1210608 | 3 a
1210610 | 3 a
1210697 | 3 a
1210699 | 3 a
1210711 | 3 a
1210713 | 3 a
1210771 | 3 a
1210773 | 3 a
1210777 | 3 a
1210779 | 3 a
1210929 | 3 a
1210931 | 3 a
1210982 | 3 a
1210984 | 3 a
1210988 | 3 a
1210990 | 3 a
1211023 | 3 a
1211025 | 3 a
1211096 | 3 a
1211098 | 3 a
1211186 | 3 a
1211188 | 3 a
1211192 | 3 a
1211194 | 3 a
1211225 | 3 a
1211227 | 3 a
1211815 | 3 a
1211817 | 3 a
1211829 | 3 a
1211831 | 3 a
1212104 | 4 a V1
1212106 | 4 a V1
1212217 | 4 a V1
1212219 | 4 a V1
1212249 | 4 a V1
1212251 | 4 a V1
1212337 | 4 a V1
1212339 | 4 a V1
1212973 | 4 a V1
1212975 | 4 a V1
1213011 | 3 a
1213013 | 3 a
1213108 | 3 a
1213110 | 3 a
1213114 | 3 a
1213116 | 3 a
1213302 | 3 a
1213304 | 3 a
1213316 | 3 a
1213318 | 3 a
1213561 | 3 a
1213563 | 3 a
1213567 | 3 a
1213569 | 3 a
1213677 | 3 a
1213679 | 3 a
1213741 | 3 a
1213743 | 3 a
1213811 | 3 a
1213813 | 3 a
1213819 | 3 a
1213821 | 3 a
1213937 | 3 a
1213939 | 3 a
1213951 | 3 a
1213953 | 3 a
1214026 | 3 a
1214028 | 3 a
1214034 | 3 a
1214036 | 3 a
1214301 | 5 a V1
1214303 | 5 a V1
1214364 | 5 a V1
1214366 | 5 a V1
1214427 | 4 a V1
1214429 | 4 a V1
1214487 | 4 a V1
1214489 | 4 a V1
1214669 | 4 a V1
1214671 | 4 a V1
1214699 | 4 a V1
1214701 | 4 a V1
1214721 | 5 a V1
1214723 | 5 a V1
1214729 | 3 a
1214731 | 3 a
1215450 | 4 a V1
1215452 | 4 a V1
1215485 | 4 a V1
1215487 | 4 a V1
1215499 | 4 a V1
1215501 | 4 a V1
1215537 | 4 a V1
1215539 | 4 a V1
1215726 | 4 a V1
1215728 | 4 a V1
1216641 | 4 a V1
1216643 | 4 a V1
1216722 | 4 a V1
1216724 | 4 a V1
1216736 | 3 a
1216738 | 3 a
1216860 | 4 a V1
1216862 | 4 a V1
1216868 | 3 a
1216870 | 3 a
1217157 | 3 a
1217159 | 3 a
1217369 | 3 a
1217371 | 3 a
1217375 | 3 a
1217377 | 3 a
1217448 | 3 a
1217450 | 3 a
1217511 | 3 a
1217513 | 3 a
1217517 | 3 a
1217519 | 3 a
1217538 | 3 a
1217540 | 3 a
1217763 | 3 a
1217765 | 3 a
1217861 | 3 a
1217863 | 3 a
1217867 | 3 a
1217869 | 3 a
1217904 | 4 a V1
1217906 | 4 a V1
1217986 | 2 a
1217988 | 2 a
1218086 | 2 a
1218088 | 2 a
1218185 | 4 a V1
1218187 | 4 a V1
1218280 | 3 a
1218282 | 3 a
1218359 | 3 a
1218361 | 3 a
1218373 | 3 a
1218375 | 3 a
1218419 | 3 a
1218421 | 3 a
1218427 | 3 a
1218429 | 3 a
1218475 | 3 a
1218477 | 3 a
1218489 | 3 a
1218491 | 3 a
1218503 | 3 a
1218505 | 3 a
1218588 | 3 a
1218590 | 3 a
1218594 | 3 a
1218596 | 3 a
1218672 | 3 a
1218674 | 3 a
1218678 | 3 a
1218680 | 3 a
1218699 | 3 a
1218701 | 3 a
1219298 | 3 a
1219300 | 3 a
1219312 | 3 a
1219314 | 3 a
1219367 | 3 a
1219369 | 3 a
1219373 | 3 a
1219375 | 3 a
1219563 | 3 a
1219580 | 3 a
1219763 | 3 a
1219765 | 3 a
1219845 | 3 a
1219847 | 3 a
1219851 | 3 a
1219853 | 3 a
1220052 | 0 a
1220054 | 0 a
1220523 | 0 a
1220525 | 0 a
1220529 | 0 a
1220531 | 0 a
1220598 | 4 a V1
1220600 | 4 a V1
1220965 | 4 a V1
1220967 | 4 a V1
1221112 | 4 a V1
1221114 | 4 a V1
1221232 | 3 a
1221234 | 3 a
1221283 | 3 a
1221285 | 3 a
1221291 | 3 a
1221293 | 3 a
1221638 | 4 a V1
1221640 | 4 a V1
1221767 | 4 a V1
1221769 | 4 a V1
1221787 | 4 a V1
1221789 | 4 a V1
1221795 | 4 a V1
1221797 | 4 a V1
1221898 | 5 a V1
1221900 | 5 a V1
1221959 | 5 a V1
1221961 | 5 a V1
1222036 | 4 a V1
1222038 | 4 a V1
1222144 | 5 a V1
1222146 | 5 a V1
1222809 | 4 a V1
1222837 | 4 a V1
1222839 | 4 a V1
1222916 | 3 a
1222918 | 3 a
1222996 | 3 a
1222998 | 3 a
1223002 | 3 a
1223004 | 3 a
1223127 | 3 a
1223129 | 3 a
1223139 | 3 a
1223141 | 3 a
1223325 | 3 a
1223327 | 3 a
1223339 | 3 a
1223341 | 3 a
1223434 | 3 a
1223436 | 3 a
1223440 | 3 a
1223442 | 3 a
1223494 | 3 a
1223496 | 3 a
1223602 | 3 a
1223604 | 3 a
1223619 | 3 a
1223621 | 3 a
1223917 | 3 a
1223919 | 3 a
1223923 | 3 a
1223925 | 3 a
1224046 | 3 a
1224048 | 3 a
1224060 | 3 a
1224062 | 3 a
1224146 | 3 a
1224148 | 3 a
1224218 | 3 a
1224220 | 3 a
1224224 | 3 a
1224226 | 3 a
1224343 | 3 a
1224345 | 3 a
1224357 | 3 a
1224359 | 3 a
1224402 | 3 a
1224404 | 3 a
1224410 | 3 a
1224412 | 3 a
1224462 | 3 a
1224464 | 3 a
1224505 | 3 a
1224507 | 3 a
1224513 | 3 a
1224515 | 3 a
1224535 | 3 a
1224537 | 3 a
1224800 | 3 a
1224802 | 3 a
1225177 | 3 a
1225179 | 3 a
1225185 | 3 a
1225187 | 3 a
1225222 | 3 a
1225224 | 3 a
1225333 | 3 a
1225335 | 3 a
1225347 | 3 a
1225349 | 3 a
1225432 | 3 a
1225434 | 3 a
1225440 | 3 a
1225442 | 3 a
1225608 | 3 a
1225610 | 3 a
1225708 | 3 a
1225710 | 3 a
1225755 | 3 a
1225757 | 3 a
1225763 | 3 a
1225765 | 3 a
1225810 | 3 a
1225812 | 3 a
1225824 | 3 a
1225826 | 3 a
1225894 | 3 a
1225896 | 3 a
1225902 | 3 a
1225904 | 3 a
1226526 | 4 a V1
1226528 | 4 a V1
1226540 | 4 a V1
1226542 | 4 a V1
1226576 | 4 a V1
1226578 | 4 a V1
1226975 | 4 a V1
1226977 | 4 a V1
1227120 | 4 a V1
1227122 | 4 a V1
1227295 | 4 a V1
1227297 | 4 a V1
1227455 | 2 a
1227457 | 2 a
1227518 | 2 a
1227520 | 2 a
1227548 | 2 a
1227550 | 2 a
1227562 | 3 a
1227564 | 3 a
1227678 | 3 a
1227680 | 3 a
1227686 | 3 a
1227688 | 3 a
1228018 | 4 a V1
1228020 | 4 a V1
1228076 | 3 a
1228078 | 3 a
1228251 | 3 a
1228253 | 3 a
1228259 | 3 a
1228261 | 3 a
1228281 | 3 a
1228283 | 3 a
1228411 | 3 a
1228413 | 3 a
1228419 | 3 a
1228421 | 3 a
1228443 | 3 a
1228445 | 3 a
1228497 | 3 a
1228499 | 3 a
1228552 | 3 a
1228554 | 3 a
1228560 | 3 a
1228562 | 3 a
1228581 | 3 a
1228583 | 3 a
1228631 | 3 a
1228633 | 3 a
1228687 | 3 a
1228689 | 3 a
1228695 | 3 a
1228697 | 3 a
1228861 | 4 a V1
1228863 | 4 a V1
1228941 | 3 a
1228943 | 3 a
1229026 | 3 a
1229028 | 3 a
1229097 | 3 a
1229099 | 3 a
1229103 | 3 a
1229105 | 3 a
1229426 | 3 a
1229428 | 3 a
1229443 | 3 a
1229445 | 3 a
1229547 | 3 a
1229549 | 3 a
1229555 | 3 a
1229557 | 3 a
1229669 | 4 a V1
1229671 | 4 a V1
1229683 | 3 a
1229685 | 3 a
1229736 | 3 a
1229738 | 3 a
1229744 | 3 a
1229746 | 3 a
1230089 | 3 a
1230091 | 3 a
1230306 | 3 a
1230308 | 3 a
1230373 | 3 a
1230375 | 3 a
1230381 | 3 a
1230383 | 3 a
1230905 | 3 a
1230907 | 3 a
1231005 | 3 a
1231007 | 3 a
1231011 | 3 a
1231013 | 3 a
1231096 | 3 a
1231098 | 3 a
1231150 | 3 a
1231152 | 3 a
1231156 | 3 a
1231158 | 3 a
1231365 | 3 a
1231367 | 3 a
1231379 | 3 a
1231381 | 3 a
1231426 | 3 a
1231428 | 3 a
1231432 | 3 a
1231434 | 3 a
1231499 | 3 a
1231501 | 3 a
1231655 | 3 a
1231657 | 3 a
1231708 | 3 a
1231710 | 3 a
1231836 | 3 a
1231838 | 3 a
1231948 | 3 a
1231950 | 3 a
1231998 | 3 a
1232000 | 3 a
1232004 | 3 a
1232006 | 3 a
1232035 | 3 a
1232037 | 3 a
1232092 | 3 a
1232094 | 3 a
1232138 | 3 a
1232140 | 3 a
1232144 | 3 a
1232146 | 3 a
1232276 | 3 a
1232278 | 3 a
1232359 | 3 a
1232361 | 3 a
1232365 | 3 a
1232367 | 3 a
1232407 | 3 a
1232409 | 3 a
1232455 | 3 a
1232457 | 3 a
1232583 | 3 a
1232585 | 3 a
1232597 | 3 a
1232599 | 3 a
1232669 | 3 a
1232671 | 3 a
1232784 | 3 a
1232786 | 3 a
1232908 | 3 a
1232910 | 3 a
1232964 | 3 a
1232966 | 3 a
1232972 | 3 a
1232974 | 3 a
1233241 | 3 a
1233243 | 3 a
1233298 | 3 a
1233300 | 3 a
1233319 | 3 a
1233321 | 3 a
1233391 | 3 a
1233393 | 3 a
1233815 | 4 a V1
1233817 | 4 a V1
1233947 | 3 a
1233949 | 3 a
1234246 | 3 a
1234248 | 3 a
1234252 | 3 a
1234254 | 3 a
1234484 | 3 a
1234486 | 3 a
1234501 | 3 a
1234503 | 3 a
1234658 | 3 a
1234660 | 3 a
1234705 | 3 a
1234707 | 3 a
1234711 | 3 a
1234713 | 3 a
1234802 | 3 a
1234804 | 3 a
1235317 | 3 a
1235319 | 3 a
1235358 | 3 a
1235360 | 3 a
1235726 | 3 a
1235728 | 3 a
1235852 | 3 a
1235854 | 3 a
1235952 | 3 a
1235954 | 3 a
1236077 | 3 a
1236079 | 3 a
1236083 | 3 a
1236085 | 3 a
1236113 | 3 a
1236115 | 3 a
1236185 | 3 a
1236187 | 3 a
1236286 | 3 a
1236288 | 3 a
1236292 | 3 a
1236294 | 3 a
1236392 | 3 a
1236394 | 3 a
1236440 | 3 a
1236442 | 3 a
1236454 | 3 a
1236456 | 3 a
1236506 | 3 a
1236508 | 3 a
1236582 | 3 a
1236584 | 3 a
1236606 | 3 a
1236608 | 3 a
1237056 | 3 a
1237058 | 3 a
1237316 | 3 a
1237318 | 3 a
1237330 | 3 a
1237332 | 3 a
1237419 | 3 a
1237421 | 3 a
1237455 | 3 a
1237457 | 3 a
1237542 | 3 a
1237544 | 3 a
1237548 | 3 a
1237550 | 3 a
1237674 | 3 a
1237676 | 3 a
1237680 | 3 a
1237682 | 3 a
1237975 | 3 a
1237977 | 3 a
1238181 | 3 a
1238183 | 3 a
1238522 | 3 a
1238524 | 3 a
1238602 | 3 a
1238604 | 3 a
1238608 | 3 a
1238610 | 3 a
1238737 | 3 a
1238739 | 3 a
1238824 | 3 a
1238826 | 3 a
1238976 | 3 a
1238978 | 3 a
1239062 | 3 a
1239064 | 3 a
1239108 | 3 a
1239110 | 3 a
1239114 | 3 a
1239116 | 3 a
1239185 | 3 a
1239187 | 3 a
1239254 | 3 a
1239256 | 3 a
1239260 | 3 a
1239262 | 3 a
1239303 | 3 a
1239305 | 3 a
1239350 | 3 a
1239352 | 3 a
1239392 | 3 a
1239394 | 3 a
1239398 | 3 a
1239400 | 3 a
1239521 | 3 a
1239523 | 3 a
1239598 | 3 a
1239600 | 3 a
1239604 | 3 a
1239606 | 3 a
1239690 | 3 a
1239692 | 3 a
1239833 | 3 a
1239835 | 3 a
1239839 | 3 a
1239841 | 3 a
1240169 | 3 a
1240171 | 3 a
1240247 | 3 a
1240249 | 3 a
1240253 | 3 a
1240255 | 3 a
1240281 | 3 a
1240283 | 3 a
1240394 | 3 a
1240396 | 3 a
1240419 | 3 a
1240421 | 3 a
1240464 | 3 a
1240466 | 3 a
1240470 | 3 a
1240472 | 3 a
1241094 | 4 a V1
1241096 | 4 a V1
1241195 | 2 a
1241197 | 2 a
1241299 | 2 a
1241301 | 2 a
1241307 | 2 a
1241309 | 2 a
1241412 | 2 a
1241414 | 2 a
1241470 | 2 a
1241472 | 2 a
1241476 | 2 a
1241478 | 2 a
1241624 | 2 a
1241626 | 2 a
1241630 | 2 a
1241632 | 2 a
1241722 | 2 a
1241724 | 2 a
1241728 | 2 a
1241730 | 2 a
1241825 | 2 a
1241827 | 2 a
1241878 | 2 a
1241880 | 2 a
1241884 | 2 a
1241886 | 2 a
1241952 | 2 a
1241954 | 2 a
1241960 | 2 a
1241962 | 2 a
1242194 | 2 a
1242196 | 2 a
1242320 | 2 a
1242322 | 2 a
1242326 | 2 a
1242328 | 2 a
1242372 | 2 a
1242374 | 2 a
1242411 | 2 a
1242413 | 2 a
1242417 | 2 a
1242419 | 2 a
1242463 | 2 a
1242465 | 2 a
1242509 | 2 a
1242511 | 2 a
1242517 | 2 a
1242519 | 2 a
1242563 | 2 a
1242565 | 2 a
1242577 | 2 a
1242579 | 2 a
1242657 | 2 a
1242659 | 2 a
1242665 | 2 a
1242667 | 2 a
1242952 | 2 a
1242954 | 2 a
1242960 | 2 a
1242962 | 2 a
1243789 | 4 a V1
1243791 | 4 a V1
1243804 | 4 a V1
1243806 | 4 a V1
1243951 | 2 a
1243953 | 2 a
1244007 | 1 a +-152.84
1244009 | 1 a +-152.84
1244021 | 1 a +-152.84
1244023 | 1 a +-152.84
1244050 | 1 a +-152.84
1244052 | 1 a +-152.84
1244064 | 2 a
1244066 | 2 a
1244078 | 2 a
1244080 | 2 a
1244121 | 2 a
1244123 | 2 a
1244129 | 2 a
1244131 | 2 a
1244215 | 2 a
1244217 | 2 a
1244293 | 2 a
1244295 | 2 a
1244453 | 2 a
1244455 | 2 a
1244461 | 2 a
1244463 | 2 a
1244816 | 2 a
1244818 | 2 a
1244824 | 2 a
1244826 | 2 a
1245007 | 2 a
1245009 | 2 a
1245216 | 2 a
1245218 | 2 a
1245256 | 2 a
1245258 | 2 a
1245264 | 2 a
1245266 | 2 a
1245595 | 2 a
1245597 | 2 a
1245601 | 2 a
1245603 | 2 a
1245807 | 2 a
1245809 | 2 a
1245824 | 2 a
1245826 | 2 a
1246011 | 2 a
1246013 | 2 a
1246028 | 2 a
1246030 | 2 a
1246129 | 2 a
1246131 | 2 a
1246238 | 2 a
1246240 | 2 a
1246452 | 2 a
1246454 | 2 a
1246606 | 2 a
1246608 | 2 a
1246614 | 2 a
1246616 | 2 a
1246792 | 2 a
1246794 | 2 a
1246806 | 2 a
1246808 | 2 a
1246863 | 2 a
1246865 | 2 a
1246871 | 2 a
1246873 | 2 a
1247164 | 2 a
1247166 | 2 a
1247255 | 2 a
1247257 | 2 a
1247263 | 2 a
1247265 | 2 a
1247434 | 2 a
1247436 | 2 a
1247453 | 2 a
1247455 | 2 a
1247726 | 2 a
1247728 | 2 a
1247738 | 2 a
1247740 | 2 a
1247845 | 2 a
1247847 | 2 a
1247982 | 2 a
1247984 | 2 a
1248154 | 2 a
1248156 | 2 a
1248160 | 2 a
1248162 | 2 a
1248208 | 2 a
1248210 | 2 a
1248256 | 2 a
1248258 | 2 a
1248264 | 2 a
1248266 | 2 a
1248317 | 2 a
1248319 | 2 a
1248363 | 2 a
1248365 | 2 a
1248371 | 2 a
1248373 | 2 a
1248526 | 2 a
1248528 | 2 a
1248532 | 2 a
1248534 | 2 a
1248674 | 2 a
1248676 | 2 a
1248682 | 2 a
1248684 | 2 a
1248784 | 2 a
1248786 | 2 a
1248847 | 2 a
1248849 | 2 a
1248855 | 2 a
1248857 | 2 a
1249003 | 2 a
1249005 | 2 a
1249059 | 2 a
1249061 | 2 a
1249073 | 2 a
1249075 | 2 a
1249223 | 2 a
1249225 | 2 a
1249229 | 2 a
1249231 | 2 a
1249515 | 2 a
1249517 | 2 a
1249560 | 2 a
1249562 | 2 a
1249568 | 2 a
1249570 | 2 a
1249612 | 2 a
1249614 | 2 a
1249660 | 2 a
1249662 | 2 a
1249666 | 2 a
1249668 | 2 a
1249760 | 2 a
1249762 | 2 a
1249780 | 2 a
1249782 | 2 a
1249934 | 4 a V1
1249936 | 4 a V1
1249948 | 2 a
1249950 | 2 a
1249994 | 2 a
1249996 | 2 a
1250000 | 2 a
1250002 | 2 a
1250103 | 2 a
1250109 | 2 a
1250161 | 2 a
1250163 | 2 a
1250167 | 2 a
1250169 | 2 a
1250272 | 2 a
1250274 | 2 a
1250280 | 2 a
1250282 | 2 a
1250318 | 2 a
1250320 | 2 a
1250368 | 4 a V1
1250370 | 4 a V1
1250435 | 4 a V1
1250437 | 4 a V1
1250780 | 4 a V1
1250782 | 4 a V1
1250794 | 2 a
1250796 | 2 a
1250849 | 2 a
1250851 | 2 a
1250857 | 2 a
1250859 | 2 a
1250898 | 2 a
1250900 | 2 a
1251004 | 4 a V1
1251006 | 4 a V1
1251051 | 2 a
1251053 | 2 a
1251102 | 2 a
1251104 | 2 a
1251108 | 2 a
1251110 | 2 a
1251210 | 2 a
1251212 | 2 a
1251217 | 2 a
1251219 | 2 a
1251328 | 2 a
1251330 | 2 a
1251383 | 2 a
1251385 | 2 a
1251391 | 2 a
1251393 | 2 a
1251443 | 2 a
1251445 | 2 a
1251491 | 2 a
1251493 | 2 a
1251499 | 2 a
1251501 | 2 a
1251641 | 2 a
1251643 | 2 a
1251660 | 2 a
1251662 | 2 a
1251864 | 2 a
1251866 | 2 a
1251933 | 2 a
1251935 | 2 a
1251976 | 2 a
1251978 | 2 a
1252061 | 2 a
1252063 | 2 a
1252145 | 2 a
1252147 | 2 a
1252153 | 2 a
1252155 | 2 a
1252225 | 2 a
1252227 | 2 a
1252280 | 2 a
1252282 | 2 a
1252288 | 2 a
1252290 | 2 a
1252368 | 4 a V1
1252370 | 4 a V1
1252451 | 2 a
1252453 | 2 a
1252459 | 2 a
1252461 | 2 a
1253196 | 2 a
1253198 | 2 a
1253277 | 2 a
1253279 | 2 a
1253372 | 2 a
1253374 | 2 a
1253378 | 2 a
1253380 | 2 a
1253426 | 2 a
1253428 | 2 a
1253478 | 2 a
1253480 | 2 a
1253492 | 2 a
1253494 | 2 a
1253570 | 2 a
1253572 | 2 a
1253578 | 2 a
1253580 | 2 a
1253605 | 2 a
1253607 | 2 a
1253663 | 2 a
1253665 | 2 a
1253677 | 2 a
1253679 | 2 a
1253714 | 2 a
1253716 | 2 a
1253722 | 2 a
1253724 | 2 a
1253768 | 2 a
1253774 | 2 a
1253786 | 2 a
1253788 | 2 a
1253838 | 2 a
1253840 | 2 a
1253846 | 2 a
1253848 | 2 a
1253955 | 4 a V1
1253957 | 4 a V1
1254020 | 2 a
1254022 | 2 a
1254160 | 2 a
1254162 | 2 a
1254214 | 2 a
1254216 | 2 a
1254374 | 2 a
1254376 | 2 a
1254382 | 2 a
1254384 | 2 a
1254424 | 2 a
1254426 | 2 a
1254506 | 2 a
1254508 | 2 a
1254514 | 2 a
1254516 | 2 a
1254752 | 2 a
1254754 | 2 a
1254805 | 2 a
1254807 | 2 a
1254877 | 2 a
1254879 | 2 a
1254885 | 2 a
1254887 | 2 a
1255035 | 2 a
1255037 | 2 a
1255041 | 2 a
1255043 | 2 a
1255083 | 2 a
1255085 | 2 a
1255263 | 2 a
1255265 | 2 a
1255269 | 2 a
1255271 | 2 a
1255388 | 2 a
1255390 | 2 a
1255443 | 2 a
1255445 | 2 a
1255449 | 2 a
1255451 | 2 a
1255817 | 2 a
1255819 | 2 a
1255991 | 2 a
1255993 | 2 a
1256115 | 2 a
1256117 | 2 a
1256198 | 2 a
1256200 | 2 a
1256204 | 2 a
1256206 | 2 a
1256340 | 2 a
1256342 | 2 a
1256623 | 4 a V1
1256625 | 4 a V1
1256770 | 2 a
1256772 | 2 a
1256866 | 2 a
1256868 | 2 a
1256878 | 2 a
1256880 | 2 a
1257144 | 2 a
1257146 | 2 a
1257150 | 2 a
1257152 | 2 a
1257244 | 2 a
1257246 | 2 a
1257256 | 2 a
1257258 | 2 a
1257981 | 2 a
1257983 | 2 a
1257987 | 2 a
1257989 | 2 a
1258101 | 2 a
1258103 | 2 a
1258110 | 2 a
1258112 | 2 a
1258250 | 2 a
1258252 | 2 a
1258258 | 2 a
1258260 | 2 a
1258460 | 2 a
1258462 | 2 a
1258468 | 2 a
1258470 | 2 a
1258555 | 2 a
1258557 | 2 a
1258563 | 2 a
1258565 | 2 a
1258636 | 2 a
1258638 | 2 a
1258690 | 2 a
1258692 | 2 a
1258698 | 2 a
1258700 | 2 a
1258749 | 2 a
1258800 | 2 a
1258802 | 2 a
1258806 | 2 a
1258808 | 2 a
1258863 | 2 a
1258927 | 2 a
1258929 | 2 a
1258933 | 2 a
1258935 | 2 a
1259240 | 2 a
1259252 | 2 a
1259254 | 2 a
1259304 | 2 a
1259306 | 2 a
1259381 | 2 a
1259383 | 2 a
1259817 | 2 a
1259819 | 2 a
1259873 | 2 a
1259875 | 2 a
1260112 | 2 a
1260114 | 2 a
1260685 | 2 a
1260687 | 2 a
1260772 | 2 a
1260774 | 2 a
1260983 | 2 a
1260985 | 2 a
1260989 | 2 a
1260991 | 2 a
1261040 | 2 a
1261042 | 2 a
1261079 | 2 a
1261081 | 2 a
1261142 | 2 a
1261144 | 2 a
1261170 | 2 a
1261172 | 2 a
1261236 | 2 a
1261238 | 2 a
1261244 | 2 a
1261246 | 2 a
1261428 | 2 a
1261430 | 2 a
1261484 | 2 a
1261486 | 2 a
1261577 | 2 a
1261579 | 2 a
1261585 | 2 a
1261587 | 2 a
1261965 | 2 a
1261967 | 2 a
1262026 | 2 a
1262033 | 2 a
1262045 | 2 a
1262047 | 2 a
1262092 | 2 a
1262094 | 2 a
1262098 | 2 a
1262100 | 2 a
1262949 | 2 a
1262951 | 2 a
1262957 | 2 a
1262959 | 2 a
1263072 | 2 a
1263074 | 2 a
1263131 | 2 a
1263133 | 2 a
1263137 | 2 a
1263139 | 2 a
1263269 | 2 a
1263271 | 2 a
1263317 | 2 a
1263319 | 2 a
1263323 | 2 a
1263325 | 2 a
1263441 | 2 a
1263443 | 2 a
1263453 | 2 a
1263455 | 2 a
1264153 | 2 a
1264155 | 2 a
1264159 | 2 a
1264161 | 2 a
1264187 | 2 a
1264189 | 2 a
1264319 | 2 a
1264321 | 2 a
1264489 | 2 a
1264491 | 2 a
1264501 | 2 a
1264503 | 2 a
1264640 | 2 a
1264642 | 2 a
1264714 | 2 a
1264716 | 2 a
1264726 | 2 a
1264728 | 2 a
1265118 | 2 a
1265120 | 2 a
1265353 | 2 a
1265355 | 2 a
1265711 | 2 a
1265713 | 2 a
1265717 | 2 a
1265719 | 2 a
1265900 | 2 a
1265902 | 2 a
1265981 | 2 a
1265983 | 2 a
1265987 | 2 a
1265989 | 2 a
1266183 | 2 a
1266185 | 2 a
1266202 | 2 a
1266204 | 2 a
1266277 | 2 a
1266279 | 2 a
1266291 | 2 a
1266293 | 2 a
1266371 | 2 a
1266373 | 2 a
1266377 | 2 a
1266379 | 2 a
1266674 | 2 a
1266676 | 2 a
1266680 | 2 a
1266682 | 2 a
1267032 | 2 a
1267034 | 2 a
1267086 | 2 a
1267088 | 2 a
1267098 | 2 a
1267100 | 2 a
1267169 | 2 a
1267171 | 2 a
1267175 | 2 a
1267177 | 2 a
1267225 | 2 a
1267227 | 2 a
1267452 | 2 a
1267454 | 2 a
1267505 | 2 a
1267507 | 2 a
1267642 | 2 a
1267644 | 2 a
1267650 | 2 a
1267652 | 2 a
1267826 | 2 a
1267828 | 2 a
1268022 | 2 a
1268024 | 2 a
1268086 | 2 a
1268088 | 2 a
1268092 | 2 a
1268094 | 2 a
1268186 | 2 a
1268188 | 2 a
1268192 | 2 a
1268194 | 2 a
1268328 | 2 a
1268330 | 2 a
1268334 | 2 a
1268336 | 2 a
1268455 | 2 a
1268457 | 2 a
1268463 | 2 a
1268465 | 2 a
1268602 | 2 a
1268604 | 2 a
1268678 | 2 a
1268680 | 2 a
1268947 | 2 a
1268949 | 2 a
1269010 | 2 a
1269012 | 2 a
1269169 | 2 a
1269171 | 2 a
1269224 | 2 a
1269226 | 2 a
1269310 | 2 a
1269312 | 2 a
1269539 | 2 a
1269541 | 2 a
1269545 | 2 a
1269547 | 2 a
1269707 | 2 a
1269709 | 2 a
1270080 | 2 a
1270082 | 2 a
1270094 | 2 a
1270096 | 2 a
1270139 | 2 a
1270141 | 2 a
1270147 | 2 a
1270149 | 2 a
1270324 | 2 a
1270326 | 2 a
1270498 | 2 a
1270500 | 2 a
1270504 | 2 a
1270506 | 2 a
1270577 | 2 a
1270579 | 2 a
1270643 | 2 a
1270645 | 2 a
1270651 | 2 a
1270653 | 2 a
1270744 | 2 a
1270746 | 2 a
1270750 | 2 a
1270752 | 2 a
1271003 | 2 a
1271005 | 2 a
1271043 | 2 a
1271045 | 2 a
1271049 | 2 a
1271051 | 2 a
1271829 | 2 a
1271831 | 2 a
1271981 | 2 a
1271983 | 2 a
1272100 | 2 a
1272102 | 2 a
1272140 | 2 a
1272142 | 2 a
1272299 | 2 a
1272301 | 2 a
1272316 | 2 a
1272318 | 2 a
1272357 | 2 a
1272359 | 2 a
1272456 | 2 a
1272458 | 2 a
1272575 | 2 a
1272577 | 2 a
1272879 | 2 a
1272881 | 2 a
1272983 | 2 a
1272985 | 2 a
1272997 | 2 a
1272999 | 2 a
1273044 | 2 a
1273046 | 2 a
1273052 | 2 a
1273054 | 2 a
1273153 | 2 a
1273155 | 2 a
1273214 | 2 a
1273216 | 2 a
1273228 | 2 a
1273230 | 2 a
1273279 | 2 a
1273281 | 2 a
1273287 | 2 a
1273289 | 2 a
1273413 | 2 a
1273415 | 2 a
1273419 | 2 a
1273421 | 2 a
1273494 | 2 a
1273496 | 2 a
1273568 | 2 a
1273570 | 2 a
1273574 | 2 a
1273576 | 2 a
1273861 | 2 a
1273863 | 2 a
1273869 | 2 a
1273871 | 2 a
1274021 | 2 a
1274023 | 2 a
1274260 | 2 a
1274262 | 2 a
1274381 | 2 a
1274383 | 2 a
1274393 | 2 a
1274395 | 2 a
1274932 | 2 a
1274934 | 2 a
1274938 | 2 a
1274940 | 2 a
1275219 | 2 a
1275221 | 2 a
1275231 | 2 a
1275233 | 2 a
1275325 | 2 a
1275327 | 2 a
1275337 | 2 a
1275339 | 2 a
1275486 | 2 a
1275488 | 2 a
1275492 | 2 a
1275494 | 2 a
1275669 | 2 a
1275671 | 2 a
1275683 | 2 a
1275685 | 2 a
1275697 | 2 a
1275699 | 2 a
1275736 | 2 a
1275738 | 2 a
1275744 | 2 a
1275746 | 2 a
1276001 | 2 a
1276003 | 2 a
1276078 | 2 a
1276080 | 2 a
1276142 | 2 a
1276144 | 2 a
1276737 | 2 a
1276739 | 2 a
1276751 | 2 a
1276753 | 2 a
1277465 | 2 a
1277467 | 2 a
1277573 | 2 a
1277575 | 2 a
1277697 | 2 a
1277699 | 2 a
1277705 | 2 a
1277707 | 2 a
1277899 | 2 a
1277901 | 2 a
1277942 | 2 a
1277944 | 2 a
1277948 | 2 a
1277950 | 2 a
1278001 | 2 a
1278003 | 2 a
1278126 | 2 a
1278128 | 2 a
1278199 | 2 a
1278201 | 2 a
1278279 | 2 a
1278281 | 2 a
1278416 | 2 a
1278418 | 2 a
1278472 | 2 a
1278474 | 2 a
1278478 | 2 a
1278480 | 2 a
1278501 | 2 a
1278503 | 2 a
1278548 | 2 a
1278550 | 2 a
1278659 | 2 a
1278661 | 2 a
1279299 | 2 a
1279301 | 2 a
1279386 | 2 a
1279388 | 2 a
1279448 | 2 a
1279450 | 2 a
1279454 | 2 a
1279456 | 2 a
1279675 | 2 a
1279677 | 2 a
1279749 | 2 a
1279751 | 2 a
1279755 | 2 a
1279757 | 2 a
1281252 | 2 a
1281254 | 2 a
1281583 | 2 a
1281585 | 2 a
1282166 | 2 a
1282168 | 2 a
1282241 | 2 a
1282243 | 2 a
1282278 | 3 a
1282280 | 3 a
1282284 | 2 a
1282286 | 2 a
1282466 | 2 a
1282468 | 2 a
1282492 | 2 a
1282494 | 2 a
1282522 | 2 a
1282524 | 2 a
1282565 | 2 a
1282567 | 2 a
1282681 | 2 a
1282683 | 2 a
1282702 | 2 a
1282704 | 2 a
1283229 | 2 a
1283231 | 2 a
1283306 | 2 a
1283308 | 2 a
1283352 | 2 a
1283354 | 2 a
1283358 | 2 a
1283360 | 2 a
1283405 | 2 a
1283407 | 2 a
1283506 | 2 a
1283508 | 2 a
1283620 | 2 a
1283622 | 2 a
1283716 | 2 a
1283718 | 2 a
1283771 | 2 a
1283773 | 2 a
1283777 | 2 a
1283779 | 2 a
1283818 | 2 a
1283820 | 2 a
1283881 | 2 a
1283883 | 2 a
1284081 | 2 a
1284083 | 2 a
1284087 | 2 a
1284089 | 2 a
1284158 | 2 a
1284160 | 2 a
1284194 | 2 a
1284196 | 2 a
1284263 | 2 a
1284265 | 2 a
1284280 | 2 a
1284282 | 2 a
1284386 | 2 a
1284388 | 2 a
1284677 | 2 a
1284679 | 2 a
1284833 | 2 a
1284835 | 2 a
1284885 | 2 a
1284887 | 2 a
1284893 | 2 a
1284895 | 2 a
1285294 | 2 a
1285296 | 2 a
1285419 | 2 a
1285421 | 2 a
1285459 | 2 a
1285461 | 2 a
1285703 | 2 a
1285705 | 2 a
1285720 | 2 a
1285722 | 2 a
1285801 | 2 a
1285803 | 2 a
1285864 | 2 a
1285866 | 2 a
1285889 | 2 a
1285891 | 2 a
1286041 | 2 a
1286043 | 2 a
1286067 | 2 a
1286069 | 2 a
1286087 | 2 a
1286089 | 2 a
1286130 | 2 a
1286132 | 2 a
1286156 | 2 a
1286158 | 2 a
1286176 | 2 a
1286178 | 2 a
1286380 | 2 a
1286382 | 2 a
1286446 | 1 a +-152.84
1286448 | 1 a +-152.84
1286740 | 2 a
1286742 | 2 a
1286841 | 2 a
1286843 | 2 a
1286847 | 2 a
1286849 | 2 a
1287008 | 2 a
1287010 | 2 a
1287016 | 2 a
1287018 | 2 a
1287237 | 2 a
1287239 | 2 a
1287276 | 2 a
1287278 | 2 a
1287284 | 2 a
1287286 | 2 a
1287433 | 2 a
1287435 | 2 a
1287441 | 2 a
1287443 | 2 a
1287506 | 2 a
1287508 | 2 a
1287520 | 2 a
1287522 | 2 a
1287809 | 2 a
1287811 | 2 a
1287815 | 2 a
1287817 | 2 a
1288064 | 2 a
1288066 | 2 a
1288083 | 2 a
1288085 | 2 a
1288250 | 2 a
1288252 | 2 a
1288306 | 2 a
1288308 | 2 a
1288312 | 2 a
1288314 | 2 a
1288832 | 4 a V1
1288834 | 4 a V1
1288874 | 4 a V1
1288876 | 4 a V1
1288961 | 3 a
1288963 | 3 a
1289839 | 3 a
1289841 | 3 a
1289853 | 3 a
1289855 | 3 a
1290152 | 3 a
1290154 | 3 a
1290201 | 3 a
1290203 | 3 a
1290253 | 2 a
1290255 | 2 a
1291794 | 2 a
1291796 | 2 a
1291874 | 2 a
1291876 | 2 a
1291880 | 2 a
1291882 | 2 a
1291960 | 2 a
1291962 | 2 a
1292039 | 2 a
1292041 | 2 a
1292045 | 2 a
1292047 | 2 a
1292085 | 2 a
1292087 | 2 a
1292250 | 2 a
1292252 | 2 a
1292306 | 2 a
1292308 | 2 a
1292457 | 2 a
1292459 | 2 a
1292463 | 2 a
1292465 | 2 a
1292535 | 2 a
1292537 | 2 a
1292541 | 2 a
1292543 | 2 a
1292703 | 2 a
1292705 | 2 a
1292858 | 2 a
1292860 | 2 a
1293059 | 2 a
1293061 | 2 a
1293143 | 2 a
1293145 | 2 a
1293151 | 2 a
1293153 | 2 a
1293235 | 2 a
1293237 | 2 a
1293272 | 2 a
1293274 | 2 a
1293280 | 2 a
1293282 | 2 a
1293355 | 2 a
1293357 | 2 a
1293363 | 2 a
1293365 | 2 a
1293412 | 2 a
1293414 | 2 a
1293485 | 2 a
1293487 | 2 a
1293860 | 2 a
1293862 | 2 a
1293874 | 2 a
1293876 | 2 a
1294144 | 2 a
1294146 | 2 a
1294150 | 2 a
1294152 | 2 a
1294306 | 2 a
1294308 | 2 a
1294343 | 2 a
1294345 | 2 a
1294558 | 2 a
1294560 | 2 a
1294591 | 2 a
1294593 | 2 a
1294597 | 2 a
1294599 | 2 a
1294639 | 2 a
1294641 | 2 a
1294784 | 2 a
1294786 | 2 a
1294798 | 2 a
1294800 | 2 a
1294912 | 2 a
1294914 | 2 a
1294996 | 2 a
1294998 | 2 a
1295041 | 2 a
1295043 | 2 a
1295047 | 2 a
1295049 | 2 a
1295571 | 2 a
1295573 | 2 a
1295603 | 2 a
1295605 | 2 a
1295615 | 2 a
1295617 | 2 a
1295697 | 2 a
1295699 | 2 a
1295766 | 2 a
1295768 | 2 a
1295801 | 2 a
1295803 | 2 a
1295844 | 2 a
1295846 | 2 a
1295850 | 2 a
1295852 | 2 a
1295903 | 2 a
1295905 | 2 a
1295961 | 2 a
1295963 | 2 a
1295969 | 2 a
1295971 | 2 a
1296061 | 2 a
1296063 | 2 a
1296078 | 2 a
1296080 | 2 a
1296137 | 2 a
1296139 | 2 a
1296272 | 2 a
1296274 | 2 a
1296404 | 2 a
1296406 | 2 a
1296429 | 2 a
1296431 | 2 a
1296513 | 2 a
1296515 | 2 a
1296519 | 2 a
1296521 | 2 a
1296653 | 2 a
1296655 | 2 a
1296672 | 2 a
1296674 | 2 a
1296942 | 2 a
1296944 | 2 a
1297017 | 2 a
1297019 | 2 a
1297025 | 2 a
1297027 | 2 a
1297126 | 2 a
1297128 | 2 a
1297179 | 2 a
1297181 | 2 a
1297185 | 2 a
1297187 | 2 a
1297314 | 4 a V1
1297316 | 4 a V1
1297469 | 2 a
1297471 | 2 a
1297555 | 2 a
1297557 | 2 a
1297655 | 2 a
1297657 | 2 a
1297840 | 2 a
1297842 | 2 a
1297846 | 2 a
1297848 | 2 a
1297955 | 2 a
1297957 | 2 a
1297961 | 2 a
1297963 | 2 a
1298063 | 2 a
1298065 | 2 a
1298069 | 2 a
1298071 | 2 a
1298186 | 2 a
1298188 | 2 a
1298240 | 2 a
1298242 | 2 a
1298294 | 2 a
1298296 | 2 a
1298765 | 2 a
1298767 | 2 a
1298803 | 2 a
1298805 | 2 a
1298811 | 2 a
1298813 | 2 a
1298897 | 2 a
1298899 | 2 a
1298940 | 2 a
1298942 | 2 a
1298946 | 2 a
1298948 | 2 a
1299051 | 2 a
1299053 | 2 a
1299059 | 2 a
1299061 | 2 a
1299248 | 2 a
1299250 | 2 a
1299292 | 2 a
1299294 | 2 a
1299332 | 2 a
1299334 | 2 a
1299338 | 2 a
1299340 | 2 a
1299405 | 2 a
1299407 | 2 a
1299530 | 2 a
1299532 | 2 a
1299573 | 2 a
1299575 | 2 a
1299579 | 2 a
1299581 | 2 a
1299679 | 2 a
1299681 | 2 a
1299753 | 2 a
1299755 | 2 a
1299770 | 2 a
1299772 | 2 a
1299805 | 2 a
1299807 | 2 a
1300091 | 2 a
1300093 | 2 a
1300202 | 2 a
1300204 | 2 a
1300469 | 2 a
1300471 | 2 a
1300660 | 2 a
1300662 | 2 a
1300701 | 2 a
1300703 | 2 a
1300707 | 2 a
1300709 | 2 a
1301031 | 2 a
1301033 | 2 a
1301037 | 2 a
1301039 | 2 a
1301150 | 2 a
1301152 | 2 a
1301164 | 2 a
1301166 | 2 a
1301209 | 2 a
1301211 | 2 a
1301401 | 2 a
1301403 | 2 a
1301452 | 2 a
1301454 | 2 a
1301458 | 2 a
1301460 | 2 a
1301503 | 2 a
1301505 | 2 a
1301542 | 2 a
1301544 | 2 a
1301550 | 2 a
1301552 | 2 a
1301727 | 2 a
1301729 | 2 a
1301753 | 2 a
1301755 | 2 a
1301903 | 2 a
1301905 | 2 a
1301949 | 2 a
1301951 | 2 a
1302088 | 2 a
1302090 | 2 a
1302107 | 2 a
1302109 | 2 a
1302669 | 2 a
1302671 | 2 a
1302675 | 2 a
1302677 | 2 a
1302751 | 2 a
1302753 | 2 a
1302792 | 2 a
1302794 | 2 a
1302798 | 2 a
1302800 | 2 a
1303010 | 2 a
1303012 | 2 a
1303068 | 2 a
1303070 | 2 a
1303074 | 2 a
1303076 | 2 a
1303173 | 2 a
1303175 | 2 a
1303179 | 2 a
1303181 | 2 a
1303796 | 4 a V1
1303798 | 4 a V1
1303810 | 4 a V1
1303812 | 4 a V1
1303822 | 4 a V1
1303824 | 4 a V1
1303847 | 4 a V1
1303849 | 4 a V1
1303980 | 4 a V1
1303982 | 4 a V1
1304284 | 4 a V1
1304322 | 1 a +-152.84
1304740 | 1 a +-152.84
1304742 | 1 a +-152.84
1304746 | 1 a +-152.84
1304748 | 1 a +-152.84
1304848 | 1 a +-152.84
1304850 | 1 a +-152.84
1304928 | 1 a +-152.84
1304930 | 1 a +-152.84
1305032 | 1 a +-152.84
1305034 | 1 a +-152.84
1305040 | 1 a +-152.84
1305042 | 1 a +-152.84
1305212 | 1 a +-152.84
1305214 | 1 a +-152.84
1305226 | 1 a +-152.84
1305228 | 1 a +-152.84
1305311 | 1 a +-152.84
1305313 | 1 a +-152.84
1305319 | 1 a +-152.84
1305321 | 1 a +-152.84
1305351 | 1 a +-152.84
1305353 | 1 a +-152.84
1305548 | 1 a +-152.84
1305550 | 1 a +-152.84
1305675 | 0 a
1305677 | 0 a
1305902 | 2 a
1305904 | 2 a
1306484 | 1 a +-152.84
1306486 | 1 a +-152.84
1306569 | 1 a +-152.84
1306571 | 1 a +-152.84
1306577 | 1 a +-152.84
1306579 | 1 a +-152.84
1306719 | 1 a +-152.84
1306721 | 1 a +-152.84
1306727 | 1 a +-152.84
1306729 | 1 a +-152.84
1307007 | 1 a +-152.84
1307009 | 1 a +-152.84
1307320 | 1 a +-152.84
1307322 | 1 a +-152.84
1307521 | 1 a +-152.84
1307523 | 1 a +-152.84
1307863 | 1 a +-152.84
1307875 | 1 a +-152.84
1307957 | 1 a +-152.84
1307959 | 1 a +-152.84
1307963 | 1 a +-152.84
1307965 | 1 a +-152.84
1308007 | 1 a +-152.84
1308009 | 1 a +-152.84
1308072 | 1 a +-152.84
1308074 | 1 a +-152.84
1308194 | 1 a +-152.84
1308196 | 1 a +-152.84
1308237 | 1 a +-152.84
1308239 | 1 a +-152.84
1308243 | 1 a +-152.84
1308245 | 1 a +-152.84
1308480 | 1 a +-152.84
1308482 | 1 a +-152.84
1308486 | 1 a +-152.84
1308488 | 1 a +-152.84
1308588 | 1 a +-152.84
1308590 | 1 a +-152.84
1308594 | 1 a +-152.84
1308596 | 1 a +-152.84
1308960 | 1 a +-152.84
1308962 | 1 a +-152.84
1309017 | 1 a +-152.84
1309019 | 1 a +-152.84
1309191 | 1 a +-152.84
1309193 | 1 a +-152.84
1309323 | 1 a +-152.84
1309325 | 1 a +-152.84
1309578 | 1 a +-152.84
1309580 | 1 a +-152.84
1309659 | 1 a +-152.84
1309661 | 1 a +-152.84
1309667 | 1 a +-152.84
1309669 | 1 a +-152.84
1309711 | 1 a +-152.84
1309717 | 1 a +-152.84
1309825 | 1 a +-152.84
1309827 | 1 a +-152.84
1309833 | 1 a +-152.84
1309835 | 1 a +-152.84
1309945 | 1 a +-152.84
1309947 | 1 a +-152.84
1309953 | 1 a +-152.84
1309955 | 1 a +-152.84
1310018 | 1 a +-152.84
1310020 | 1 a +-152.84
1310089 | 1 a +-152.84
1310091 | 1 a +-152.84
1310095 | 1 a +-152.84
1310097 | 1 a +-152.84
1310190 | 1 a +-152.84
1310192 | 1 a +-152.84
1310362 | 1 a +-152.84
1310364 | 1 a +-152.84
1310368 | 1 a +-152.84
1310370 | 1 a +-152.84
1310539 | 1 a +-152.84
1310541 | 1 a +-152.84
1310564 | 1 a +-152.84
1310566 | 1 a +-152.84
1310656 | 1 a +-152.84
1310658 | 1 a +-152.84
1310664 | 1 a +-152.84
1310666 | 1 a +-152.84
1310804 | 1 a +-152.84
1310806 | 1 a +-152.84
1310812 | 1 a +-152.84
1310814 | 1 a +-152.84
1310934 | 1 a +-152.84
1310936 | 1 a +-152.84
1310942 | 1 a +-152.84
1310944 | 1 a +-152.84
1310991 | 1 a +-152.84
1310993 | 1 a +-152.84
1311061 | 1 a +-152.84
1311063 | 1 a +-152.84
1311067 | 1 a +-152.84
1311069 | 1 a +-152.84
1311324 | 4 a V1
1311326 | 4 a V1
1311339 | 4 a V1
1311341 | 4 a V1
1311674 | 1 a +-152.84
1311676 | 1 a +-152.84
1311759 | 1 a +-152.84
1311761 | 1 a +-152.84
1311765 | 1 a +-152.84
1311767 | 1 a +-152.84
1312138 | 1 a +-152.84
1312140 | 1 a +-152.84
1312144 | 1 a +-152.84
1312146 | 1 a +-152.84
1312235 | 1 a +-152.84
1312237 | 1 a +-152.84
1312460 | 1 a +-152.84
1312462 | 1 a +-152.84
1312466 | 1 a +-152.84
1312468 | 1 a +-152.84
1313004 | 4 a V1
1313006 | 4 a V1
1313050 | 1 a +-152.84
1313052 | 1 a +-152.84
1313056 | 1 a +-152.84
1313058 | 1 a +-152.84
1313162 | 1 a +-152.84
1313164 | 1 a +-152.84
1313272 | 1 a +-152.84
1313274 | 1 a +-152.84
1313278 | 1 a +-152.84
1313280 | 1 a +-152.84
1313317 | 1 a +-152.84
1313319 | 1 a +-152.84
1313380 | 2 a
1313382 | 2 a
1313398 | 1 a +-152.84
1313400 | 1 a +-152.84
1313408 | 1 a +-152.84
1313410 | 1 a +-152.84
1313414 | 1 a +-152.84
1313416 | 1 a +-152.84
1313432 | 1 a +-152.84
1313434 | 1 a +-152.84
1313438 | 1 a +-152.84
1313440 | 1 a +-152.84
1313454 | 1 a +-152.84
1313456 | 1 a +-152.84
1313470 | 1 a +-152.84
1313472 | 1 a +-152.84
1313492 | 1 a +-152.84
1313494 | 1 a +-152.84
1313519 | 1 a +-152.84
1313525 | 1 a +-152.84
1313533 | 1 a +-152.84
1313535 | 1 a +-152.84
1313539 | 1 a +-152.84
1313541 | 1 a +-152.84
1313555 | 1 a +-152.84
1313557 | 1 a +-152.84
1313571 | 1 a +-152.84
1313573 | 1 a +-152.84
1313593 | 1 a +-152.84
1313595 | 1 a +-152.84
1313603 | 1 a +-152.84
1313605 | 1 a +-152.84
1313609 | 1 a +-152.84
1313611 | 1 a +-152.84
1313627 | 1 a +-152.84
1313629 | 1 a +-152.84
1313633 | 1 a +-152.84
1313635 | 1 a +-152.84
1313651 | 1 a +-152.84
1313653 | 1 a +-152.84
1313657 | 1 a +-152.84
1313659 | 1 a +-152.84
1313673 | 1 a +-152.84
1313675 | 1 a +-152.84
1313681 | 1 a +-152.84
1313683 | 1 a +-152.84
1313697 | 1 a +-152.84
1313699 | 1 a +-152.84
1313713 | 1 a +-152.84
1313715 | 1 a +-152.84
1313738 | 1 a +-152.84
1313740 | 1 a +-152.84
1313748 | 1 a +-152.84
1313750 | 1 a +-152.84
1313754 | 1 a +-152.84
1313756 | 1 a +-152.84
1313772 | 1 a +-152.84
1313776 | 1 a +-152.84
1313784 | 1 a +-152.84
1313786 | 1 a +-152.84
1313790 | 1 a +-152.84
1313792 | 1 a +-152.84
1313808 | 1 a +-152.84
1313810 | 1 a +-152.84
1313814 | 1 a +-152.84
1313816 | 1 a +-152.84
1313830 | 1 a +-152.84
1313832 | 1 a +-152.84
1313840 | 1 a +-152.84
1313842 | 1 a +-152.84
1313846 | 1 a +-152.84
1313848 | 1 a +-152.84
1313866 | 1 a +-152.84
1313868 | 1 a +-152.84
1313878 | 1 a +-152.84
1313880 | 1 a +-152.84
1313884 | 1 a +-152.84
1313886 | 1 a +-152.84
1313900 | 1 a +-152.84
1313902 | 1 a +-152.84
1313908 | 1 a +-152.84
1313910 | 1 a +-152.84
1313918 | 1 a +-152.84
1313920 | 1 a +-152.84
1313924 | 1 a +-152.84
1313926 | 1 a +-152.84
1313942 | 1 a +-152.84
1313944 | 1 a +-152.84
1313948 | 1 a +-152.84
1313950 | 1 a +-152.84
1313966 | 1 a +-152.84
1313968 | 1 a +-152.84
1313972 | 1 a +-152.84
1313974 | 1 a +-152.84
1313988 | 1 a +-152.84
1313990 | 1 a +-152.84
1313998 | 1 a +-152.84
1314000 | 1 a +-152.84
1314004 | 1 a +-152.84
1314006 | 1 a +-152.84
1316267 | 4 a V1
1316269 | 4 a V1
1316364 | 1 a +-152.84
1316366 | 1 a +-152.84
1316590 | 1 a +-152.84
1316592 | 1 a +-152.84
1316598 | 1 a +-152.84
1316600 | 1 a +-152.84
1316709 | 1 a +-152.84
1316711 | 1 a +-152.84
1316717 | 1 a +-152.84
1316719 | 1 a +-152.84
1316790 | 1 a +-152.84
1316792 | 1 a +-152.84
1316798 | 1 a +-152.84
1316800 | 1 a +-152.84
1316891 | 1 a +-152.84
1316893 | 1 a +-152.84
1316899 | 1 a +-152.84
1316901 | 1 a +-152.84
1317028 | 1 a +-152.84
1317030 | 1 a +-152.84
1317078 | 1 a +-152.84
1317080 | 1 a +-152.84
1317084 | 1 a +-152.84
1317086 | 1 a +-152.84
1317131 | 1 a +-152.84
1317133 | 1 a +-152.84
1317171 | 1 a +-152.84
1317173 | 1 a +-152.84
1317179 | 1 a +-152.84
1317181 | 1 a +-152.84
1317291 | 1 a +-152.84
1317293 | 1 a +-152.84
1317297 | 1 a +-152.84
1317299 | 1 a +-152.84
1317380 | 1 a +-152.84
1317382 | 1 a +-152.84
1317386 | 1 a +-152.84
1317388 | 1 a +-152.84
1317497 | 1 a +-152.84
1317499 | 1 a +-152.84
1317564 | 1 a +-152.84
1317566 | 1 a +-152.84
1317570 | 1 a +-152.84
1317572 | 1 a +-152.84
1317648 | 1 a +-152.84
1317693 | 1 a +-152.84
1317785 | 1 a +-152.84
1317787 | 1 a +-152.84
1318005 | 4 a V1
1318007 | 4 a V1
1318092 | 1 a +-152.84
1318094 | 1 a +-152.84
1318213 | 1 a +-152.84
1318215 | 1 a +-152.84
1318309 | 1 a +-152.84
1318311 | 1 a +-152.84
1318315 | 1 a +-152.84
1318317 | 1 a +-152.84
1318342 | 1 a +-152.84
1318344 | 1 a +-152.84
1318392 | 1 a +-152.84
1318394 | 1 a +-152.84
1318473 | 1 a +-152.84
1318475 | 1 a +-152.84
1318479 | 1 a +-152.84
1318481 | 1 a +-152.84
1318653 | 2 a
1318655 | 2 a
1318743 | 2 a
1318745 | 2 a
1318832 | 2 a
1318834 | 2 a
1318908 | 2 a
1318910 | 2 a
1318914 | 2 a
1318916 | 2 a
1319055 | 2 a
1319057 | 2 a
1319256 | 2 a
1319258 | 2 a
1319321 | 1 a +-152.84
1319323 | 1 a +-152.84
1319329 | 1 a +-152.84
1319331 | 1 a +-152.84
1319750 | 1 a +-152.84
1319752 | 1 a +-152.84
1319758 | 1 a +-152.84
1319760 | 1 a +-152.84
1319907 | 1 a +-152.84
1319909 | 1 a +-152.84
1319915 | 1 a +-152.84
1319917 | 1 a +-152.84
1320047 | 1 a +-152.84
1320049 | 1 a +-152.84
1320055 | 1 a +-152.84
1320057 | 1 a +-152.84
1320235 | 1 a +-152.84
1320237 | 1 a +-152.84
1320274 | 1 a +-152.84
1320276 | 1 a +-152.84
1320280 | 1 a +-152.84
1320282 | 1 a +-152.84
1320411 | 1 a +-152.84
1320413 | 1 a +-152.84
1320417 | 1 a +-152.84
1320419 | 1 a +-152.84
1320467 | 1 a +-152.84
1320469 | 1 a +-152.84
1320481 | 1 a +-152.84
1320483 | 1 a +-152.84
1320528 | 1 a +-152.84
1320530 | 1 a +-152.84
1320534 | 1 a +-152.84
1320536 | 1 a +-152.84
1320612 | 1 a +-152.84
1320614 | 1 a +-152.84
1320618 | 1 a +-152.84
1320620 | 1 a +-152.84
1320723 | 1 a +-152.84
1320725 | 1 a +-152.84
1320729 | 1 a +-152.84
1320731 | 1 a +-152.84
1411649 | 4 a V1
1411651 | 4 a V1
1411796 | 0 a
1411798 | 0 a
1411855 | 0 a
1411857 | 0 a
1411861 | 0 a
1411863 | 0 a
1412250 | 0 a
1412252 | 0 a
1412262 | 0 a
1412264 | 0 a
1412542 | 2 a
1412544 | 2 a
1412670 | 0 a
1412672 | 0 a
1412879 | 0 a
1412881 | 0 a
1413243 | 0 a
1413245 | 0 a
1413256 | 0 a
1413258 | 0 a
1413643 | 0 a
1413645 | 0 a
1413757 | 0 a
1413759 | 0 a
1414164 | 0 a
1414166 | 0 a
1414170 | 0 a
1414172 | 0 a
1414302 | 0 a
1414304 | 0 a
1414358 | 0 a
1414360 | 0 a
1414366 | 0 a
1414368 | 0 a
1414524 | 0 a
1414526 | 0 a
1414532 | 0 a
1414534 | 0 a
1414593 | 0 a
1414595 | 0 a
1414680 | 0 a
1414682 | 0 a
1414686 | 0 a
1414688 | 0 a
1414721 | 0 a
1414723 | 0 a
1414916 | 0 a
1414918 | 0 a
1415035 | 2 a
1415037 | 2 a
1415107 | 2 a
1415109 | 2 a
1415363 | 2 a
1415365 | 2 a
1415377 | 0 a
1415379 | 0 a
1415521 | 0 a
1415523 | 0 a
1415615 | 0 a
1415617 | 0 a
1415621 | 0 a
1415623 | 0 a
1415857 | 0 a
1415859 | 0 a
1415893 | 0 a
1415895 | 0 a
1415983 | 0 a
1415985 | 0 a
1415989 | 0 a
1415991 | 0 a
1416121 | 1 a +-152.84
1416123 | 1 a +-152.84
1416151 | 1 a +-152.84
1416153 | 1 a +-152.84
1416316 | 0 a
1416318 | 0 a
1416433 | 0 a
1416435 | 0 a
1416439 | 0 a
1416441 | 0 a
1416665 | 0 a
1416667 | 0 a
1416671 | 0 a
1416673 | 0 a
1416798 | 0 a
1416800 | 0 a
1416831 | 0 a
1416833 | 0 a
1416903 | 0 a
1416905 | 0 a
1417062 | 0 a
1417064 | 0 a
1417096 | 0 a
1417098 | 0 a
1417288 | 2 a
1417290 | 2 a
1417458 | 0 a
1417460 | 0 a
1417472 | 0 a
1417474 | 0 a
1417829 | 0 a
1417831 | 0 a
1417895 | 0 a
1417897 | 0 a
1417903 | 0 a
1417905 | 0 a
1417942 | 2 a
1417944 | 2 a
1418160 | 0 a
1418162 | 0 a
1418424 | 0 a
1418426 | 0 a
1418818 | 0 a
1418820 | 0 a
1418877 | 0 a
1418879 | 0 a
1419007 | 0 a
1419009 | 0 a
1419054 | 4 a V1
1419056 | 4 a V1
1419162 | 1 a +-152.84
1419164 | 1 a +-152.84
1419242 | 2 a
1419244 | 2 a
1419338 | 4 a V1
1419340 | 4 a V1
1419478 | 2 a
1419480 | 2 a
1419575 | 4 a V1
1419577 | 4 a V1
1497993 | 5 a V1
1497995 | 5 a V1
1498260 | 5 a V1
1498262 | 5 a V1
1498274 | 5 a V1
1498276 | 5 a V1
1498385 | 5 a V1
1498387 | 5 a V1
1498478 | 5 a V1
1498480 | 5 a V1
1498486 | 5 a V1
1498488 | 5 a V1
1498496 | 5 a V1
1498498 | 5 a V1
1498711 | 5 a V1
1498713 | 5 a V1
1498753 | 5 a V1
1498755 | 5 a V1
1498820 | 0 a
1498822 | 0 a
1498863 | 5 a V1
1498865 | 5 a V1
1499011 | 5 a V1
1499013 | 5 a V1
1499062 | 5 a V1
1499066 | 5 a V1
1499068 | 5 a V1
1499096 | 5 a V1
1499098 | 5 a V1
1499201 | 0 a
1499203 | 0 a
1500743 | 0 a
1501813 | 0 a
1501815 | 0 a
1501852 | 0 a
1501854 | 0 a
1502321 | 0 a
1502323 | 0 a
1502498 | 0 a
1502500 | 0 a
1502908 | 0 a
1502910 | 0 a
1502916 | 0 a
1502918 | 0 a
1503299 | 4 a V1
1503301 | 4 a V1
1503345 | 4 a V1
1503357 | 0 a
1503546 | 5 a V1
1503548 | 5 a V1
1503690 | 0 a
1503692 | 0 a
1504091 | 2 a
1504093 | 2 a
1504106 | 0 a
1504108 | 0 a
1504148 | 2 a
1504150 | 2 a
1506158 | 0 a
1506195 | 0 a
1506197 | 0 a
1506209 | 0 a
1506211 | 0 a
1506620 | 2 a
1506622 | 2 a
1506634 | 2 a
1506636 | 2 a
1856021 | 5 a V1
1856023 | 5 a V1
1856035 | 5 a V1
1856037 | 5 a V1
1856645 | 5 a V1
1856647 | 5 a V1
1856685 | 5 a V1
1856687 | 5 a V1
1856865 | 5 a V1
1856867 | 5 a V1
1857396 | 5 a V1
1857402 | 5 a V1
1857414 | 5 a V1
1857416 | 5 a V1
1857471 | 5 a V1
1857477 | 5 a V1
1857601 | 5 a V1
1857603 | 5 a V1
1857654 | 5 a V1
1857656 | 5 a V1
1857668 | 5 a V1
1857670 | 5 a V1
1858431 | 4 a V1
1858445 | 4 a V1
1859554 | 4 a V1
1859652 | 4 a V1
1862261 | 2 a

# IfcFlowFitting: Z_PIF_AS+_Reducer_Long_Wavin_(nested):Black (165)
Type - Description: Reducer long; PredefinedType: TRANSITION; Material: Polypropylene, Black, RAL 9200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Black; sets with these values: 2
Name (Z_PIF_AS+_Reducer_Long_Wavin_(nested):Black:...) | In
1112450 | 4 a V1
1112452 | 4 a V1
1121334 | 5 a V1
1121336 | 5 a V1
1128109 | 4 a V1
1128111 | 4 a V1
1129683 | 4 a V1
1129685 | 4 a V1
1130221 | 4 a V1
1130223 | 4 a V1
1131322 | 4 a V1
1131324 | 4 a V1
1139428 | 5 a V1
1139430 | 5 a V1
1139660 | 5 a V1
1139662 | 5 a V1
1143913 | 5 a V1
1143915 | 5 a V1
1144139 | 5 a V1
1144141 | 5 a V1
1150823 | 5 a V1
1151897 | 4 a V1
1151899 | 4 a V1
1152491 | 4 a V1
1152493 | 4 a V1
1152826 | 4 a V1
1152828 | 4 a V1
1165579 | 4 a V1
1165581 | 4 a V1
1173297 | 4 a V1
1173299 | 4 a V1
1177569 | 4 a V1
1177571 | 4 a V1
1186153 | 4 a V1
1186155 | 4 a V1
1186669 | 4 a V1
1186671 | 4 a V1
1187134 | 4 a V1
1187136 | 4 a V1
1187266 | 4 a V1
1187268 | 4 a V1
1189482 | 4 a V1
1189484 | 4 a V1
1192491 | 4 a V1
1192493 | 4 a V1
1192881 | 4 a V1
1192883 | 4 a V1
1195178 | 4 a V1
1195180 | 4 a V1
1195326 | 4 a V1
1195328 | 4 a V1
1198450 | 4 a V1
1198452 | 4 a V1
1200459 | 4 a V1
1200461 | 4 a V1
1201163 | 4 a V1
1201165 | 4 a V1
1201262 | 4 a V1
1201264 | 4 a V1
1203625 | 4 a V1
1203627 | 4 a V1
1213643 | 3 a
1213645 | 3 a
1217414 | 3 a
1217416 | 3 a
1217630 | 3 a
1217632 | 3 a
1223530 | 3 a
1223532 | 3 a
1229358 | 3 a
1229360 | 3 a
1231062 | 3 a
1231064 | 3 a
1234355 | 3 a
1234357 | 3 a
1236151 | 3 a
1236153 | 3 a
1245704 | 2 a
1245706 | 2 a
1245917 | 2 a
1245919 | 2 a
1247333 | 2 a
1247335 | 2 a
1251163 | 2 a
1251165 | 2 a
1251537 | 2 a
1251539 | 2 a
1252191 | 2 a
1252193 | 2 a
1258024 | 2 a
1258026 | 2 a
1266032 | 2 a
1266034 | 2 a
1273460 | 2 a
1273462 | 2 a
1283287 | 2 a
1283289 | 2 a
1283682 | 2 a
1283684 | 2 a
1283862 | 2 a
1283864 | 2 a
1287990 | 2 a
1287992 | 2 a
1288216 | 2 a
1288218 | 2 a
1292748 | 2 a
1292750 | 2 a
1293188 | 2 a
1293190 | 2 a
1296008 | 2 a
1296010 | 2 a
1296370 | 2 a
1296372 | 2 a
1296586 | 2 a
1296588 | 2 a
1298152 | 2 a
1298154 | 2 a
1298578 | 2 a
1298580 | 2 a
1305608 | 0 a
1305610 | 0 a
1307376 | 1 a +-152.84
1307378 | 1 a +-152.84
1308175 | 1 a +-152.84
1308177 | 1 a +-152.84
1310156 | 1 a +-152.84
1310158 | 1 a +-152.84
1313484 | 1 a +-152.84
1313486 | 1 a +-152.84
1313585 | 1 a +-152.84
1313587 | 1 a +-152.84
1313860 | 1 a +-152.84
1313862 | 1 a +-152.84
1317614 | 1 a +-152.84
1317616 | 1 a +-152.84
1415800 | 0 a
1415802 | 0 a
1416884 | 0 a
1416886 | 0 a
1503671 | 0 a
1503673 | 0 a
1506139 | 0 a
1506141 | 0 a
1856427 | 5 a V1
1856429 | 5 a V1
1857927 | 5 a V1
1857929 | 5 a V1
1857931 | 5 a V1
1857933 | 5 a V1
1857935 | 5 a V1
1857937 | 5 a V1
1857939 | 5 a V1
1857941 | 5 a V1
1857943 | 5 a V1
1857945 | 5 a V1
1857947 | 5 a V1
1857949 | 5 a V1
1857951 | 5 a V1
1857953 | 5 a V1
1859559 | 4 a V1
1859561 | 4 a V1
1859656 | 4 a V1
1859658 | 4 a V1
1862265 | 2 a
1862267 | 2 a

# IfcFlowFitting: Z_PIF_AS+_Reducer_Short_Wavin_(nested):White (3)
In: 0 a
Type - Description: Reducer Short; PredefinedType: TRANSITION; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: White; sets with these values: 2
Name (Z_PIF_AS+_Reducer_Short_Wavin_(nested):White:...)
1414067
1415511
1416827

# IfcFlowFitting: Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):1 - M5 (443)
Type - Description: Reducer; PredefinedType: CONNECTOR; Material: Steel WVN-T, Brass WVN-T
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 1 - M5; sets with these values: 2
Name (Z_PIF_Tigris_Reducer_M-K_Wavin_(nested):1 - M5:...) | In
1330817 | 3 a
1330819 | 3 a
1331560 | 4 a V1
1333703 | 4 a V1
1334078 | 2 a
1334124 | 4 a V1
1336498 | 4 a V1
1336554 | 4 a V1
1337427 | 4 a V1
1337661 | 4 a V1
1339077 | 5 a V1
1339206 | 5 a V1
1339337 | 5 a V1
1339718 | 5 a V1
1339720 | 5 a V1
1339799 | 2 a
1339830 | 2 a
1340543 | 4 a V1
1341062 | 4 a V1
1341749 | 2 a
1341831 | 2 a
1342726 | 4 a V1
1343032 | 4 a V1
1343317 | 4 a V1
1344238 | 2 a
1344599 | 5 a V1
1345222 | 2 a
1345864 | 4 a V1
1346138 | 4 a V1
1346681 | 4 a V1
