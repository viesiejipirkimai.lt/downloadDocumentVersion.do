Properties of the parts of a building model (IFC2X3), part 32 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1470227_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470269_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470227_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470263_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470265_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470263_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470269_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470285_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470303_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470285_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470315_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470303_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470304_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470307_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470315_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470307_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470323_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470317_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470323_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470317_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470333_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470325_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470333_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470325_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470384_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470335_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470388_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470335_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470382_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470384_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470388_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470404_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470420_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470404_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470475_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470420_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470421_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470421_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470503_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470424_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470479_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470473_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470475_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470473_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470479_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470495_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470503_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470495_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470503_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470504_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470507_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470565_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470559_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470561_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470559_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470565_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1470591_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470599_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470591_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470643_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470599_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470672_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470599_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470600_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470603_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470647_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470603_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470641_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470643_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470641_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470647_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470663_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470671_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470663_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470773_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470671_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470672_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470675_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470777_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470771_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470773_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470771_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470777_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1470807_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1470808_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1470807_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1483434_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1470807_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471048_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471048_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471074_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471058_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471074_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471058_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471088_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471076_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471088_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471076_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471118_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471257_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471118_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471138_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471128_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471138_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471128_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471156_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472389_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471156_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471170_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471164_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471170_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471164_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471198_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471190_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471198_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471190_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1481040_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1471228_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471236_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1481064_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471257_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471268_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471322_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471322_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471324_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471332_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471324_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471340_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471334_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471334_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472281_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471342_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471342_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471404_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471362_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471360_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471574_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471366_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471406_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471366_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471426_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471410_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471426_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471434_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471428_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471543_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471496_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471434_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471544_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471436_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471498_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471436_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471494_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471496_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471494_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471498_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471526_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471547_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471526_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471541_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471543_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471541_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471547_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471543_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471544_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471563_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471573_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471585_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471573_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471574_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471577_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471585_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471587_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471663_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471587_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471655_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471657_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471655_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471663_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471657_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471659_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471800_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471808_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471800_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471818_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471808_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471809_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471809_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472073_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471812_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471818_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471812_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471828_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471820_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471828_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471820_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471830_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471885_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471830_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471879_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471881_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471879_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1471885_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472019_2 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1472021_0 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1472021_1 | SOURCEANDSINK | vanduo šaltas - V1 8
Port_1472065_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472147_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472114_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472073_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472074_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472073_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472148_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472074_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472280_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472077_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472116_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472077_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472112_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472114_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472112_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472116_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472132_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472151_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472132_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472145_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472147_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472145_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472151_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472147_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472148_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472179_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472187_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472199_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472187_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472188_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472191_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472199_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472191_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472207_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472201_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472207_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472201_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472250_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472209_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472254_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472209_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472248_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472250_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472248_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472254_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1472270_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472280_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472270_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472290_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472280_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472281_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472284_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472290_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472361_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472292_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472365_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472292_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472359_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472361_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472359_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472365_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472389_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472400_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472400_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472456_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472450_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472456_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472450_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472468_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472458_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472468_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472458_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472479_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472470_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472479_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472470_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472499_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472481_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472499_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472481_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472507_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472501_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472507_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472501_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472519_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472509_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472519_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472509_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472540_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472560_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472540_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472560_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472561_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472685_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472703_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472685_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472872_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472703_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472704_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472866_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473895_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472866_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473193_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472872_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473896_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473179_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473179_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473207_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473193_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473785_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473197_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473601_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473197_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473242_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473207_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473705_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473209_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473380_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473209_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473259_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473242_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473244_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473244_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473457_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473248_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473259_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473248_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473269_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473261_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473269_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473261_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473271_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473330_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473271_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473324_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473326_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473324_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473330_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473372_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473380_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473372_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473380_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473381_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473381_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473456_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473384_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473432_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473384_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473426_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473428_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473426_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473432_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473448_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473527_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473448_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473466_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473456_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473457_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473456_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473528_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473460_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473466_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473460_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473501_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473468_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473505_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473468_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473499_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473501_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473499_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473505_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473521_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473527_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473521_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473573_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473527_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473528_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473531_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473577_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473571_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473573_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473595_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473601_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473595_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473601_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473602_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473602_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473704_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473605_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473613_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473605_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473621_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473615_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473623_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473615_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473674_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473621_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473623_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473627_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473678_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473672_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473674_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473672_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473678_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473694_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473704_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473694_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473752_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473704_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473705_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473708_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473756_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473750_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473752_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473750_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473756_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473776_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473784_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473776_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473794_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473784_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473785_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473788_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473794_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473788_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473804_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473796_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473804_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473796_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473812_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473812_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473865_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473814_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473869_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473814_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473863_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473865_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473863_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473869_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473887_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474002_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473887_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473905_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473895_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473896_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473895_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474003_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473899_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473905_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473899_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473970_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473974_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473968_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473970_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473968_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473974_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473990_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474002_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1473990_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474017_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474002_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474003_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474006_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474006_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474063_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474017_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474092_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474019_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474019_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474061_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474063_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474085_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474091_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474111_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474091_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474092_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474095_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474111_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474095_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474165_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474113_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474167_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474113_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474163_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474165_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474163_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474167_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474220_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474221_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474220_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475160_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474240_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474273_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474240_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474304_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474273_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474274_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474296_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475960_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474296_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475918_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474304_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475961_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474740_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474740_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474766_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474752_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474764_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474752_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474879_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474764_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474766_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474770_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474879_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474770_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474796_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474784_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474798_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474852_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474796_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474798_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474802_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474856_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474802_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474850_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474852_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474856_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474879_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475062_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474890_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474992_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474890_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474906_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474900_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474906_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474900_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474940_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474908_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474944_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474908_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474938_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474940_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474938_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474944_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474984_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474992_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474984_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475033_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474992_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474993_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474993_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474996_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475037_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474996_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475031_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475033_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475031_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475037_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475053_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475061_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475053_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475073_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475061_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475062_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475065_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475073_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475083_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475075_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475083_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475120_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475085_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475124_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475118_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475120_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475118_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475124_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475151_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475159_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475151_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475169_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475159_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475327_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475159_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475160_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475163_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475169_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475163_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475179_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475171_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475254_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475171_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475216_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475179_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475255_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475181_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475218_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475181_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475214_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475216_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475214_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475218_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475243_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475258_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475252_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475254_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475258_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475254_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475255_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475314_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475326_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475314_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475336_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475326_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475327_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475330_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475336_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475330_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475338_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475759_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475338_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475376_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475360_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475760_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475362_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475399_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475376_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475378_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475378_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475619_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475382_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475399_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475401_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475410_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475401_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475461_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475412_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475465_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475412_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475459_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475461_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475459_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475465_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475510_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475522_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475510_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475532_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475522_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475523_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475523_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475618_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475526_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475532_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475526_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475542_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475534_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475542_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475534_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475590_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475544_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475594_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475544_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475588_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475590_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475588_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475594_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475610_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475618_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475610_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475715_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475618_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475619_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475622_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475717_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475622_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475713_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475715_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475713_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475717_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475737_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475759_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475737_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475759_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475760_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475763_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475774_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475782_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475776_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475782_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475776_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475792_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475784_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475880_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475847_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475792_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475881_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475794_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475849_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475794_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475845_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475847_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475845_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475867_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475884_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475867_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475878_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475880_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475878_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475884_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475880_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1475906_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475935_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475906_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475918_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475935_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475944_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476023_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475944_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475978_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475960_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475961_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475960_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476024_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475964_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475978_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475964_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475995_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475980_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475995_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1475980_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476011_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476023_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476011_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476033_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476023_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476024_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476027_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476033_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476027_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476047_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476035_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476087_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476035_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476055_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476047_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476088_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476049_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476055_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476049_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476077_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476087_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476077_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476101_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476087_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476088_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476091_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476101_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476091_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476109_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476103_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476109_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476103_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476269_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477612_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1476269_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1476279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477613_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1476564_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476598_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476598_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476878_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476870_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476878_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476870_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479113_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1477009_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477160_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477045_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477021_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477501_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477021_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477023_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477027_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477045_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477027_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477053_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477047_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477053_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477047_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477067_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477055_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477069_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477055_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477126_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477067_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477073_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477130_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477073_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477124_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477126_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477124_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477130_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477152_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477160_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477152_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477170_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477160_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477271_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477164_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477170_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477164_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477240_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477172_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477244_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477172_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477238_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477240_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477244_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477262_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477320_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477262_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477335_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477271_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477320_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477320_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477321_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477321_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477325_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477335_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477325_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477400_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1477337_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
