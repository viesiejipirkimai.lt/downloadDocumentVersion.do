Properties of the parts of a building model (IFC2X3), part 7 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1228417_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228336_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228407_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228409_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228441_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 52
Port_1228441_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 52
Port_1228461_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228479_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228461_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228495_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228479_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228480_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228479_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228614_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228489_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228495_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228489_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228550_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228503_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228558_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228503_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228548_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228550_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228548_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228558_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228579_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 53
Port_1228579_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 53
Port_1228599_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228613_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228599_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228629_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228614_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228623_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228629_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228623_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228637_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228693_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228637_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228683_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228685_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228683_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228693_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1228821_0 | SOURCEANDSINK | K1 2
Port_1228829_3 | SOURCEANDSINK | K1 2
Port_1228821_1 | SOURCEANDSINK | K1 2
Port_1228859_1 | SOURCEANDSINK | K1 2
Port_1228829_1 | SOURCEANDSINK | K1 2
Port_1247595_0 | SOURCEANDSINK | K1 2
Port_1228829_2 | SOURCEANDSINK | K1 2
Port_1228830_1 | SOURCEANDSINK | K1 2
Port_1228849_0 | SOURCEANDSINK | K1 2
Port_1229008_2 | SOURCEANDSINK | K1 2
Port_1228849_1 | SOURCEANDSINK | K1 2
Port_1228939_1 | SOURCEANDSINK | K1 2
Port_1228859_2 | SOURCEANDSINK | K1 2
Port_1229491_0 | SOURCEANDSINK | K1 2
Port_1228937_0 | SOURCEANDSINK | K1 2
Port_1228939_2 | SOURCEANDSINK | K1 2
Port_1228937_1 | SOURCEANDSINK | K1 2
Port_1228976_1 | SOURCEANDSINK | K1 2
Port_1229000_0 | SOURCEANDSINK | K1 2
Port_1229348_2 | SOURCEANDSINK | K1 2
Port_1229000_1 | SOURCEANDSINK | K1 2
Port_1229024_1 | SOURCEANDSINK | K1 2
Port_1229008_1 | SOURCEANDSINK | K1 2
Port_1229009_1 | SOURCEANDSINK | K1 2
Port_1229008_3 | SOURCEANDSINK | K1 2
Port_1229349_0 | SOURCEANDSINK | K1 2
Port_1229009_0 | SOURCEANDSINK | K1 2
Port_1229490_2 | SOURCEANDSINK | K1 2
Port_1229018_0 | SOURCEANDSINK | K1 2
Port_1229024_2 | SOURCEANDSINK | K1 2
Port_1229018_1 | SOURCEANDSINK | K1 2
Port_1229095_1 | SOURCEANDSINK | K1 2
Port_1229032_0 | SOURCEANDSINK | K1 2
Port_1229101_2 | SOURCEANDSINK | K1 2
Port_1229032_1 | SOURCEANDSINK | K1 2
Port_1229093_0 | SOURCEANDSINK | K1 2
Port_1229095_2 | SOURCEANDSINK | K1 2
Port_1229093_1 | SOURCEANDSINK | K1 2
Port_1229101_1 | SOURCEANDSINK | K1 2
Port_1229342_0 | SOURCEANDSINK | K1 2
Port_1229356_2 | SOURCEANDSINK | K1 2
Port_1229342_1 | SOURCEANDSINK | K1 2
Port_1229402_1 | SOURCEANDSINK | K1 2
Port_1229348_1 | SOURCEANDSINK | K1 2
Port_1229349_1 | SOURCEANDSINK | K1 2
Port_1229348_3 | SOURCEANDSINK | K1 2
Port_1229356_1 | SOURCEANDSINK | K1 2
Port_1229400_0 | SOURCEANDSINK | K1 2
Port_1229402_2 | SOURCEANDSINK | K1 2
Port_1229400_1 | SOURCEANDSINK | K1 2
Port_1229441_1 | SOURCEANDSINK | K1 2
Port_1229441_2 | SOURCEANDSINK | K1 2
Port_1229449_0 | SOURCEANDSINK | K1 2
Port_1229449_1 | SOURCEANDSINK | K1 2
Port_1229480_0 | SOURCEANDSINK | K1 2
Port_1229490_3 | SOURCEANDSINK | K1 2
Port_1229480_1 | SOURCEANDSINK | K1 2
Port_1229545_1 | SOURCEANDSINK | K1 2
Port_1229490_1 | SOURCEANDSINK | K1 2
Port_1229491_1 | SOURCEANDSINK | K1 2
Port_1229500_0 | SOURCEANDSINK | K1 2
Port_1229553_2 | SOURCEANDSINK | K1 2
Port_1229500_1 | SOURCEANDSINK | K1 2
Port_1229543_0 | SOURCEANDSINK | K1 2
Port_1229545_2 | SOURCEANDSINK | K1 2
Port_1229543_1 | SOURCEANDSINK | K1 2
Port_1229553_1 | SOURCEANDSINK | K1 2
Port_1229613_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231476_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229613_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229667_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1312703_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229621_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229621_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231477_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229655_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229655_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229681_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229675_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229875_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229675_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229734_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229681_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230344_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229721_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229742_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229721_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229732_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229734_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229742_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229875_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229875_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231051_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1229876_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230938_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230004_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231050_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230004_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230087_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230079_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230087_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230079_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230304_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230290_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230304_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230325_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230911_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230325_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230343_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230344_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230343_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230939_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230343_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230912_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230353_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230371_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230379_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230860_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230903_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230860_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230911_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230901_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230901_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230903_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230911_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230912_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230926_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230938_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230926_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231003_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230938_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230939_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230948_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231009_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1230948_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231001_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231003_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231001_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231009_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231042_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231187_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231042_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231072_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231050_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231051_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231050_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231060_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231188_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231066_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231072_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231066_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231148_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231113_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231154_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231113_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231146_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231148_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231146_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231154_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231187_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231188_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231187_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231219_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231219_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231363_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231357_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231363_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231377_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231371_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231377_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231371_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231424_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231385_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231430_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231385_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231422_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231424_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231430_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231464_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231476_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231464_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231490_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231476_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231477_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231484_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232074_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231484_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231653_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231490_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231744_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231605_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231653_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231605_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231644_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231687_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231706_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231687_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231696_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231698_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231696_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231706_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231698_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231699_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231698_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231925_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231699_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231743_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231727_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231743_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231727_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231834_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231743_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231744_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231832_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231834_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231832_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231924_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231925_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231924_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232075_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231924_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231934_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231946_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231940_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231946_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231940_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231996_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231994_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231996_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1231994_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232002_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232002_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232033_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 54
Port_1232033_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 54
Port_1232060_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232260_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232090_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232074_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232075_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232074_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232261_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232084_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232090_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232084_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232136_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232098_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232142_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232098_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232134_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232136_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232134_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232142_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232252_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232260_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232252_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232274_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232261_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232268_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232439_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232268_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232274_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232440_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232282_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232363_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232355_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232357_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232355_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232363_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232405_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 55
Port_1232405_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 55
Port_1232431_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232439_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232431_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232453_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232439_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232440_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232447_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232453_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232447_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235468_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232546_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232547_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232546_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233382_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232547_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232567_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233381_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232567_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232581_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232575_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232892_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232575_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232595_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232581_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233287_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232589_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232774_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232589_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232667_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232595_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232775_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232665_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232667_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232665_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232750_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232772_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232774_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232772_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232782_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232774_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232775_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232782_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232882_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232892_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232906_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232892_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232893_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232893_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236422_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232900_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232906_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232900_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232962_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232914_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232970_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232914_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232960_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232962_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232960_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1232970_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233176_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233217_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233176_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233191_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233193_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233217_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233193_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233194_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233193_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236423_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233194_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233286_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233271_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233296_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233271_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233284_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233286_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233296_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233286_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233287_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233317_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 56
Port_1233317_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 56
Port_1233370_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233389_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233379_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233381_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233379_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233389_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233381_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233382_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233442_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234780_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233442_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233813_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233450_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233450_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233451_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233450_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233868_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233811_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233813_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233811_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233857_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233867_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233857_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233945_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233867_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233868_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233867_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234061_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233943_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233945_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1233943_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234052_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234345_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234052_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234627_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234061_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234060_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234781_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234060_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234346_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234070_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234627_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234070_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234244_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234242_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234244_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234242_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234250_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234250_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234337_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234353_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234337_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234345_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234346_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234345_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234353_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234458_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234460_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234458_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234499_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234499_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234627_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234640_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234640_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234656_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234650_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234656_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234650_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234703_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234664_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234709_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234701_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234703_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234701_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234709_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234780_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234781_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234780_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234788_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234788_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234800_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234800_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234808_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1234808_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235315_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235309_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235315_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235309_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235354_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235356_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235354_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235467_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235467_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235639_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235639_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235724_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235714_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236139_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235714_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235850_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235724_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235935_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235848_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235850_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235848_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235924_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235934_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235924_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235950_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235934_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235935_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235934_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236140_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235944_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235950_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235944_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236075_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235958_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236081_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1235958_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236073_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236075_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236073_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236081_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236111_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 57
Port_1236111_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 57
Port_1236131_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236149_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236131_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236161_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236139_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236140_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236139_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236149_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236155_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236161_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236155_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236284_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236202_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236290_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236202_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236282_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236284_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236282_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236290_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236390_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 58
Port_1236390_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 58
Port_1236410_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236422_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236438_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236422_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236423_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236432_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236438_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236432_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236452_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236446_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236677_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236504_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236452_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236678_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236491_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236580_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236491_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236502_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236504_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236502_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236580_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236604_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 59
Port_1236604_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 59
Port_1236669_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236677_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236669_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1237032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236677_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236685_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1237032_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1236685_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 1
Port_1237092_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237127_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237092_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237093_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237092_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237093_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237126_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241059_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237126_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237127_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237126_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239632_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237296_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238504_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237296_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237314_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237308_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237504_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237308_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237328_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237314_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237715_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237322_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237445_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237322_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237328_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237446_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237370_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237417_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237407_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237434_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237453_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237434_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237443_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237445_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237443_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237453_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237445_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237446_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237492_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237504_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237492_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237540_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237504_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237505_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237633_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237512_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237546_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237512_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237538_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237540_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237621_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237633_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237621_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237633_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237634_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237634_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237714_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237643_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237678_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237643_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237670_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237672_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237670_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237678_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237714_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237715_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237714_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237928_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238179_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237928_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237971_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237973_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237971_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238179_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1237973_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238494_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238504_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238494_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238520_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238504_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238514_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238520_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238514_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238600_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238528_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238606_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238528_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238598_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238600_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238598_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238606_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238660_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238806_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238660_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238735_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238733_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238735_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238733_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238771_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238792_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238806_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238792_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238822_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238806_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238807_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238807_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239631_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238822_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239333_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238830_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239044_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238830_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238974_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238972_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238974_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1238972_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239023_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239036_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239169_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239060_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239045_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239044_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239294_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239045_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239332_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239054_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239060_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239054_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239106_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239068_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239112_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239068_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239104_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239106_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239104_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239112_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239155_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239169_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239155_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239183_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239169_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239170_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239170_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239293_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239177_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239183_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239177_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239252_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239191_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239258_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239250_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239252_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239250_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239258_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239280_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239301_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239280_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239291_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239293_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239291_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239301_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239293_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239294_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239322_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239332_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239322_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239348_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239332_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239333_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239342_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239505_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239342_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239390_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239348_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239506_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239356_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239396_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239388_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239390_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239388_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239396_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239491_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239505_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239491_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239519_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239505_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239506_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239513_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239519_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239513_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239596_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239527_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239602_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239527_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239594_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239596_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239594_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239602_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239623_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240175_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239623_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239688_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239631_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239632_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239631_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240357_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239686_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239688_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239686_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239732_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239745_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240206_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239745_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240175_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239777_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240167_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239777_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239831_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239791_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239837_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239791_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239829_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239831_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239829_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1239837_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240167_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240207_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240175_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240176_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240176_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240356_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240198_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240206_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240198_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240245_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240206_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240207_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240212_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240251_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240212_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240243_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240245_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240243_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240251_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240279_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 60
Port_1240279_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 60
Port_1240338_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240356_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240338_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240370_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240356_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240357_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240364_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240370_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240364_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240417_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240411_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240417_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240411_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240462_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240460_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240462_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240460_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1240468_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241032_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241058_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241032_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241092_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241058_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1304158_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241058_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241059_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241078_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1243832_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241078_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241193_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241092_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241260_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241191_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241193_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241191_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241228_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241249_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241259_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241249_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241297_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241260_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241259_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241369_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241267_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241305_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241267_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241295_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241297_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241295_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241305_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241326_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241538_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241326_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241410_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241368_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241369_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241368_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242355_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241368_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241665_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241378_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241410_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241378_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241468_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241418_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241474_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241418_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241466_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241468_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241466_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241474_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241496_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241538_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241496_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241622_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241538_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241539_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241539_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241664_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241546_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241628_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241546_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241620_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241622_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241620_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241628_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241658_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241664_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241658_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241720_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241664_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241665_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241672_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241726_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241672_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241718_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241720_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241718_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241726_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241801_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241809_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241801_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241823_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241809_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241810_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241809_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242038_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241810_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242278_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241817_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241823_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241817_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241876_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241831_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241882_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241831_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241874_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241876_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241874_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241882_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1241903_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
Port_1242447_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 2
