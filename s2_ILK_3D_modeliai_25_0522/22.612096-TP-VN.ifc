Properties of the parts of a building model (IFC2X3), part 28 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1447753_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447610_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447612_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447616_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 9
Port_1447616_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 9
Port_1447627_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447736_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447627_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447650_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447693_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447650_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447687_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447689_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447687_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447693_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447736_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 8
Port_1447753_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463696_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447890_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463695_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447890_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447905_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463695_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447905_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1447920_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447920_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447969_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447926_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447926_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448010_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447928_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447971_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447928_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447967_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447969_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447967_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1447971_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448001_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448009_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448001_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448009_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448010_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 10
Port_1448150_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448156_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448150_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448168_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448156_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448157_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448160_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448168_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448160_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448232_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448170_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448236_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448170_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448228_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448230_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448230_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448232_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448267_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448277_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448267_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448291_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448277_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448278_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448285_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448291_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448285_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448340_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448338_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448340_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448338_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448342_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448342_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448749_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448708_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448748_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448708_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448730_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448748_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448730_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448748_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448749_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448822_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1448846_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1448822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1448846_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1448847_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1448907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449176_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448953_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448917_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449478_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448917_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448918_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448917_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449284_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448921_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448953_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448921_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448963_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448957_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448963_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448957_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448973_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448965_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448973_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448965_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448981_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448975_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448981_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448975_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449025_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448983_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449029_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448983_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449023_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449025_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449029_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449047_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449065_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449047_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449080_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449177_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449066_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449066_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449069_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449080_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449110_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449082_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449112_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449082_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449108_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449110_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449108_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449112_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449158_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449176_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449158_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449245_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449176_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449177_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449180_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449249_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449180_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449243_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449245_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449249_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449267_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449283_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449267_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449295_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449283_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449371_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449283_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449287_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449295_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449287_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449336_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449297_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449340_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449297_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449334_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449336_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449334_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449340_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449360_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449370_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449386_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449370_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449371_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449374_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449386_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449374_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449436_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449388_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449440_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449388_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449432_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449434_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449432_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449440_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449434_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449436_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449477_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449478_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449477_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449481_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449481_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449501_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449487_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449501_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449571_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449563_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472703_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1479228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449571_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450200_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449813_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449821_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449813_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449839_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449821_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449822_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449825_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449839_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449825_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449873_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449858_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 2
Port_1449877_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 2
Port_1449858_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 2
Port_1449873_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472561_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449877_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 2
Port_1450147_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1472560_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1450147_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1479179_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1450193_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450199_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450193_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450228_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450199_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450199_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1472704_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450218_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450226_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450218_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450274_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450226_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450228_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450232_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450429_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450232_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450304_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450274_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451077_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450276_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450381_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450276_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450345_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450302_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450382_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450302_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450304_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450308_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450347_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450308_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450343_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450345_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450343_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450347_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450368_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450385_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450368_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450379_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450381_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450379_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450385_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450381_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450421_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450429_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450421_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450483_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450429_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450430_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450430_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450433_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450487_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450481_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450483_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450481_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450503_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450511_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450503_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450521_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450511_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450512_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450512_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451076_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450515_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450521_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450515_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450531_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450523_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450655_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450523_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450539_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450912_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450533_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450539_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450533_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450621_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450541_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450625_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450541_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450619_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450621_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450619_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450625_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450643_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450655_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450643_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450667_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450655_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450656_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450656_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451008_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450659_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450675_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450669_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450675_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450669_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450714_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450677_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450718_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450677_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450712_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450714_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450712_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450718_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450742_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450754_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450742_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450789_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450754_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451009_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450754_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450755_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450755_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450911_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450758_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450793_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450758_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450787_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450789_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450787_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450793_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450897_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450911_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450897_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450926_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450911_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450912_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450915_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450926_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450915_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450928_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450984_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450928_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450978_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450980_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450978_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1450984_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451000_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451008_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451000_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451046_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451008_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451009_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451012_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451050_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451012_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451044_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451046_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451044_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451050_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451068_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451076_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451068_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451086_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451076_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451077_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451080_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451086_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451080_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451096_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451088_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451096_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451088_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451129_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451098_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451133_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451098_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451127_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451129_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451127_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451133_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451189_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474221_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451189_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457109_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451200_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1474220_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451200_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451264_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451238_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1476252_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1476279_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451264_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1476252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451291_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474274_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451304_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1474273_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451304_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451383_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451383_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1476564_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451415_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451423_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451415_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451431_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451425_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451431_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451425_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451441_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451433_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459489_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451467_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451441_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1459490_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451443_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456670_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451443_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451477_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451467_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456671_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451469_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451469_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451485_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451477_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1456526_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451479_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451485_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451479_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451499_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451499_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452136_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451589_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461048_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452135_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451614_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451761_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451618_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451624_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451618_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451624_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451946_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451727_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453564_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451727_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451728_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451727_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451772_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451728_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453400_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451761_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451958_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451955_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451782_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451955_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451782_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451957_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451946_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451957_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451957_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451958_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452121_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452135_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452121_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452147_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452135_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452136_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452139_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452147_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452139_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452159_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452149_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452346_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452149_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452182_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452157_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452159_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452157_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452686_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452163_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452184_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452163_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452245_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452182_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452184_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452188_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452279_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452188_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452243_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452245_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452279_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452326_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452346_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452326_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452358_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452346_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452347_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452347_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452536_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452350_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452350_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452368_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452360_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452368_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452370_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452410_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452370_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452404_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452406_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452404_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452410_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452425_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452433_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452425_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452508_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452433_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452537_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452433_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452434_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452434_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452607_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452437_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452512_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452437_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452506_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452508_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452506_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452512_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452528_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452536_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452528_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452576_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452536_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452537_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452540_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452580_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452540_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452574_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452576_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452574_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452580_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452599_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453367_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452599_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452659_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452607_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452608_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452607_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453368_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452608_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452685_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452611_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452661_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452611_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452657_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452659_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452657_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452661_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452677_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452755_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452677_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452721_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452685_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452686_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452685_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452756_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452689_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452723_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452719_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452721_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452719_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452723_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452747_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452755_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452747_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452769_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452755_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452756_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452759_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452771_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452759_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452771_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452775_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452819_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452775_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452813_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452815_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452813_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452819_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1452915_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452933_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452915_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452974_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452933_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452934_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452966_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452974_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452966_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453131_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452998_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453131_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452998_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453131_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453337_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453142_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453336_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453142_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453158_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453152_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453158_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453152_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453176_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453160_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453176_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453160_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453184_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453178_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453184_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453178_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453194_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453186_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453194_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453186_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453202_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453196_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453202_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453196_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453220_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453204_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453220_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453204_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453228_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453222_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457154_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453222_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453305_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453228_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1457155_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453297_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453305_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453297_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
InPort_1453324_0 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453336_3 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1453348_2 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453324_1 | SOURCE | vanduo karštas apytakinis - T4 1
Port_1453336_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1453337_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
InPort_1453340_0 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453348_1 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1453375_1 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453340_1 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1453371_2 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453350_0 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1453350_1 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453375_2 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1453365_0 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453367_3 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1453365_1 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1453371_1 | SOURCE | vanduo karštas apytakinis - T4 1
Port_1453367_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453368_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453386_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453400_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453386_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453470_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453400_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453401_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453406_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453474_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453406_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453468_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453470_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453468_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453474_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453555_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453563_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453555_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453618_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453563_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461049_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453563_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453564_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453569_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453622_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453569_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453616_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453618_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453616_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453622_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453691_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453707_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453691_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453719_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453707_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453708_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453893_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453711_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453805_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453711_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453765_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453719_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453806_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453721_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453769_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453721_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453763_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453765_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453763_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453799_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453805_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453799_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453859_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453805_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453806_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453809_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453863_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453809_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453857_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453859_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453857_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453863_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453881_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453893_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453893_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453894_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453894_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453975_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453897_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453941_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453897_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453935_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453937_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453935_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453941_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453965_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453975_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453965_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454024_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453975_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453976_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453976_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454061_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453979_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454028_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453979_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454022_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454024_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454022_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454028_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454049_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454061_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454049_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454103_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454061_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454062_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454062_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454141_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454065_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454107_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454101_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454103_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454101_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454107_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454125_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454238_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454125_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454156_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454141_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454142_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454141_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454312_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454142_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460282_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454145_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454156_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454145_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454164_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454158_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454164_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454158_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454208_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454166_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454212_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454166_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454206_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454208_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454206_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454212_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454230_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454238_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454230_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454280_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454238_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454239_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454239_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454311_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454242_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454284_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454242_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454278_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454280_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454278_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454284_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454303_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454311_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454303_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454356_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454311_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454315_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454360_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454315_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454354_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454356_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454354_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454360_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454376_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454388_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454376_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454430_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454388_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454461_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454388_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454389_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454389_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454845_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454392_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454434_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454392_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454428_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454430_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454428_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454434_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454460_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1460283_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454460_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454461_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454460_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454614_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454464_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454692_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454464_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454529_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454521_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454529_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454521_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454580_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454531_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454582_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1454531_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
