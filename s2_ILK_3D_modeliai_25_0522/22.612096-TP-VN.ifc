Properties of the parts of a building model (IFC2X3), part 45 of 57

# IfcFlowFitting: PIF_Tigris_Super_Tee_Wavin:Standard SuperTee (1063)
Name (PIF_Tigris_Super_Tee_Wavin:Standard SuperTee:...) | In | Material | Group
1456917 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457003 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457108 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457154 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1457309 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457402 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457513 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457594 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457670 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1457748 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457864 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1457928 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458005 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458105 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1458246 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458374 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458463 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458547 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458616 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458697 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458832 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1458983 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459082 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459209 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459306 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1459403 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459489 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459587 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459649 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459761 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459877 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1459905 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460041 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460146 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460206 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460282 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460440 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460530 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460613 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460694 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460765 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1460850 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461194 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461307 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461414 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461483 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461570 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461675 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1461978 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462055 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462165 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462255 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462345 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462490 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462562 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462632 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462741 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1462849 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1463183 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1463219 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1463492 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1463695 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1464065 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1464196 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1464311 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1464390 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1464476 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1464665 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1464859 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo karštas tiekiamasis - T3 1
1465006 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1465138 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1465219 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1465288 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1465757 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1465881 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1465964 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466053 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466142 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466233 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466383 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466494 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466668 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1466736 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1466850 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1467204 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1467533 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1467561 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1467687 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1467780 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1467801 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo karštas tiekiamasis - T3 1
1468039 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1468717 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1468886 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1468980 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1469084 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo karštas tiekiamasis - T3 1
1469328 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 11
1469409 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 11
1469518 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 11
1469655 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 11
1469753 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 11
1469835 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 11
1470119 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1470213 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1470303 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1470420 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1470503 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1470599 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1470671 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1470807 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1471257 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo karštas tiekiamasis - T3 1
1471543 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1471573 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1471808 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1472073 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1472147 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1472187 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1472280 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1472389 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100 | vanduo karštas apytakinis - T4 1
1472560 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1473380 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1473456 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1473527 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1473601 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1473704 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1473784 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1473895 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1474002 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1474091 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1474273 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1474879 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1474992 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475061 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475159 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475254 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475326 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475522 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475618 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475759 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475880 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1475960 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1476023 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1476087 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1477160 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477320 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477428 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477500 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477612 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477791 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477855 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1477950 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478136 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478213 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478316 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478366 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478429 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478548 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478676 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478803 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1478976 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1479076 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1479113 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1479488 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1479765 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1479865 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1479939 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480009 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480105 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480237 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480314 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480398 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480470 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480577 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480693 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480808 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480894 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1480976 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1481269 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1481567 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1481734 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1481848 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1481939 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482036 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482110 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482264 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482359 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482435 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482534 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482628 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482744 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482844 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1482984 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483055 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483134 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483300 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483433 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1483592 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483697 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483773 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483859 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1483924 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484026 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484061 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484089 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484250 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484331 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484404 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484496 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484599 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484734 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484804 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484877 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1484959 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1485075 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1485356 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1485561 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1485669 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1485763 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1485833 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1485944 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486009 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486085 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486196 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486224 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486328 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486358 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486465 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486547 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486629 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486662 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1486857 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1487165 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487293 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487391 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487466 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487548 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487686 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487840 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1487915 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1488013 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1488122 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1488154 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1488226 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1488301 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1488388 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1488641 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1488690 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1488726 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1489351 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1489442 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1489522 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1489600 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1489672 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1489750 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1489832 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1489906 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1490004 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1490171 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1490291 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1490559 | 2 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1490900 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1490986 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1491135 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491220 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491302 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491385 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491458 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491537 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491613 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo šaltas - V1 2
1491638 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491705 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 13
1491824 | 3 a | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1491900 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492088 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492119 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1492177 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492322 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492426 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492521 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492655 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492743 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492863 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1492943 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493067 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493179 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493317 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493414 | 4 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1493634 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493727 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493835 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1493938 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1494022 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1494141 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1494326 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1
1494674 | 5 a V1 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas tiekiamasis - T3 1
1494760 | 1 a +-152.84 | <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T | vanduo karštas apytakinis - T4 1

# IfcFlowFitting: PIF_Tigris_Super_Tee_Wavin:Standard SuperTee (128)
Type - Description: Branch; PredefinedType: JUNCTION; Material: Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T, PE-X, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 53.11 Uniformat (Uniformat); Material: PE-X, White, RAL 9100, <Unnamed>, Steel WVN-T, PPSU-K5, Blue, RAL5100, Brass WVN-T
Pset_DistributionFlowElementCommon - Reference: Standard SuperTee; sets with these values: 2
Name (PIF_Tigris_Super_Tee_Wavin:Standard SuperTee:...) | In | Group
1339795 | 2 a | vanduo šaltas - V1 2
1341827 | 2 a | vanduo šaltas - V1 2
1345218 | 2 a | vanduo šaltas - V1 2
1349360 | 4 a V1 | vanduo šaltas - V1 2
1351786 | 4 a V1 | vanduo šaltas - V1 2
1352266 | 4 a V1 | vanduo šaltas - V1 2
1352822 | 2 a | vanduo šaltas - V1 2
1357234 | 1 a +-152.84 | vanduo šaltas - V1 2
1358779 | 2 a | vanduo šaltas - V1 2
1360317 | 2 a | vanduo šaltas - V1 2
1361464 | 2 a | vanduo šaltas - V1 2
1362085 | 2 a | vanduo šaltas - V1 2
1363356 | 3 a | vanduo šaltas - V1 2
1364400 | 2 a | vanduo šaltas - V1 2
1366308 | 2 a | vanduo šaltas - V1 2
1366856 | 2 a | vanduo šaltas - V1 2
1369043 | 2 a | vanduo šaltas - V1 2
1370620 | 2 a | vanduo šaltas - V1 2
1370822 | 2 a | vanduo šaltas - V1 2
1371147 | 2 a | vanduo šaltas - V1 2
1371280 | 2 a | vanduo šaltas - V1 2
1372232 | 2 a | vanduo šaltas - V1 2
1373723 | 2 a | vanduo šaltas - V1 2
1374600 | 2 a | vanduo šaltas - V1 2
1389440 | 2 a | vanduo šaltas - V1 2
1390716 | 2 a | vanduo šaltas - V1 2
1390787 | 2 a | vanduo šaltas - V1 2
1392238 | 2 a | vanduo šaltas - V1 2
1392320 | 2 a | vanduo šaltas - V1 2
1393361 | 2 a | vanduo šaltas - V1 2
1395062 | 2 a | vanduo šaltas - V1 2
1395707 | 1 a +-152.84 | vanduo šaltas - V1 2
1396198 | 2 a | vanduo šaltas - V1 2
1396380 | 2 a | vanduo šaltas - V1 2
1396674 | 1 a +-152.84 | vanduo šaltas - V1 2
1397277 | 2 a | vanduo šaltas - V1 2
1400455 | 1 a +-152.84 | vanduo šaltas - V1 2
1400913 | 1 a +-152.84 | vanduo šaltas - V1 2
1401734 | 1 a +-152.84 | vanduo šaltas - V1 2
1402470 | 1 a +-152.84 | vanduo šaltas - V1 2
1403176 | 1 a +-152.84 | vanduo šaltas - V1 2
1403626 | 1 a +-152.84 | vanduo šaltas - V1 2
1404166 | 1 a +-152.84 | vanduo šaltas - V1 2
1407334 | 1 a +-152.84 | vanduo šaltas - V1 2
1407563 | 1 a +-152.84 | vanduo šaltas - V1 2
1408247 | 1 a +-152.84 | vanduo šaltas - V1 2
1409068 | 1 a +-152.84 | vanduo šaltas - V1 2
1420428 | 0 a | vanduo šaltas - V1 2
1420786 | 0 a | vanduo šaltas - V1 2
1420939 | 0 a | vanduo šaltas - V1 2
1421050 | 0 a | vanduo šaltas - V1 2
1421146 | 0 a | vanduo šaltas - V1 2
1421267 | 0 a | vanduo šaltas - V1 2
1421360 | 0 a | vanduo šaltas - V1 2
1421495 | 0 a | vanduo šaltas - V1 2
1421931 | 0 a | vanduo šaltas - V1 2
1422048 | 0 a | vanduo šaltas - V1 2
1422171 | 0 a | vanduo šaltas - V1 2
1422281 | 0 a | vanduo šaltas - V1 2
1422393 | 0 a | vanduo šaltas - V1 2
1422735 | 0 a | vanduo šaltas - V1 2
1423005 | 0 a | vanduo šaltas - V1 2
1423195 | 0 a | vanduo šaltas - V1 2
1423356 | 0 a | vanduo šaltas - V1 2
1423532 | 0 a | vanduo šaltas - V1 2
1423777 | 0 a | vanduo šaltas - V1 2
1424033 | 0 a | vanduo šaltas - V1 2
1424090 | 0 a | vanduo šaltas - V1 2
1424159 | 0 a | vanduo šaltas - V1 2
1424201 | 0 a | vanduo šaltas - V1 2
1424301 | 0 a | vanduo šaltas - V1 2
1424357 | 0 a | vanduo šaltas - V1 2
1424409 | 0 a | vanduo šaltas - V1 2
1428502 | 0 a | vanduo karštas tiekiamasis - T3 1
1428639 | 0 a | vanduo karštas tiekiamasis - T3 1
1428699 | 0 a | vanduo karštas tiekiamasis - T3 1
1428807 | 0 a | vanduo karštas tiekiamasis - T3 1
1428955 | 0 a | vanduo karštas tiekiamasis - T3 1
1429252 | 0 a | vanduo karštas tiekiamasis - T3 1
1429479 | 0 a | vanduo karštas tiekiamasis - T3 1
1429653 | 0 a | vanduo karštas tiekiamasis - T3 1
1429737 | 0 a | vanduo karštas tiekiamasis - T3 1
1429849 | 0 a | vanduo karštas tiekiamasis - T3 1
1429980 | 0 a | vanduo karštas tiekiamasis - T3 1
1430113 | 0 a | vanduo karštas tiekiamasis - T3 1
1430690 | 0 a | vanduo karštas tiekiamasis - T3 1
1431191 | 0 a | vanduo karštas tiekiamasis - T3 1
1431382 | 0 a | vanduo karštas tiekiamasis - T3 1
1431647 | 0 a | vanduo karštas tiekiamasis - T3 1
1434225 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1434426 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435139 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1435708 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1436600 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437013 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1437529 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1438855 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1438955 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439165 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439287 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439523 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1439730 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1440126 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1441103 | 2 a | vanduo karštas tiekiamasis - T3 1
1441805 | 2 a | vanduo karštas tiekiamasis - T3 1
1442204 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1443857 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1448277 | 2 a | vanduo karštas apytakinis - T4 1
1451291 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1452933 | 2 a | vanduo karštas apytakinis - T4 1
1453400 | 2 a | vanduo karštas tiekiamasis - T3 1
1453563 | 2 a | vanduo karštas tiekiamasis - T3 1
1461048 | 2 a | vanduo karštas tiekiamasis - T3 1
1461814 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1463031 | 2 a | vanduo karštas tiekiamasis - T3 1
1463292 | 2 a | vanduo karštas tiekiamasis - T3 1
1463403 | 2 a | vanduo karštas tiekiamasis - T3 1
1463532 | 2 a | vanduo karštas tiekiamasis - T3 1
1464631 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1465483 | 2 a | vanduo karštas apytakinis - T4 1
1467003 | 1 a +-152.84 | vanduo karštas apytakinis - T4 1
1468208 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1469923 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1472703 | 2 a | vanduo karštas tiekiamasis - T3 1
1474220 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1483397 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1485331 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1
1486825 | 1 a +-152.84 | vanduo karštas tiekiamasis - T3 1

# IfcFlowFitting: Z_PIF_AS+_Bend_For_Branch_Wavin_(nested):socket_end (715)
Type - Description: Bend; PredefinedType: JUNCTION; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket_end; sets with these values: 2
Name (Z_PIF_AS+_Bend_For_Branch_Wavin_(nested):socket_end:...) | In
1104313 | 0 a
1104543 | 0 a
1104770 | 0 a
1104890 | 0 a
1105077 | 0 a
1107128 | 0 a
1107755 | 0 a
1108244 | 0 a
1111250 | 2 a
1111304 | 2 a
1111336 | 2 a
1111610 | 2 a
1111642 | 2 a
1111674 | 2 a
1118917 | 4 a V1
1119212 | 5 a V1
1119353 | 4 a V1
1119587 | 5 a V1
1119889 | 5 a V1
1121139 | 4 a V1
1121262 | 5 a V1
1121328 | 5 a V1
1127494 | 4 a V1
1127986 | 5 a V1
1128103 | 4 a V1
1128145 | 4 a V1
1128224 | 4 a V1
1128806 | 4 a V1
1128886 | 4 a V1
1129459 | 4 a V1
1129677 | 4 a V1
1129744 | 4 a V1
1129834 | 4 a V1
1129976 | 4 a V1
1130190 | 4 a V1
1130319 | 4 a V1
1130775 | 4 a V1
1131316 | 4 a V1
1131584 | 5 a V1
1139420 | 5 a V1
1139654 | 5 a V1
1140048 | 5 a V1
1140674 | 4 a V1
1141374 | 5 a V1
1142819 | 5 a V1
1143195 | 0 a
1143514 | 5 a V1
1143907 | 5 a V1
1144131 | 5 a V1
1144403 | 5 a V1
1144536 | 5 a V1
1144655 | 5 a V1
1145403 | 5 a V1
1145464 | 5 a V1
1145848 | 5 a V1
1151787 | 4 a V1
1151893 | 4 a V1
1152006 | 4 a V1
1152458 | 4 a V1
1152822 | 4 a V1
1153065 | 4 a V1
1153205 | 4 a V1
1153535 | 4 a V1
1153720 | 4 a V1
1154255 | 4 a V1
1155952 | 4 a V1
1156126 | 4 a V1
1156341 | 4 a V1
1156570 | 4 a V1
1156815 | 4 a V1
1157021 | 4 a V1
1157228 | 4 a V1
1157293 | 4 a V1
1157494 | 4 a V1
1158114 | 4 a V1
1158273 | 4 a V1
1158545 | 4 a V1
1158700 | 4 a V1
1159094 | 4 a V1
1159235 | 4 a V1
1159582 | 4 a V1
1159736 | 4 a V1
1159851 | 4 a V1
1160019 | 4 a V1
1160320 | 4 a V1
1160431 | 4 a V1
1160617 | 4 a V1
1160736 | 4 a V1
1160906 | 4 a V1
1163084 | 4 a V1
1163547 | 4 a V1
1165575 | 4 a V1
1166251 | 4 a V1
1166780 | 4 a V1
1167063 | 4 a V1
1167267 | 4 a V1
1167442 | 4 a V1
1167637 | 4 a V1
1167850 | 4 a V1
1169381 | 5 a V1
1169611 | 4 a V1
1169784 | 4 a V1
1170025 | 4 a V1
1170476 | 4 a V1
1170589 | 4 a V1
1170754 | 4 a V1
1170870 | 4 a V1
1170979 | 4 a V1
1171222 | 4 a V1
1171342 | 4 a V1
1171518 | 4 a V1
1171856 | 4 a V1
1171988 | 4 a V1
1172297 | 4 a V1
1172611 | 4 a V1
1172732 | 4 a V1
1173149 | 4 a V1
1173291 | 4 a V1
1173491 | 4 a V1
1173625 | 4 a V1
1173771 | 4 a V1
1173923 | 4 a V1
1174042 | 4 a V1
1174190 | 4 a V1
1174313 | 4 a V1
1174540 | 4 a V1
1174720 | 4 a V1
1174856 | 4 a V1
1176341 | 4 a V1
1176810 | 4 a V1
1177060 | 5 a V1
1177147 | 4 a V1
1177308 | 4 a V1
1177561 | 4 a V1
1177893 | 4 a V1
1178248 | 4 a V1
1178404 | 4 a V1
1178586 | 4 a V1
1179043 | 4 a V1
1179408 | 4 a V1
1179906 | 4 a V1
1180130 | 4 a V1
1180277 | 4 a V1
1180625 | 4 a V1
1180709 | 4 a V1
1180806 | 4 a V1
1180913 | 4 a V1
1182392 | 0 a
1183057 | 4 a V1
1183230 | 5 a V1
1183310 | 5 a V1
1183485 | 4 a V1
1183781 | 4 a V1
1183924 | 4 a V1
1184060 | 4 a V1
1184312 | 4 a V1
1185443 | 4 a V1
1186147 | 4 a V1
1186412 | 4 a V1
1186565 | 4 a V1
1186663 | 4 a V1
1186887 | 4 a V1
1187128 | 4 a V1
1187260 | 4 a V1
1187478 | 4 a V1
1187618 | 4 a V1
1187726 | 4 a V1
1187962 | 4 a V1
1188270 | 4 a V1
1188412 | 4 a V1
1188710 | 4 a V1
1188849 | 4 a V1
1189179 | 4 a V1
1189476 | 4 a V1
1189647 | 4 a V1
1189844 | 4 a V1
1190025 | 4 a V1
1190335 | 4 a V1
1190641 | 4 a V1
1190938 | 4 a V1
1191179 | 4 a V1
1191324 | 4 a V1
1191501 | 4 a V1
1191690 | 4 a V1
1191810 | 4 a V1
1192009 | 4 a V1
1192114 | 4 a V1
1192292 | 4 a V1
1192403 | 4 a V1
1192485 | 4 a V1
1192692 | 4 a V1
1192875 | 4 a V1
1193227 | 4 a V1
1193400 | 4 a V1
1193814 | 4 a V1
1193894 | 4 a V1
1194065 | 4 a V1
1194414 | 4 a V1
1194583 | 4 a V1
1194726 | 4 a V1
1194862 | 4 a V1
1195083 | 4 a V1
1195172 | 4 a V1
1195320 | 4 a V1
1195666 | 4 a V1
1196289 | 5 a V1
1196395 | 5 a V1
1196895 | 5 a V1
1197242 | 5 a V1
1197487 | 5 a V1
1197617 | 4 a V1
1198371 | 4 a V1
1198799 | 4 a V1
1198838 | 4 a V1
1199123 | 4 a V1
1199482 | 4 a V1
1200121 | 4 a V1
1200330 | 4 a V1
1200453 | 4 a V1
1201035 | 4 a V1
1201157 | 4 a V1
1201256 | 4 a V1
1201353 | 4 a V1
1201649 | 4 a V1
1201766 | 4 a V1
1201824 | 4 a V1
1201992 | 4 a V1
1202341 | 4 a V1
1202411 | 4 a V1
1202688 | 4 a V1
1202944 | 4 a V1
1202999 | 4 a V1
1203103 | 4 a V1
1203217 | 4 a V1
1203312 | 4 a V1
1203410 | 4 a V1
1203534 | 4 a V1
1203619 | 4 a V1
1203723 | 4 a V1
1203932 | 4 a V1
1204071 | 4 a V1
1204177 | 4 a V1
1204288 | 4 a V1
1204613 | 4 a V1
1204689 | 4 a V1
1204804 | 4 a V1
1205306 | 4 a V1
1205439 | 4 a V1
1205807 | 4 a V1
1205970 | 4 a V1
1206277 | 4 a V1
1206496 | 4 a V1
1206739 | 4 a V1
1207026 | 4 a V1
1209677 | 4 a V1
1210040 | 3 a
1210520 | 3 a
1210683 | 3 a
1210915 | 3 a
1211082 | 3 a
1212948 | 4 a V1
1213288 | 3 a
1213637 | 3 a
1213904 | 3 a
1217143 | 3 a
1217408 | 3 a
1217624 | 3 a
1218132 | 4 a V1
1218345 | 3 a
1218461 | 3 a
1218630 | 3 a
1218739 | 3 a
1219535 | 3 a
1220511 | 0 a
1221194 | 4 a V1
1222904 | 3 a
1223115 | 3 a
1223296 | 3 a
1223524 | 3 a
1223807 | 3 a
1224034 | 3 a
1224267 | 4 a V1
1224431 | 3 a
1224749 | 4 a V1
1225321 | 3 a
1225527 | 3 a
1225694 | 3 a
1225798 | 3 a
1227504 | 2 a
1227987 | 4 a V1
1228161 | 3 a
1228330 | 3 a
1228483 | 3 a
1228617 | 3 a
1228833 | 4 a V1
1229012 | 3 a
1229352 | 3 a
1229494 | 3 a
1229627 | 4 a V1
1229879 | 3 a
1230347 | 3 a
1230915 | 3 a
1230942 | 3 a
1231054 | 3 a
1231215 | 3 a
1231480 | 3 a
1231702 | 3 a
1231747 | 3 a
1231928 | 3 a
1232078 | 3 a
1232264 | 3 a
1232443 | 3 a
1232552 | 4 a V1
1232778 | 3 a
1232896 | 3 a
1233211 | 3 a
1233290 | 3 a
1233385 | 3 a
1233456 | 4 a V1
1233871 | 3 a
1234064 | 3 a
1234349 | 3 a
1234629 | 3 a
1234784 | 3 a
1235485 | 4 a V1
1235938 | 3 a
1236143 | 3 a
1236426 | 3 a
1236681 | 3 a
1237096 | 4 a V1
1237130 | 4 a V1
1237449 | 3 a
1237508 | 3 a
1237637 | 3 a
1237718 | 3 a
1238508 | 3 a
1238810 | 3 a
1239048 | 3 a
1239173 | 3 a
1239297 | 3 a
1239336 | 3 a
1239509 | 3 a
1239635 | 3 a
1240179 | 3 a
1240210 | 3 a
1240360 | 3 a
1241062 | 4 a V1
1241263 | 2 a
1241372 | 2 a
1241542 | 2 a
1241668 | 2 a
1241813 | 2 a
1241915 | 2 a
1242041 | 2 a
1242282 | 2 a
1242358 | 2 a
1242451 | 2 a
1242549 | 2 a
1242854 | 2 a
1243836 | 2 a
1244201 | 2 a
1244397 | 2 a
1244734 | 2 a
1244993 | 2 a
1245534 | 2 a
1245698 | 2 a
1245911 | 2 a
1246067 | 2 a
1246232 | 2 a
1246379 | 2 a
1246571 | 2 a
1246778 | 2 a
1246977 | 2 a
1247327 | 2 a
1247600 | 4 a V1
1247940 | 2 a
1248080 | 2 a
1248105 | 2 a
1248194 | 2 a
1248303 | 2 a
1248429 | 2 a
1248630 | 2 a
1248770 | 2 a
1249047 | 2 a
1249457 | 4 a V1
1249600 | 2 a
1249838 | 4 a V1
1250097 | 2 a
1250199 | 2 a
1250669 | 4 a V1
1250950 | 4 a V1
1251039 | 2 a
1251157 | 2 a
1251314 | 2 a
1251429 | 2 a
1251531 | 2 a
1251805 | 2 a
1251927 | 2 a
1251970 | 2 a
1252047 | 2 a
1252185 | 2 a
1252356 | 4 a V1
1252407 | 2 a
1252782 | 2 a
1253317 | 2 a
1253464 | 2 a
1253649 | 2 a
1253762 | 2 a
1253906 | 4 a V1
1254146 | 2 a
1254304 | 2 a
1254454 | 2 a
1254704 | 2 a
1254830 | 2 a
1254958 | 2 a
1255077 | 2 a
1255210 | 2 a
1255374 | 2 a
1255745 | 2 a
1255910 | 2 a
1256101 | 2 a
1256235 | 2 a
1256585 | 4 a V1
1256808 | 2 a
1257198 | 2 a
1258018 | 2 a
1258206 | 2 a
1258415 | 2 a
1258501 | 2 a
1258624 | 2 a
1258735 | 2 a
1258849 | 2 a
1259195 | 2 a
1259883 | 2 a
1260099 | 2 a
1260554 | 2 a
1260900 | 2 a
1261073 | 2 a
1261128 | 2 a
1261296 | 2 a
1261866 | 2 a
1262013 | 2 a
1262544 | 2 a
1262829 | 2 a
1263058 | 2 a
1263257 | 2 a
1263372 | 2 a
1264307 | 2 a
1264650 | 2 a
1264688 | 2 a
1265051 | 2 a
1265306 | 2 a
1265339 | 2 a
1265886 | 2 a
1266026 | 2 a
1266265 | 2 a
1266582 | 2 a
1266931 | 2 a
1267020 | 2 a
1267275 | 2 a
1267565 | 2 a
1267836 | 2 a
1267905 | 2 a
1268135 | 2 a
1268272 | 2 a
1268376 | 2 a
1269123 | 2 a
1269218 | 2 a
1269266 | 2 a
1269304 | 2 a
1269611 | 2 a
1269793 | 2 a
1270066 | 2 a
1270241 | 2 a
1270452 | 2 a
1270563 | 2 a
1270691 | 2 a
1270989 | 2 a
1271170 | 2 a
1271919 | 2 a
1272136 | 2 a
1272236 | 2 a
1272452 | 2 a
1272561 | 2 a
1272971 | 2 a
1273200 | 2 a
1273353 | 2 a
1273452 | 2 a
1273755 | 2 a
1273906 | 2 a
1274103 | 2 a
1274346 | 2 a
1274792 | 2 a
1275048 | 2 a
1275143 | 2 a
1275406 | 2 a
1275624 | 2 a
1277109 | 2 a
1277186 | 2 a
1277415 | 2 a
1277624 | 2 a
1277885 | 2 a
1278058 | 2 a
1278185 | 2 a
1278402 | 2 a
1278542 | 2 a
1278761 | 2 a
1278842 | 2 a
1279178 | 2 a
1279372 | 2 a
1279661 | 2 a
1282488 | 2 a
1282677 | 2 a
1282970 | 2 a
1283281 | 2 a
1283393 | 2 a
1283574 | 2 a
1283676 | 2 a
1283812 | 2 a
1283856 | 2 a
1284144 | 2 a
1284380 | 2 a
1284573 | 2 a
1284819 | 2 a
1285259 | 2 a
1285413 | 2 a
1285453 | 2 a
1285591 | 2 a
1285858 | 2 a
1286063 | 2 a
1286545 | 2 a
1286982 | 2 a
1287045 | 2 a
1287391 | 2 a
1287492 | 2 a
1287984 | 2 a
1288210 | 2 a
1291416 | 2 a
1291946 | 2 a
1292079 | 2 a
1292236 | 2 a
1292388 | 2 a
1292498 | 2 a
1292695 | 2 a
1292740 | 2 a
1293045 | 2 a
1293184 | 2 a
1293311 | 2 a
1293398 | 2 a
1293565 | 2 a
1294292 | 2 a
1294544 | 2 a
1294633 | 2 a
1294680 | 2 a
1294984 | 2 a
1295082 | 2 a
1295205 | 2 a
1295383 | 2 a
1295889 | 2 a
1296002 | 2 a
1296123 | 2 a
1296362 | 2 a
1296580 | 2 a
1296930 | 2 a
1297090 | 2 a
1297272 | 4 a V1
1297770 | 2 a
1297887 | 2 a
1298001 | 2 a
1298144 | 2 a
1298572 | 2 a
1298885 | 2 a
1299009 | 2 a
1299280 | 2 a
1299399 | 2 a
1299516 | 2 a
1299643 | 2 a
1300336 | 2 a
1300993 | 2 a
1301136 | 2 a
1301491 | 2 a
1301719 | 2 a
1302058 | 2 a
1302628 | 2 a
1302737 | 2 a
1302857 | 2 a
1303140 | 2 a
1304163 | 4 a V1
1305200 | 1 a +-152.84
1305600 | 0 a
1305768 | 2 a
1306470 | 1 a +-152.84
1306608 | 1 a +-152.84
1306917 | 1 a +-152.84
1307275 | 1 a +-152.84
1307370 | 1 a +-152.84
1307820 | 1 a +-152.84
1308001 | 1 a +-152.84
1308066 | 1 a +-152.84
1308169 | 1 a +-152.84
1308443 | 1 a +-152.84
1308520 | 1 a +-152.84
1308946 | 1 a +-152.84
1309069 | 1 a +-152.84
1309245 | 1 a +-152.84
1309492 | 1 a +-152.84
1309705 | 1 a +-152.84
1309902 | 1 a +-152.84
1310006 | 1 a +-152.84
1310150 | 1 a +-152.84
1310505 | 1 a +-152.84
1310720 | 1 a +-152.84
1310844 | 1 a +-152.84
1310977 | 1 a +-152.84
1311433 | 4 a V1
1312052 | 1 a +-152.84
1312417 | 1 a +-152.84
1312720 | 4 a V1
1313156 | 1 a +-152.84
1313204 | 1 a +-152.84
1313374 | 2 a
1313392 | 1 a +-152.84
1313424 | 1 a +-152.84
1313448 | 1 a +-152.84
1313464 | 1 a +-152.84
1313480 | 1 a +-152.84
1313513 | 1 a +-152.84
1313551 | 1 a +-152.84
1313567 | 1 a +-152.84
1313581 | 1 a +-152.84
1313619 | 1 a +-152.84
1313643 | 1 a +-152.84
1313667 | 1 a +-152.84
1313691 | 1 a +-152.84
1313707 | 1 a +-152.84
1313730 | 1 a +-152.84
1313768 | 1 a +-152.84
1313800 | 1 a +-152.84
1313824 | 1 a +-152.84
1313856 | 1 a +-152.84
1313894 | 1 a +-152.84
1313934 | 1 a +-152.84
1313958 | 1 a +-152.84
1313982 | 1 a +-152.84
1315123 | 4 a V1
1316529 | 1 a +-152.84
1316633 | 1 a +-152.84
1316753 | 1 a +-152.84
1316833 | 1 a +-152.84
1317014 | 1 a +-152.84
1317119 | 1 a +-152.84
1317211 | 1 a +-152.84
1317333 | 1 a +-152.84
1317461 | 1 a +-152.84
1317606 | 1 a +-152.84
1317918 | 4 a V1
1318199 | 1 a +-152.84
1318386 | 1 a +-152.84
1318428 | 1 a +-152.84
1318904 | 2 a
1319389 | 1 a +-152.84
1319808 | 1 a +-152.84
1319961 | 1 a +-152.84
1320223 | 1 a +-152.84
1320351 | 1 a +-152.84
1320453 | 1 a +-152.84
1320573 | 1 a +-152.84
1320661 | 1 a +-152.84
1411746 | 2 a
1412039 | 0 a
1412465 | 2 a
1412849 | 0 a
1413427 | 0 a
1413630 | 0 a
1413727 | 0 a
1414019 | 0 a
1414288 | 0 a
1414443 | 0 a
1414579 | 0 a
1414879 | 0 a
1414964 | 0 a
1415260 | 2 a
1415792 | 0 a
1415929 | 0 a
1416276 | 1 a +-152.84
1416545 | 0 a
1416741 | 0 a
1416878 | 0 a
1417019 | 0 a
1417263 | 2 a
1417707 | 0 a
1417817 | 0 a
1417869 | 0 a
1418073 | 0 a
1418146 | 0 a
1418410 | 0 a
1418808 | 0 a
1418863 | 0 a
1497558 | 1 a +-152.84
1499007 | 5 a V1
1499050 | 5 a V1
1499092 | 5 a V1
1502248 | 0 a
1502904 | 0 a
1503665 | 0 a
1506606 | 2 a
1856011 | 5 a V1
1856423 | 5 a V1
1856507 | 5 a V1
1856853 | 5 a V1
1856918 | 5 a V1
1857390 | 5 a V1
1857465 | 5 a V1
1858420 | 4 a V1
1862257 | 2 a

# IfcFlowFitting: Z_PIF_AS+_Bend_Wavin_(nested):socket_end (3905)
Type - Description: Bend; PredefinedType: JUNCTION; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket_end; sets with these values: 2
Name (Z_PIF_AS+_Bend_Wavin_(nested):socket_end:...) | In
1104147 | 0 a
1104149 | 0 a
1104317 | 0 a
1104323 | 0 a
1104418 | 0 a
1104420 | 0 a
1104547 | 0 a
1104553 | 0 a
1104641 | 0 a
1104643 | 0 a
1104655 | 0 a
1104657 | 0 a
1104734 | 0 a
1104736 | 0 a
1104774 | 0 a
1104780 | 0 a
1104832 | 0 a
1104834 | 0 a
1104894 | 0 a
1104900 | 0 a
1104960 | 0 a
1104962 | 0 a
1105081 | 0 a
1105087 | 0 a
1106749 | 0 a
1106751 | 0 a
1106763 | 0 a
1106765 | 0 a
1106881 | 0 a
1106883 | 0 a
1107050 | 0 a
1107073 | 0 a
1107132 | 0 a
1107138 | 0 a
1107361 | 0 a
1107363 | 0 a
1107375 | 0 a
1107377 | 0 a
1107477 | 0 a
1107479 | 0 a
1107523 | 0 a
1107535 | 0 a
1107781 | 0 a
1107783 | 0 a
1107975 | 0 a
1107977 | 0 a
1108003 | 0 a
1108005 | 0 a
1108185 | 0 a
1108197 | 0 a
1108248 | 0 a
1108254 | 0 a
1108364 | 0 a
1108366 | 0 a
1108378 | 0 a
1108380 | 0 a
1109137 | 0 a
1109139 | 0 a
1109689 | 5 a V1
1109691 | 5 a V1
1109725 | 0 a
1109737 | 0 a
1110882 | 2 a
1110884 | 2 a
1111148 | 0 a
1111160 | 0 a
1111276 | 2 a
1111278 | 2 a
1111308 | 2 a
1111310 | 2 a
1111340 | 2 a
1111342 | 2 a
1111377 | 2 a
1111379 | 2 a
1111446 | 2 a
1111458 | 0 a
1111614 | 2 a
1111616 | 2 a
1111646 | 2 a
1111648 | 2 a
1111678 | 2 a
1111680 | 2 a
1112242 | 4 a V1
1112244 | 4 a V1
1112472 | 4 a V1
1112567 | 4 a V1
1112569 | 4 a V1
1112604 | 4 a V1
1112606 | 4 a V1
1112935 | 4 a V1
1112937 | 4 a V1
1118473 | 0 a
1118475 | 0 a
1118531 | 0 a
1118533 | 0 a
1118596 | 5 a V1
1118598 | 5 a V1
1118769 | 0 a
1118771 | 0 a
1118783 | 0 a
1118785 | 0 a
1119459 | 4 a V1
1119461 | 4 a V1
1119918 | 5 a V1
1119920 | 5 a V1
1121198 | 5 a V1
1121200 | 5 a V1
1121212 | 5 a V1
1121214 | 5 a V1
1121496 | 4 a V1
1121498 | 4 a V1
1121510 | 4 a V1
1121512 | 4 a V1
1121576 | 4 a V1
1121578 | 4 a V1
1121590 | 4 a V1
1121592 | 4 a V1
1121671 | 4 a V1
1121673 | 4 a V1
1121685 | 4 a V1
1121687 | 4 a V1
1122102 | 5 a V1
1122517 | 5 a V1
1122626 | 4 a V1
1122628 | 4 a V1
1122640 | 4 a V1
1122642 | 4 a V1
1123239 | 5 a V1
1124063 | 4 a V1
1124065 | 4 a V1
1124077 | 4 a V1
1124079 | 4 a V1
1125098 | 5 a V1
1125257 | 5 a V1
1125259 | 5 a V1
1125459 | 5 a V1
1125461 | 5 a V1
1125928 | 4 a V1
1125930 | 4 a V1
1126265 | 4 a V1
1126267 | 4 a V1
1126301 | 5 a V1
1126303 | 5 a V1
1127285 | 4 a V1
1127287 | 4 a V1
1127339 | 4 a V1
1127341 | 4 a V1
1127616 | 4 a V1
1127618 | 4 a V1
1127630 | 4 a V1
1127632 | 4 a V1
1128290 | 4 a V1
1128292 | 4 a V1
1128431 | 4 a V1
1128433 | 4 a V1
1128445 | 4 a V1
1128447 | 4 a V1
1128622 | 4 a V1
1128624 | 4 a V1
1128636 | 4 a V1
1128638 | 4 a V1
1128854 | 4 a V1
1128856 | 4 a V1
1128911 | 4 a V1
1128913 | 4 a V1
1129214 | 5 a V1
1129216 | 5 a V1
1129244 | 5 a V1
1129246 | 5 a V1
1129354 | 5 a V1
1129356 | 5 a V1
1129390 | 5 a V1
1129392 | 5 a V1
1129795 | 4 a V1
1129797 | 4 a V1
1129910 | 4 a V1
1129912 | 4 a V1
1130065 | 4 a V1
1130067 | 4 a V1
1130079 | 4 a V1
1130081 | 4 a V1
1130093 | 4 a V1
1130095 | 4 a V1
1130259 | 4 a V1
1130261 | 4 a V1
1130284 | 4 a V1
1130286 | 4 a V1
1130356 | 4 a V1
1130358 | 4 a V1
1130600 | 4 a V1
1130602 | 4 a V1
1130642 | 4 a V1
1130702 | 4 a V1
1130830 | 4 a V1
1130832 | 4 a V1
1130842 | 4 a V1
1130844 | 4 a V1
1130902 | 4 a V1
1130904 | 4 a V1
1131267 | 4 a V1
1131269 | 4 a V1
1131378 | 4 a V1
1131380 | 4 a V1
1131633 | 5 a V1
1131635 | 5 a V1
1131647 | 5 a V1
1131649 | 5 a V1
1131661 | 5 a V1
1131663 | 5 a V1
1131675 | 5 a V1
1131677 | 5 a V1
1131949 | 5 a V1
1131951 | 5 a V1
1131968 | 5 a V1
1131970 | 5 a V1
1132368 | 5 a V1
1132370 | 5 a V1
1132499 | 5 a V1
1132501 | 5 a V1
1139545 | 5 a V1
1139547 | 5 a V1
1139564 | 5 a V1
1139566 | 5 a V1
1139694 | 5 a V1
1139696 | 5 a V1
1139796 | 5 a V1
1139798 | 5 a V1
1139804 | 5 a V1
1139806 | 5 a V1
1140062 | 5 a V1
1140064 | 5 a V1
1140076 | 5 a V1
1140078 | 5 a V1
1140090 | 5 a V1
1140092 | 5 a V1
1140173 | 5 a V1
1140175 | 5 a V1
1140181 | 5 a V1
1140183 | 5 a V1
1141279 | 4 a V1
1141281 | 4 a V1
1141426 | 5 a V1
1141428 | 5 a V1
1141434 | 5 a V1
1141436 | 5 a V1
1141653 | 5 a V1
1141655 | 5 a V1
1141858 | 5 a V1
1141860 | 5 a V1
1143127 | 0 a
1143129 | 0 a
1143163 | 5 a V1
1143165 | 5 a V1
1143201 | 0 a
1143207 | 5 a V1
1143211 | 5 a V1
1143213 | 5 a V1
1143763 | 5 a V1
1143765 | 5 a V1
1143990 | 5 a V1
1143992 | 5 a V1
1143997 | 5 a V1
1143999 | 5 a V1
1144039 | 5 a V1
1144041 | 5 a V1
1144173 | 5 a V1
1144175 | 5 a V1
1144234 | 5 a V1
1144236 | 5 a V1
1144240 | 5 a V1
1144242 | 5 a V1
1144454 | 5 a V1
1144456 | 5 a V1
1144462 | 5 a V1
1144464 | 5 a V1
1144573 | 5 a V1
1144575 | 5 a V1
1144581 | 5 a V1
1144583 | 5 a V1
1145060 | 5 a V1
1145062 | 5 a V1
1145205 | 5 a V1
1145207 | 5 a V1
1145240 | 5 a V1
1145242 | 5 a V1
1145371 | 5 a V1
1145373 | 5 a V1
1145409 | 5 a V1
1145411 | 5 a V1
1145616 | 5 a V1
1145618 | 5 a V1
1145706 | 5 a V1
1145708 | 5 a V1
1145714 | 5 a V1
1145716 | 5 a V1
1145944 | 5 a V1
1145946 | 5 a V1
1151775 | 4 a V1
1151777 | 4 a V1
1151960 | 4 a V1
1151962 | 4 a V1
1152082 | 4 a V1
1152084 | 4 a V1
1152373 | 4 a V1
1152375 | 4 a V1
1152715 | 4 a V1
1152717 | 4 a V1
1152953 | 4 a V1
1152955 | 4 a V1
1152962 | 4 a V1
1152964 | 4 a V1
1153079 | 4 a V1
1153081 | 4 a V1
1153093 | 4 a V1
1153095 | 4 a V1
1153107 | 4 a V1
1153109 | 4 a V1
1153167 | 4 a V1
1153169 | 4 a V1
1153173 | 4 a V1
1153175 | 4 a V1
1153296 | 4 a V1
1153298 | 4 a V1
1153302 | 4 a V1
1153304 | 4 a V1
1153549 | 4 a V1
1153551 | 4 a V1
1153608 | 4 a V1
1153610 | 4 a V1
1153614 | 4 a V1
1153616 | 4 a V1
1153636 | 4 a V1
1153638 | 4 a V1
1154151 | 4 a V1
1154201 | 4 a V1
1154203 | 4 a V1
1154209 | 4 a V1
1154211 | 4 a V1
1155039 | 4 a V1
1155041 | 4 a V1
1155107 | 4 a V1
1155109 | 4 a V1
1155213 | 4 a V1
1155215 | 4 a V1
1155411 | 4 a V1
1155413 | 4 a V1
1155500 | 4 a V1
1155502 | 4 a V1
1155520 | 4 a V1
1155522 | 4 a V1
1155528 | 4 a V1
1155530 | 4 a V1
1155835 | 4 a V1
1155837 | 4 a V1
1155849 | 4 a V1
1155851 | 4 a V1
1155869 | 4 a V1
1155871 | 4 a V1
1155877 | 4 a V1
1155879 | 4 a V1
1156060 | 4 a V1
1156062 | 4 a V1
1156169 | 4 a V1
1156171 | 4 a V1
1156182 | 4 a V1
1156184 | 4 a V1
1156214 | 4 a V1
1156216 | 4 a V1
1156226 | 4 a V1
1156228 | 4 a V1
1156355 | 4 a V1
1156357 | 4 a V1
1156405 | 4 a V1
1156407 | 4 a V1
1156411 | 4 a V1
1156413 | 4 a V1
1156432 | 4 a V1
1156434 | 4 a V1
1156498 | 4 a V1
1156500 | 4 a V1
1156584 | 4 a V1
1156586 | 4 a V1
1156695 | 4 a V1
1156697 | 4 a V1
1156701 | 4 a V1
1156703 | 4 a V1
1156735 | 4 a V1
1156737 | 4 a V1
1156845 | 4 a V1
1156847 | 4 a V1
1156857 | 4 a V1
1156859 | 4 a V1
1156871 | 4 a V1
1156873 | 4 a V1
1156883 | 4 a V1
1156885 | 4 a V1
1157060 | 4 a V1
1157062 | 4 a V1
1157264 | 4 a V1
1157266 | 4 a V1
1157322 | 4 a V1
1157324 | 4 a V1
1157334 | 4 a V1
1157336 | 4 a V1
1157348 | 4 a V1
1157350 | 4 a V1
1157360 | 4 a V1
1157362 | 4 a V1
1157508 | 4 a V1
1157510 | 4 a V1
1157952 | 4 a V1
1157954 | 4 a V1
1157958 | 4 a V1
1157960 | 4 a V1
1158001 | 4 a V1
1158003 | 4 a V1
1158128 | 4 a V1
1158130 | 4 a V1
1158190 | 4 a V1
1158192 | 4 a V1
1158196 | 4 a V1
1158198 | 4 a V1
1158224 | 4 a V1
1158226 | 4 a V1
1158331 | 4 a V1
1158333 | 4 a V1
1158343 | 4 a V1
1158345 | 4 a V1
1158375 | 4 a V1
1158377 | 4 a V1
1158387 | 4 a V1
1158389 | 4 a V1
1158401 | 4 a V1
1158403 | 4 a V1
1158413 | 4 a V1
1158415 | 4 a V1
1158637 | 4 a V1
1158639 | 4 a V1
1158731 | 4 a V1
1158733 | 4 a V1
1158743 | 4 a V1
1158745 | 4 a V1
1158819 | 4 a V1
1158821 | 4 a V1
1158831 | 4 a V1
1158833 | 4 a V1
1158845 | 4 a V1
1158847 | 4 a V1
1158875 | 4 a V1
1158877 | 4 a V1
1158942 | 4 a V1
1158944 | 4 a V1
1159013 | 4 a V1
