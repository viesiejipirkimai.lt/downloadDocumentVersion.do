Properties of the parts of a building model (IFC2X3), part 48 of 57

# IfcFlowSegment: Pipe Types:Wavin AS+ (socket end) OD (3301)
Name (Pipe Types:Wavin AS+ (socket end) OD:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1153555 | 4 a V1 | 47.4729 | 14229.5 | Ūkio-buities nuotekos - F1 1
1153604 | 4 a V1 | 1377.57 | 12757.3 | Ūkio-buities nuotekos - F1 1
1153731 | 4 a V1 | 127.46 | 12565.9 | Ūkio-buities nuotekos - F1 1
1154141 | 4 a V1 | 46.6265 | 12570.8 | Ūkio-buities nuotekos - F1 1
1154155 | 4 a V1 | 124.761 | 14052.6 | Ūkio-buities nuotekos - F1 1
1154197 | 4 a V1 | 38.6266 | 13893.2 | Ūkio-buities nuotekos - F1 1
1154229 | 4 a V1 | 590.022 | 12605.9 | Ūkio-buities nuotekos - F1 1
1154238 | 4 a V1 | 527.103 | 12570.7 | Ūkio-buities nuotekos - F1 1
1155035 | 4 a V1 | 976.441 | 12739.3 | Ūkio-buities nuotekos - F1 1
1155113 | 4 a V1 | 408.118 | 12636.3 | Ūkio-buities nuotekos - F1 1
1155209 | 4 a V1 | 954.485 | 12812.8 | Ūkio-buities nuotekos - F1 1
1155365 | 4 a V1 | 232.119 | 12833.2 | Ūkio-buities nuotekos - F1 1
1155401 | 4 a V1 | 159.314 | 13680.8 | Ūkio-buities nuotekos - F1 1
1155490 | 4 a V1 | 201.327 | 13410.6 | Ūkio-buities nuotekos - F1 1
1155504 | 4 a V1 | 211.995 | 13186.1 | Ūkio-buities nuotekos - F1 1
1155731 | 4 a V1 | 278.497 | 12740.1 | Ūkio-buities nuotekos - F1 1
1155825 | 4 a V1 | 376.659 | 13665.5 | Ūkio-buities nuotekos - F1 1
1155841 | 4 a V1 | 228.327 | 13368.2 | Ūkio-buities nuotekos - F1 1
1155853 | 4 a V1 | 429.23 | 13139.4 | Ūkio-buities nuotekos - F1 1
1155940 | 4 a V1 | 589.98 | 12632 | Ūkio-buities nuotekos - F1 1
1155949 | 4 a V1 | 424.831 | 12599.6 | Ūkio-buities nuotekos - F1 1
1156056 | 4 a V1 | 1048.9 | 12765.4 | Ūkio-buities nuotekos - F1 1
1156123 | 4 a V1 | 475.413 | 12611.5 | Ūkio-buities nuotekos - F1 1
1156146 | 4 a V1 | 513.962 | 12629.7 | Ūkio-buities nuotekos - F1 1
1156154 | 4 a V1 | 722.997 | 12808.2 | Ūkio-buities nuotekos - F1 1
1156174 | 4 a V1 | 236.631 | 13652 | Ūkio-buities nuotekos - F1 1
1156188 | 4 a V1 | 106.127 | 13825.1 | Ūkio-buities nuotekos - F1 1
1156218 | 4 a V1 | 84.7533 | 14052 | Ūkio-buities nuotekos - F1 1
1156329 | 4 a V1 | 1831.67 | 12630.7 | Ūkio-buities nuotekos - F1 1
1156338 | 4 a V1 | 601.358 | 12584.7 | Ūkio-buities nuotekos - F1 1
1156347 | 4 a V1 | 599.676 | 12690.9 | Ūkio-buities nuotekos - F1 1
1156361 | 4 a V1 | 167.497 | 14229.5 | Ūkio-buities nuotekos - F1 1
1156401 | 4 a V1 | 1335.11 | 12799.7 | Ūkio-buities nuotekos - F1 1
1156488 | 4 a V1 | 1077.08 | 12679.6 | Ūkio-buities nuotekos - F1 1
1156554 | 4 a V1 | 129.296 | 12534.5 | Ūkio-buities nuotekos - F1 1
1156567 | 4 a V1 | 188.866 | 12498.3 | Ūkio-buities nuotekos - F1 1
1156576 | 4 a V1 | 11.045 | 12540.9 | Ūkio-buities nuotekos - F1 1
1156590 | 4 a V1 | 107.319 | 14229.5 | Ūkio-buities nuotekos - F1 1
1156691 | 4 a V1 | 1496.93 | 12637.9 | Ūkio-buities nuotekos - F1 1
1156801 | 4 a V1 | 529.628 | 12502.5 | Ūkio-buities nuotekos - F1 1
1156812 | 4 a V1 | 454.494 | 12484.7 | Ūkio-buities nuotekos - F1 1
1156835 | 4 a V1 | 875.676 | 12681.4 | Ūkio-buities nuotekos - F1 1
1156849 | 4 a V1 | 136.501 | 13677.9 | Ūkio-buities nuotekos - F1 1
1156863 | 4 a V1 | 88.1288 | 13848.9 | Ūkio-buities nuotekos - F1 1
1156875 | 4 a V1 | 84.7533 | 14057.9 | Ūkio-buities nuotekos - F1 1
1156946 | 4 a V1 | 169.69 | 12500.8 | Ūkio-buities nuotekos - F1 1
1157004 | 4 a V1 | 331.894 | 12474.6 | Ūkio-buities nuotekos - F1 1
1157028 | 4 a V1 | 1193.6 | 12620.4 | Ūkio-buities nuotekos - F1 1
1157210 | 4 a V1 | 189.236 | 12471.2 | Ūkio-buities nuotekos - F1 1
1157225 | 4 a V1 | 529.01 | 12437.3 | Ūkio-buities nuotekos - F1 1
1157254 | 4 a V1 | 1205.98 | 12596.6 | Ūkio-buities nuotekos - F1 1
1157281 | 4 a V1 | 201.339 | 12464.9 | Ūkio-buities nuotekos - F1 1
1157290 | 4 a V1 | 627.752 | 12458.3 | Ūkio-buities nuotekos - F1 1
1157312 | 4 a V1 | 913.102 | 12637.3 | Ūkio-buities nuotekos - F1 1
1157326 | 4 a V1 | 236.711 | 13671.2 | Ūkio-buities nuotekos - F1 1
1157340 | 4 a V1 | 86.125 | 13844.3 | Ūkio-buities nuotekos - F1 1
1157352 | 4 a V1 | 84.7533 | 14051.2 | Ūkio-buities nuotekos - F1 1
1157482 | 4 a V1 | 248.046 | 12526.4 | Ūkio-buities nuotekos - F1 1
1157491 | 4 a V1 | 2522.63 | 12473.7 | Ūkio-buities nuotekos - F1 1
1157500 | 4 a V1 | 92.2479 | 12535.2 | Ūkio-buities nuotekos - F1 1
1157935 | 4 a V1 | 47.2968 | 14229.5 | Ūkio-buities nuotekos - F1 1
1157948 | 4 a V1 | 1500.97 | 12633.9 | Ūkio-buities nuotekos - F1 1
1158102 | 4 a V1 | 1491.58 | 12555.6 | Ūkio-buities nuotekos - F1 1
1158111 | 4 a V1 | 466.357 | 12526.9 | Ūkio-buities nuotekos - F1 1
1158120 | 4 a V1 | 426.011 | 12593.6 | Ūkio-buities nuotekos - F1 1
1158134 | 4 a V1 | 107.664 | 14229.5 | Ūkio-buities nuotekos - F1 1
1158186 | 4 a V1 | 1435.87 | 12699 | Ūkio-buities nuotekos - F1 1
1158270 | 4 a V1 | 6.70827 | 12563.6 | Ūkio-buities nuotekos - F1 1
1158277 | 4 a V1 | 550.345 | 12574.8 | Ūkio-buities nuotekos - F1 1
1158321 | 4 a V1 | 111.674 | 12754.1 | Ūkio-buities nuotekos - F1 1
1158335 | 4 a V1 | 156.667 | 12986.6 | Ūkio-buities nuotekos - F1 1
1158349 | 4 a V1 | 387.726 | 13158.1 | Ūkio-buities nuotekos - F1 1
1158379 | 4 a V1 | 136.611 | 13666.6 | Ūkio-buities nuotekos - F1 1
1158393 | 4 a V1 | 88.1266 | 13837.7 | Ūkio-buities nuotekos - F1 1
1158405 | 4 a V1 | 64.7493 | 14046.6 | Ūkio-buities nuotekos - F1 1
1158533 | 4 a V1 | 30.0333 | 12602.8 | Ūkio-buities nuotekos - F1 1
1158542 | 4 a V1 | 497.382 | 12568.2 | Ūkio-buities nuotekos - F1 1
1158633 | 4 a V1 | 1090.74 | 12725 | Ūkio-buities nuotekos - F1 1
1158686 | 4 a V1 | 281.34 | 12609.8 | Ūkio-buities nuotekos - F1 1
1158697 | 4 a V1 | 974.973 | 12581.6 | Ūkio-buities nuotekos - F1 1
1158721 | 4 a V1 | 212.072 | 12783.7 | Ūkio-buities nuotekos - F1 1
1158749 | 4 a V1 | 196.682 | 13116.6 | Ūkio-buities nuotekos - F1 1
1158811 | 4 a V1 | 226.925 | 13288.9 | Ūkio-buities nuotekos - F1 1
1158823 | 4 a V1 | 436.671 | 13636.6 | Ūkio-buities nuotekos - F1 1
1158837 | 4 a V1 | 62.1266 | 13813.7 | Ūkio-buities nuotekos - F1 1
1158849 | 4 a V1 | 84.7533 | 13996.6 | Ūkio-buities nuotekos - F1 1
1158932 | 4 a V1 | 355.876 | 12650.2 | Ūkio-buities nuotekos - F1 1
1159009 | 4 a V1 | 935.254 | 12825.6 | Ūkio-buities nuotekos - F1 1
1159068 | 4 a V1 | 51.9623 | 12678.1 | Ūkio-buities nuotekos - F1 1
1159091 | 4 a V1 | 59.5874 | 12640.6 | Ūkio-buities nuotekos - F1 1
1159100 | 4 a V1 | 288.857 | 12682.9 | Ūkio-buities nuotekos - F1 1
1159114 | 4 a V1 | 67.1664 | 14229.5 | Ūkio-buities nuotekos - F1 1
1159157 | 4 a V1 | 1349.28 | 12785.6 | Ūkio-buities nuotekos - F1 1
1159209 | 4 a V1 | 982.03 | 12824.7 | Ūkio-buities nuotekos - F1 1
1159218 | 4 a V1 | 10.5613 | 12617.4 | Ūkio-buities nuotekos - F1 1
1159564 | 4 a V1 | 350.798 | 12526 | Ūkio-buities nuotekos - F1 1
1159579 | 4 a V1 | 4427.29 | 12340 | Ūkio-buities nuotekos - F1 1
1159584 | 4 a V1 | 358.121 | 12563.9 | Ūkio-buities nuotekos - F1 1
1159634 | 4 a V1 | 1027.41 | 12739.4 | Ūkio-buities nuotekos - F1 1
1159718 | 4 a V1 | 408.833 | 12595 | Ūkio-buities nuotekos - F1 1
1159733 | 4 a V1 | 411.875 | 12552.8 | Ūkio-buities nuotekos - F1 1
1159742 | 4 a V1 | 211.529 | 12607 | Ūkio-buities nuotekos - F1 1
1159756 | 4 a V1 | 107.844 | 14229.5 | Ūkio-buities nuotekos - F1 1
1159796 | 4 a V1 | 1426.78 | 12708.1 | Ūkio-buities nuotekos - F1 1
1159835 | 4 a V1 | 388.999 | 12586.4 | Ūkio-buities nuotekos - F1 1
1159848 | 4 a V1 | 168.109 | 12546.7 | Ūkio-buities nuotekos - F1 1
1159857 | 4 a V1 | 107.497 | 14229.5 | Ūkio-buities nuotekos - F1 1
1159969 | 4 a V1 | 1443.83 | 12691 | Ūkio-buities nuotekos - F1 1
1159999 | 4 a V1 | 451.375 | 12580.2 | Ūkio-buities nuotekos - F1 1
1160016 | 4 a V1 | 256.006 | 12538.7 | Ūkio-buities nuotekos - F1 1
1160072 | 4 a V1 | 89.3356 | 12593.1 | Ūkio-buities nuotekos - F1 1
1160078 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 1
1160129 | 4 a V1 | 1443.13 | 12691.7 | Ūkio-buities nuotekos - F1 1
1160306 | 4 a V1 | 449.171 | 12557.2 | Ūkio-buities nuotekos - F1 1
1160317 | 4 a V1 | 720.736 | 12508.8 | Ūkio-buities nuotekos - F1 1
1160326 | 4 a V1 | 951.677 | 12569.9 | Ūkio-buities nuotekos - F1 1
1160340 | 4 a V1 | 124.622 | 14179.5 | Ūkio-buities nuotekos - F1 1
1160389 | 4 a V1 | 1399.04 | 12685.8 | Ūkio-buities nuotekos - F1 1
1160419 | 4 a V1 | 40.9809 | 12513 | Ūkio-buities nuotekos - F1 1
1160428 | 4 a V1 | 627.62 | 12491.8 | Ūkio-buities nuotekos - F1 1
1160435 | 4 a V1 | 92.9842 | 14052.6 | Ūkio-buities nuotekos - F1 1
1160516 | 4 a V1 | 1249.65 | 12682.2 | Ūkio-buities nuotekos - F1 1
1160605 | 4 a V1 | 413.454 | 12496 | Ūkio-buities nuotekos - F1 1
1160614 | 4 a V1 | 644.423 | 12474.5 | Ūkio-buities nuotekos - F1 1
1160621 | 4 a V1 | 512.325 | 12510 | Ūkio-buities nuotekos - F1 1
1160635 | 4 a V1 | 124.761 | 14052.6 | Ūkio-buities nuotekos - F1 1
1160680 | 4 a V1 | 1243.25 | 12688.6 | Ūkio-buities nuotekos - F1 1
1160724 | 4 a V1 | 941.065 | 12481.1 | Ūkio-buities nuotekos - F1 1
1160733 | 4 a V1 | 1155.5 | 12446.9 | Ūkio-buities nuotekos - F1 1
1160740 | 4 a V1 | 224.781 | 14052.6 | Ūkio-buities nuotekos - F1 1
1160861 | 4 a V1 | 1263.58 | 12668.2 | Ūkio-buities nuotekos - F1 1
1160892 | 4 a V1 | 249.075 | 12478.1 | Ūkio-buities nuotekos - F1 1
1160903 | 4 a V1 | 4995.71 | 12344.2 | Ūkio-buities nuotekos - F1 1
1160912 | 4 a V1 | 11.5053 | 12486.8 | Ūkio-buities nuotekos - F1 1
1160926 | 4 a V1 | 167.497 | 14229.5 | Ūkio-buities nuotekos - F1 1
1161008 | 4 a V1 | 1550.94 | 12583.9 | Ūkio-buities nuotekos - F1 1
1161091 | 4 a V1 | 1787.18 | 16814.7 | K1 2
1161699 | 5 a V1 | 152.913 | 16806 | K1 2
1161968 | 5 a V1 | 3566.33 | 13170.7 | K1 2
1162074 | 5 a V1 | 17.7194 | 12925.8 | K1 2
1162108 | 5 a V1 | 254.602 | 12602.1 | K1 2
1162123 | 5 a V1 | 204.776 | 12436.3 | K1 2
1162226 | 0 a | 2142.69 | 17366.2 | Lietaus nuotekos - L1 3
1162237 | 0 a | 12142.6 | 107.811 | Lietaus nuotekos - L1 3
1162320 | 5 a V1 | 71.1083 | 17357.5 | Lietaus nuotekos - L1 3
1162546 | 5 a V1 | 4251.66 | 13028 | Lietaus nuotekos - L1 3
1162554 | 5 a V1 | 2006.02 | 12695.1 | Lietaus nuotekos - L1 3
1162695 | 5 a V1 | 2.77329 | 12614.4 | Lietaus nuotekos - L1 3
1162710 | 5 a V1 | 135.937 | 12391 | Lietaus nuotekos - L1 3
1163081 | 5 a V1 | 119.993 | 12918.1 | K1 2
1163230 | 4 a V1 | 1079.88 | 13055 | K1 2
1163544 | 5 a V1 | 48.1816 | 12932.9 | K1 2
1163553 | 4 a V1 | 57.5269 | 14179.5 | K1 2
1163590 | 4 a V1 | 1020.11 | 13064.7 | K1 2
1165561 | 4 a V1 | 520.655 | 12959.9 | K1 2
1165572 | 5 a V1 | 285.009 | 12938.3 | K1 2
1165583 | 4 a V1 | 3922.32 | 12984.6 | K1 2
1166076 | 4 a V1 | 300.373 | 13098.4 | K1 2
1166084 | 4 a V1 | 403.129 | 13110.2 | K1 2
1166167 | 4 a V1 | 465.731 | 13286.6 | K1 2
1166237 | 4 a V1 | 151.186 | 13105 | K1 2
1166248 | 4 a V1 | 16.0196 | 13093.7 | K1 2
1166449 | 4 a V1 | 654.203 | 13276.4 | K1 2
1166760 | 4 a V1 | 2089.14 | 13124.8 | K1 2
1166777 | 4 a V1 | 414.89 | 13082.6 | K1 2
1166786 | 4 a V1 | 582.026 | 13170.4 | K1 2
1166800 | 4 a V1 | 147.493 | 14229.5 | K1 2
1166843 | 4 a V1 | 855.984 | 13278.9 | K1 2
1167043 | 4 a V1 | 790.093 | 13104.2 | K1 2
1167060 | 4 a V1 | 215.752 | 13074.8 | K1 2
1167175 | 4 a V1 | 561.468 | 13241.6 | K1 2
1167255 | 4 a V1 | 216.212 | 13010.5 | K1 2
1167264 | 4 a V1 | 158.701 | 12976.9 | K1 2
1167322 | 4 a V1 | 574.853 | 13183.2 | K1 2
1167424 | 4 a V1 | 741.324 | 13014.7 | K1 2
1167439 | 4 a V1 | 471.036 | 12996.6 | K1 2
1167446 | 4 a V1 | 149.927 | 14052.6 | K1 2
1167490 | 4 a V1 | 733.953 | 13197.9 | K1 2
1167621 | 4 a V1 | 229.965 | 13018.3 | K1 2
1167634 | 4 a V1 | 97.8516 | 12991.2 | K1 2
1167734 | 4 a V1 | 620.176 | 13144.5 | K1 2
1167834 | 4 a V1 | 71.3285 | 12993.5 | K1 2
1167847 | 4 a V1 | 732.495 | 12942.5 | K1 2
1167856 | 4 a V1 | 668.913 | 13027.1 | K1 2
1167870 | 4 a V1 | 127.489 | 14229.5 | K1 2
1167913 | 4 a V1 | 997.51 | 13137.3 | K1 2
1168487 | 4 a V1 | 10.9136 | 17034.1 | Ūkio-buities nuotekos - F1 5
1168495 | 4 a V1 | 115.921 | 16811.7 | Ūkio-buities nuotekos - F1 5
1168636 | 4 a V1 | 315.853 | 16799.6 | Ūkio-buities nuotekos - F1 5
1168932 | 5 a V1 | 3326.09 | 13404.6 | Ūkio-buities nuotekos - F1 5
1169182 | 5 a V1 | 316.473 | 13178.1 | Ūkio-buities nuotekos - F1 5
1169198 | 5 a V1 | 54.7577 | 12487.1 | Ūkio-buities nuotekos - F1 5
1169264 | 5 a V1 | 114.636 | 12321.3 | Ūkio-buities nuotekos - F1 5
1169369 | 5 a V1 | 915.216 | 12767.2 | Ūkio-buities nuotekos - F1 5
1169378 | 5 a V1 | 345.025 | 12764.1 | Ūkio-buities nuotekos - F1 5
1169406 | 4 a V1 | 749.544 | 12845.4 | Ūkio-buities nuotekos - F1 5
1169420 | 4 a V1 | 226.08 | 12896.3 | Ūkio-buities nuotekos - F1 5
1169478 | 4 a V1 | 697.635 | 13069.2 | Ūkio-buities nuotekos - F1 5
1169595 | 4 a V1 | 602.001 | 12900.5 | Ūkio-buities nuotekos - F1 5
1169608 | 4 a V1 | 14.6404 | 12891.6 | Ūkio-buities nuotekos - F1 5
1169615 | 4 a V1 | 136.44 | 14052.6 | Ūkio-buities nuotekos - F1 5
1169659 | 4 a V1 | 850.918 | 13080.9 | Ūkio-buities nuotekos - F1 5
1169766 | 4 a V1 | 648.821 | 12922.7 | Ūkio-buities nuotekos - F1 5
1169781 | 4 a V1 | 428.222 | 12880.2 | Ūkio-buities nuotekos - F1 5
1169790 | 4 a V1 | 571.985 | 12939.5 | Ūkio-buities nuotekos - F1 5
1169804 | 4 a V1 | 127.774 | 14229.5 | Ūkio-buities nuotekos - F1 5
1169850 | 4 a V1 | 1087.09 | 13047.8 | Ūkio-buities nuotekos - F1 5
1170007 | 4 a V1 | 70.5205 | 12901.4 | Ūkio-buities nuotekos - F1 5
1170022 | 4 a V1 | 530.178 | 12866.1 | Ūkio-buities nuotekos - F1 5
1170251 | 4 a V1 | 791.341 | 13024.4 | Ūkio-buities nuotekos - F1 5
1170464 | 4 a V1 | 351.213 | 12861.5 | Ūkio-buities nuotekos - F1 5
1170473 | 4 a V1 | 2491.86 | 12791.2 | Ūkio-buities nuotekos - F1 5
1170480 | 4 a V1 | 124.427 | 14052.6 | Ūkio-buities nuotekos - F1 5
1170544 | 4 a V1 | 895.3 | 13036.5 | Ūkio-buities nuotekos - F1 5
1170573 | 4 a V1 | 249.924 | 12877.2 | Ūkio-buities nuotekos - F1 5
1170586 | 4 a V1 | 137.076 | 12849.6 | Ūkio-buities nuotekos - F1 5
1170664 | 4 a V1 | 812.004 | 13003.8 | Ūkio-buities nuotekos - F1 5
1170736 | 4 a V1 | 383.996 | 12916.7 | Ūkio-buities nuotekos - F1 5
1170751 | 4 a V1 | 139.058 | 12855.9 | Ūkio-buities nuotekos - F1 5
1170760 | 4 a V1 | 769.357 | 12928.2 | Ūkio-buities nuotekos - F1 5
1170774 | 4 a V1 | 147.788 | 14229.5 | Ūkio-buities nuotekos - F1 5
1170825 | 4 a V1 | 1094.42 | 13040.4 | Ūkio-buities nuotekos - F1 5
1170856 | 4 a V1 | 218.439 | 12817.8 | Ūkio-buities nuotekos - F1 5
1170867 | 5 a V1 | 1414.83 | 12734.4 | Ūkio-buities nuotekos - F1 5
1170965 | 4 a V1 | 81.6047 | 12784.9 | Ūkio-buities nuotekos - F1 5
1170976 | 4 a V1 | 134.914 | 12771.4 | Ūkio-buities nuotekos - F1 5
1170983 | 4 a V1 | 204.455 | 14102.6 | Ūkio-buities nuotekos - F1 5
1171038 | 4 a V1 | 1026.94 | 12954.9 | Ūkio-buities nuotekos - F1 5
1171175 | 4 a V1 | 759.34 | 12990.5 | Ūkio-buities nuotekos - F1 5
1171208 | 4 a V1 | 243.568 | 12858.7 | Ūkio-buities nuotekos - F1 5
1171219 | 4 a V1 | 767.111 | 12799.7 | Ūkio-buities nuotekos - F1 5
1171228 | 4 a V1 | 100.774 | 14229.5 | Ūkio-buities nuotekos - F1 5
1171279 | 4 a V1 | 1174.45 | 12960.4 | Ūkio-buities nuotekos - F1 5
1171330 | 4 a V1 | 12.4772 | 12841.2 | Ūkio-buities nuotekos - F1 5
1171339 | 4 a V1 | 236.396 | 12790.5 | Ūkio-buities nuotekos - F1 5
1171346 | 4 a V1 | 736.273 | 12847.2 | Ūkio-buities nuotekos - F1 5
1171360 | 4 a V1 | 130.432 | 14102.6 | Ūkio-buities nuotekos - F1 5
1171409 | 4 a V1 | 951.576 | 13030.2 | Ūkio-buities nuotekos - F1 5
1171498 | 4 a V1 | 678.759 | 12872.4 | Ūkio-buities nuotekos - F1 5
1171515 | 4 a V1 | 356.753 | 12831.3 | Ūkio-buities nuotekos - F1 5
1171524 | 4 a V1 | 110.421 | 12898.1 | Ūkio-buities nuotekos - F1 5
1171538 | 4 a V1 | 67.4769 | 14229.5 | Ūkio-buities nuotekos - F1 5
1171629 | 4 a V1 | 1137.65 | 12997.2 | Ūkio-buities nuotekos - F1 5
1171838 | 4 a V1 | 170.07 | 12852.9 | Ūkio-buities nuotekos - F1 5
1171853 | 4 a V1 | 1211.74 | 12803.6 | Ūkio-buities nuotekos - F1 5
1171927 | 4 a V1 | 837.877 | 12977.9 | Ūkio-buities nuotekos - F1 5
1171976 | 4 a V1 | 10.059 | 12812.2 | Ūkio-buities nuotekos - F1 5
1171985 | 4 a V1 | 425.614 | 12778.5 | Ūkio-buities nuotekos - F1 5
1172076 | 4 a V1 | 879.82 | 12934 | Ūkio-buities nuotekos - F1 5
1172294 | 4 a V1 | 9930.83 | 13069.2 | Ūkio-buities nuotekos - F1 6
1172326 | 4 a V1 | 1038.6 | 13052.4 | Ūkio-buities nuotekos - F1 6
1172334 | 4 a V1 | 651.421 | 13078.9 | Ūkio-buities nuotekos - F1 6
1172356 | 4 a V1 | 203.445 | 13127.9 | Ūkio-buities nuotekos - F1 6
1172482 | 4 a V1 | 446.551 | 13300.3 | Ūkio-buities nuotekos - F1 6
1172599 | 4 a V1 | 651.127 | 13134.5 | Ūkio-buities nuotekos - F1 6
1172608 | 4 a V1 | 16.1389 | 13123.1 | Ūkio-buities nuotekos - F1 6
1172615 | 4 a V1 | 180.82 | 14052.6 | Ūkio-buities nuotekos - F1 6
1172649 | 4 a V1 | 616 | 13315.8 | Ūkio-buities nuotekos - F1 6
1172712 | 4 a V1 | 708.779 | 13154.2 | Ūkio-buities nuotekos - F1 6
1172729 | 4 a V1 | 378.924 | 13112.7 | Ūkio-buities nuotekos - F1 6
1172738 | 4 a V1 | 165.359 | 13179.9 | Ūkio-buities nuotekos - F1 6
1172785 | 4 a V1 | 137.982 | 14229.5 | Ūkio-buities nuotekos - F1 6
1172865 | 4 a V1 | 854.781 | 13280.1 | Ūkio-buities nuotekos - F1 6
1173133 | 4 a V1 | 119.548 | 13134.3 | Ūkio-buities nuotekos - F1 6
1173146 | 4 a V1 | 580.617 | 13097.6 | Ūkio-buities nuotekos - F1 6
1173229 | 4 a V1 | 557.47 | 13258.3 | Ūkio-buities nuotekos - F1 6
1173279 | 4 a V1 | 475.784 | 13062.5 | Ūkio-buities nuotekos - F1 6
1173288 | 4 a V1 | 110.606 | 13039.5 | Ūkio-buities nuotekos - F1 6
1173301 | 4 a V1 | 521.922 | 13087.4 | Ūkio-buities nuotekos - F1 6
1173323 | 4 a V1 | 431.239 | 13130 | Ūkio-buities nuotekos - F1 6
1173409 | 4 a V1 | 539.819 | 13260.2 | Ūkio-buities nuotekos - F1 6
1173471 | 4 a V1 | 890.721 | 13094 | Ūkio-buities nuotekos - F1 6
1173488 | 4 a V1 | 301.977 | 13077 | Ūkio-buities nuotekos - F1 6
1173495 | 4 a V1 | 110.813 | 14052.6 | Ūkio-buities nuotekos - F1 6
1173546 | 4 a V1 | 651.627 | 13280.2 | Ūkio-buities nuotekos - F1 6
1173607 | 4 a V1 | 111.309 | 13096.1 | Ūkio-buities nuotekos - F1 6
1173622 | 4 a V1 | 346.089 | 13052.8 | Ūkio-buities nuotekos - F1 6
1173631 | 4 a V1 | 306.023 | 13117 | Ūkio-buities nuotekos - F1 6
1173645 | 4 a V1 | 258.63 | 13126.9 | Ūkio-buities nuotekos - F1 6
1173659 | 4 a V1 | 147.457 | 14229.5 | Ūkio-buities nuotekos - F1 6
1173704 | 4 a V1 | 905.967 | 13228.9 | Ūkio-buities nuotekos - F1 6
1173755 | 4 a V1 | 4130.49 | 13059 | Ūkio-buities nuotekos - F1 6
1173766 | 4 a V1 | 89.1993 | 13046.2 | Ūkio-buities nuotekos - F1 6
1173775 | 4 a V1 | 218.08 | 13222.4 | Ūkio-buities nuotekos - F1 6
1173842 | 4 a V1 | 321.376 | 13395.4 | Ūkio-buities nuotekos - F1 6
1173905 | 4 a V1 | 690.688 | 13167.7 | Ūkio-buities nuotekos - F1 6
1173920 | 4 a V1 | 340.924 | 13152.3 | Ūkio-buities nuotekos - F1 6
1173927 | 4 a V1 | 189.332 | 14052.6 | Ūkio-buities nuotekos - F1 6
1173977 | 4 a V1 | 581.936 | 13349.9 | Ūkio-buities nuotekos - F1 6
1174024 | 4 a V1 | 591.499 | 13200.4 | Ūkio-buities nuotekos - F1 6
1174039 | 4 a V1 | 145.895 | 13163.5 | Ūkio-buities nuotekos - F1 6
1174048 | 4 a V1 | 578.798 | 13216 | Ūkio-buities nuotekos - F1 6
1174062 | 4 a V1 | 127.573 | 14229.5 | Ūkio-buities nuotekos - F1 6
1174143 | 4 a V1 | 810.423 | 13324.4 | Ūkio-buities nuotekos - F1 6
1174174 | 4 a V1 | 159.325 | 13198.7 | Ūkio-buities nuotekos - F1 6
1174187 | 4 a V1 | 337.682 | 13169.3 | Ūkio-buities nuotekos - F1 6
1174258 | 4 a V1 | 492.276 | 13323.5 | Ūkio-buities nuotekos - F1 6
1174299 | 4 a V1 | 159.275 | 13225.9 | Ūkio-buities nuotekos - F1 6
1174310 | 4 a V1 | 1184.54 | 13179.5 | Ūkio-buities nuotekos - F1 6
1174398 | 4 a V1 | 465.12 | 13350.7 | Ūkio-buities nuotekos - F1 6
1174524 | 4 a V1 | 650.596 | 13226.6 | Ūkio-buities nuotekos - F1 6
1174537 | 4 a V1 | 319.158 | 13211.6 | Ūkio-buities nuotekos - F1 6
1174544 | 4 a V1 | 198.601 | 14052.6 | Ūkio-buities nuotekos - F1 6
1174579 | 4 a V1 | 523.828 | 13408 | Ūkio-buities nuotekos - F1 6
1174704 | 4 a V1 | 548.809 | 13242.8 | Ūkio-buities nuotekos - F1 6
1174717 | 4 a V1 | 107.003 | 13206.7 | Ūkio-buities nuotekos - F1 6
1174726 | 4 a V1 | 862.676 | 13257.5 | Ūkio-buities nuotekos - F1 6
1174740 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 6
1174778 | 4 a V1 | 763.246 | 13371.6 | Ūkio-buities nuotekos - F1 6
1174853 | 5 a V1 | 104.375 | 12948.4 | K1 2
1175039 | 4 a V1 | 16.2371 | 12952.6 | K1 2
1175093 | 4 a V1 | 810.54 | 13121.3 | K1 2
1175255 | 4 a V1 | 810.008 | 13121.8 | Ūkio-buities nuotekos - F1 34
1175326 | 0 a | 217.148 | 17432.4 | Lietaus nuotekos - L1 11
1175477 | 5 a V1 | 282.526 | 17419.4 | Lietaus nuotekos - L1 11
1175497 | 5 a V1 | 217.252 | 17407.8 | Lietaus nuotekos - L1 11
1175538 | 5 a V1 | 4149.1 | 13180.8 | Lietaus nuotekos - L1 11
1175753 | 0 a | 12718.4 | 6.32477 | Lietaus nuotekos - L1 11
1175852 | 5 a V1 | 83.2123 | 12887.9 | Lietaus nuotekos - L1 11
1175990 | 4 a V1 | 282.527 | 12874.9 | Lietaus nuotekos - L1 11
1175998 | 4 a V1 | 17.2372 | 12867.3 | Lietaus nuotekos - L1 11
1176327 | 4 a V1 | 253.31 | 17001.3 | Ūkio-buities nuotekos - F1 7
1176336 | 4 a V1 | 5962.75 | 17037.3 | Ūkio-buities nuotekos - F1 7
1176375 | 5 a V1 | 355.043 | 16988.5 | Ūkio-buities nuotekos - F1 7
1176397 | 5 a V1 | 72.8108 | 16978.3 | Ūkio-buities nuotekos - F1 7
1176738 | 5 a V1 | 55.8807 | 12431.5 | Ūkio-buities nuotekos - F1 7
1176774 | 4 a V1 | 355.043 | 12418.7 | Ūkio-buities nuotekos - F1 7
1176792 | 4 a V1 | 33.7261 | 12412.3 | Ūkio-buities nuotekos - F1 7
1176807 | 4 a V1 | 4373.09 | 12442 | Ūkio-buities nuotekos - F1 7
1177048 | 5 a V1 | 866.305 | 12857.5 | Ūkio-buities nuotekos - F1 7
1177057 | 5 a V1 | 4046.29 | 12863 | Ūkio-buities nuotekos - F1 7
1177131 | 4 a V1 | 220.849 | 12869.5 | Ūkio-buities nuotekos - F1 7
1177144 | 5 a V1 | 335.989 | 12839.3 | Ūkio-buities nuotekos - F1 7
1177206 | 4 a V1 | 693.644 | 13042.4 | Ūkio-buities nuotekos - F1 7
1177292 | 4 a V1 | 761.529 | 12876.1 | Ūkio-buities nuotekos - F1 7
1177305 | 4 a V1 | 297.166 | 12859.1 | Ūkio-buities nuotekos - F1 7
1177312 | 4 a V1 | 94.4478 | 14052.6 | Ūkio-buities nuotekos - F1 7
1177346 | 4 a V1 | 872.187 | 13059.6 | Ūkio-buities nuotekos - F1 7
1177478 | 4 a V1 | 691.261 | 12890.2 | Ūkio-buities nuotekos - F1 7
1177558 | 4 a V1 | 80.5692 | 12854.7 | Ūkio-buities nuotekos - F1 7
1177573 | 4 a V1 | 118.667 | 12921.2 | Ūkio-buities nuotekos - F1 7
1177620 | 4 a V1 | 107.485 | 14229.5 | Ūkio-buities nuotekos - F1 7
1177656 | 4 a V1 | 1114.42 | 13020.4 | Ūkio-buities nuotekos - F1 7
1177715 | 4 a V1 | 107.485 | 14229.5 | Ūkio-buities nuotekos - F1 33
1177890 | 5 a V1 | 121.078 | 12833.4 | Ūkio-buities nuotekos - F1 7
1177976 | 4 a V1 | 44.9312 | 12858.5 | Ūkio-buities nuotekos - F1 7
1178030 | 4 a V1 | 784.766 | 12981 | Ūkio-buities nuotekos - F1 7
1178236 | 4 a V1 | 252.159 | 12899.2 | Ūkio-buities nuotekos - F1 7
1178245 | 5 a V1 | 128.606 | 12850.5 | Ūkio-buities nuotekos - F1 7
1178287 | 4 a V1 | 674.745 | 13072.3 | Ūkio-buities nuotekos - F1 7
1178388 | 4 a V1 | 1121.52 | 12895.9 | Ūkio-buities nuotekos - F1 7
1178401 | 4 a V1 | 482.953 | 12878.6 | Ūkio-buities nuotekos - F1 7
1178408 | 4 a V1 | 144.765 | 14052.6 | Ūkio-buities nuotekos - F1 7
1178455 | 4 a V1 | 845.11 | 13086.7 | Ūkio-buities nuotekos - F1 7
1178570 | 4 a V1 | 288.748 | 12930.3 | Ūkio-buities nuotekos - F1 7
1178583 | 4 a V1 | 180.072 | 12892.7 | Ūkio-buities nuotekos - F1 7
1178814 | 4 a V1 | 82.4739 | 14229.5 | Ūkio-buities nuotekos - F1 7
1178825 | 4 a V1 | 1092.89 | 13042 | Ūkio-buities nuotekos - F1 7
1179025 | 4 a V1 | 618.075 | 12895.5 | Ūkio-buities nuotekos - F1 7
1179040 | 4 a V1 | 375.007 | 12867.7 | Ūkio-buities nuotekos - F1 7
1179197 | 4 a V1 | 730.656 | 13029.4 | Ūkio-buities nuotekos - F1 7
1179403 | 4 a V1 | 4351.14 | 7993.21 | Ūkio-buities nuotekos - F1 8
1179458 | 4 a V1 | 2293.77 | 12590.5 | Ūkio-buities nuotekos - F1 8
1179466 | 4 a V1 | 451.146 | 12732.3 | Ūkio-buities nuotekos - F1 8
1179850 | 4 a V1 | 841.512 | 12909.7 | Ūkio-buities nuotekos - F1 8
1179892 | 4 a V1 | 881.352 | 12721.4 | Ūkio-buities nuotekos - F1 8
1179903 | 4 a V1 | 3503.8 | 12642.1 | Ūkio-buities nuotekos - F1 8
1179910 | 4 a V1 | 209.081 | 14052.6 | Ūkio-buities nuotekos - F1 8
1179948 | 4 a V1 | 1024.45 | 12907.4 | Ūkio-buities nuotekos - F1 8
1180112 | 4 a V1 | 218.045 | 12759 | Ūkio-buities nuotekos - F1 8
1180127 | 4 a V1 | 238.014 | 12716.6 | Ūkio-buities nuotekos - F1 8
1180136 | 4 a V1 | 689.348 | 12767.1 | Ūkio-buities nuotekos - F1 8
1180150 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 8
1180199 | 4 a V1 | 1257.1 | 12877.7 | Ūkio-buities nuotekos - F1 8
1180255 | 4 a V1 | 369.993 | 12751.6 | Ūkio-buities nuotekos - F1 8
1180274 | 4 a V1 | 233.922 | 12724.2 | Ūkio-buities nuotekos - F1 8
1180488 | 4 a V1 | 935.227 | 12880.6 | Ūkio-buities nuotekos - F1 8
1180613 | 4 a V1 | 109.402 | 14028.5 | Ūkio-buities nuotekos - F1 9
1180622 | 4 a V1 | 4441.89 | 14058.1 | Ūkio-buities nuotekos - F1 9
1180697 | 4 a V1 | 180.766 | 12561.5 | Ūkio-buities nuotekos - F1 9
1180706 | 4 a V1 | 1280.34 | 12555.6 | Ūkio-buities nuotekos - F1 9
1180742 | 4 a V1 | 1029.31 | 12733.3 | Ūkio-buities nuotekos - F1 9
1180794 | 4 a V1 | 370.145 | 12552.5 | Ūkio-buities nuotekos - F1 9
1180803 | 4 a V1 | 193.395 | 12525.9 | Ūkio-buities nuotekos - F1 9
1180840 | 4 a V1 | 1124.87 | 12681.5 | Ūkio-buities nuotekos - F1 9
1180901 | 4 a V1 | 309.286 | 12592.7 | Ūkio-buities nuotekos - F1 9
1180910 | 4 a V1 | 511.857 | 12548.5 | Ūkio-buities nuotekos - F1 9
1180919 | 4 a V1 | 86.5656 | 14229.5 | Ūkio-buities nuotekos - F1 9
1180945 | 4 a V1 | 1439.14 | 12695.7 | Ūkio-buities nuotekos - F1 9
1181157 | 4 a V1 | 86.5656 | 14229.5 | Ūkio-buities nuotekos - F1 36
1181206 | 4 a V1 | 115.401 | 17541.8 | Ūkio-buities nuotekos - F1 10
1181215 | 4 a V1 | 5507.56 | 17792.5 | Ūkio-buities nuotekos - F1 10
1181263 | 5 a V1 | 108.099 | 17533.9 | Ūkio-buities nuotekos - F1 10
1181279 | 5 a V1 | 122.961 | 17525.8 | Ūkio-buities nuotekos - F1 10
1181496 | 5 a V1 | 6.20059 | 12992.9 | Ūkio-buities nuotekos - F1 10
1181707 | 5 a V1 | 1298.92 | 12746.7 | Ūkio-buities nuotekos - F1 10
1181812 | 4 a V1 | 416.154 | 12736 | Ūkio-buities nuotekos - F1 10
1181902 | 4 a V1 | 178.892 | 12735.4 | Ūkio-buities nuotekos - F1 10
1182356 | 0 a | 1464.44 | 17297.4 | Lietaus nuotekos - L1 13
1182365 | 0 a | 5407.49 | 17383.1 | Lietaus nuotekos - L1 13
1182413 | 5 a V1 | 137.108 | 17287.4 | Lietaus nuotekos - L1 13
1182672 | 5 a V1 | 3881.97 | 13327.6 | Lietaus nuotekos - L1 13
1182719 | 5 a V1 | 1183.88 | 13012.6 | Lietaus nuotekos - L1 13
1182814 | 4 a V1 | 403.874 | 13009.8 | Lietaus nuotekos - L1 13
1183030 | 0 a | 4009.89 | 13065.2 | Lietaus nuotekos - L1 13
1183216 | 5 a V1 | 49.5627 | 14097.9 | Ūkio-buities nuotekos - F1 10
1183225 | 5 a V1 | 3329.26 | 14127.6 | Ūkio-buities nuotekos - F1 10
1183296 | 5 a V1 | 211.42 | 13248.2 | Ūkio-buities nuotekos - F1 10
1183305 | 5 a V1 | 684.09 | 13221.3 | Ūkio-buities nuotekos - F1 10
1183393 | 5 a V1 | 330.813 | 13420.8 | Ūkio-buities nuotekos - F1 10
1183467 | 4 a V1 | 522.916 | 13303.8 | Ūkio-buities nuotekos - F1 10
1183482 | 5 a V1 | 173.987 | 13241.9 | Ūkio-buities nuotekos - F1 10
1183491 | 4 a V1 | 10.0866 | 13318 | Ūkio-buities nuotekos - F1 10
1183505 | 4 a V1 | 127.373 | 14229.5 | Ūkio-buities nuotekos - F1 10
1183549 | 4 a V1 | 719.777 | 13415.1 | Ūkio-buities nuotekos - F1 10
1183575 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 37
1183773 | 4 a V1 | 448.214 | 13481.6 | Ūkio-buities nuotekos - F1 10
1183776 | 5 a V1 | 464.64 | 13228.2 | Ūkio-buities nuotekos - F1 10
1183910 | 4 a V1 | 269.877 | 13247.4 | Ūkio-buities nuotekos - F1 10
1183921 | 5 a V1 | 1198.37 | 13200.7 | Ūkio-buities nuotekos - F1 10
1184006 | 4 a V1 | 441.398 | 13374.4 | Ūkio-buities nuotekos - F1 10
1184046 | 4 a V1 | 1793.3 | 13225.7 | Ūkio-buities nuotekos - F1 10
1184057 | 5 a V1 | 8.55029 | 13191.6 | Ūkio-buities nuotekos - F1 10
1184066 | 4 a V1 | 49.1218 | 13278 | Ūkio-buities nuotekos - F1 10
1184080 | 4 a V1 | 70.4893 | 14229.5 | Ūkio-buities nuotekos - F1 10
1184141 | 4 a V1 | 758.978 | 13375.9 | Ūkio-buities nuotekos - F1 10
1184166 | 4 a V1 | 67.4769 | 14229.5 | Ūkio-buities nuotekos - F1 38
1184294 | 4 a V1 | 289.977 | 13219.9 | Ūkio-buities nuotekos - F1 10
1184309 | 5 a V1 | 132.341 | 13194.6 | Ūkio-buities nuotekos - F1 10
1184383 | 4 a V1 | 468.439 | 13347.3 | Ūkio-buities nuotekos - F1 10
1185427 | 4 a V1 | 200.977 | 12714.9 | Ūkio-buities nuotekos - F1 1
1185440 | 4 a V1 | 4.12475 | 12673.2 | Ūkio-buities nuotekos - F1 1
1185449 | 4 a V1 | 529.311 | 12722.6 | Ūkio-buities nuotekos - F1 1
1185496 | 4 a V1 | 439.464 | 12842.9 | Ūkio-buities nuotekos - F1 1
1185712 | 4 a V1 | 34.6471 | 12855.5 | Ūkio-buities nuotekos - F1 1
1185751 | 4 a V1 | 1181.82 | 12953 | Ūkio-buities nuotekos - F1 1
1186144 | 4 a V1 | 139.412 | 12709.6 | Ūkio-buities nuotekos - F1 1
1186157 | 4 a V1 | 69.2073 | 12723.3 | Ūkio-buities nuotekos - F1 1
1186252 | 4 a V1 | 1313.35 | 12821.5 | Ūkio-buities nuotekos - F1 1
1186400 | 4 a V1 | 619.78 | 12703.3 | Ūkio-buities nuotekos - F1 1
1186409 | 4 a V1 | 61.4427 | 12694.7 | Ūkio-buities nuotekos - F1 1
1186416 | 4 a V1 | 281.858 | 12719.5 | Ūkio-buities nuotekos - F1 1
1186430 | 4 a V1 | 146.665 | 14229.5 | Ūkio-buities nuotekos - F1 1
1186498 | 4 a V1 | 1312.86 | 12822 | Ūkio-buities nuotekos - F1 1
1186551 | 4 a V1 | 42.2631 | 12651 | Ūkio-buities nuotekos - F1 1
1186562 | 4 a V1 | 1768.15 | 12608.2 | Ūkio-buities nuotekos - F1 1
1186569 | 4 a V1 | 551.379 | 12655.7 | Ūkio-buities nuotekos - F1 1
1186583 | 4 a V1 | 669.512 | 12670.5 | Ūkio-buities nuotekos - F1 1
1186597 | 4 a V1 | 53.9094 | 14229.5 | Ūkio-buities nuotekos - F1 1
1186622 | 4 a V1 | 1354.15 | 12780.7 | Ūkio-buities nuotekos - F1 1
1186651 | 4 a V1 | 302.064 | 12685.2 | Ūkio-buities nuotekos - F1 1
1186660 | 4 a V1 | 866.483 | 12671.1 | Ūkio-buities nuotekos - F1 1
1186673 | 4 a V1 | 329.246 | 12685 | Ūkio-buities nuotekos - F1 1
1186720 | 4 a V1 | 87.4809 | 14229.5 | Ūkio-buities nuotekos - F1 1
1186753 | 4 a V1 | 1346.39 | 12788.5 | Ūkio-buities nuotekos - F1 1
1186884 | 4 a V1 | 163.817 | 12504.8 | Ūkio-buities nuotekos - F1 1
1186893 | 4 a V1 | 651.412 | 12542.4 | Ūkio-buities nuotekos - F1 1
1186899 | 4 a V1 | 14.4544 | 12559.2 | Ūkio-buities nuotekos - F1 1
1186913 | 4 a V1 | 107.14 | 14229.5 | Ūkio-buities nuotekos - F1 1
1186954 | 4 a V1 | 1478.53 | 12656.3 | Ūkio-buities nuotekos - F1 1
1187114 | 4 a V1 | 223.256 | 12517.5 | Ūkio-buities nuotekos - F1 1
1187125 | 4 a V1 | 1077.59 | 12502.4 | Ūkio-buities nuotekos - F1 1
1187138 | 4 a V1 | 629.251 | 12515.1 | Ūkio-buities nuotekos - F1 1
1187185 | 4 a V1 | 93.3478 | 14229.5 | Ūkio-buities nuotekos - F1 1
1187216 | 4 a V1 | 1510.28 | 12624.6 | Ūkio-buities nuotekos - F1 1
1187248 | 4 a V1 | 342.226 | 12598.6 | Ūkio-buities nuotekos - F1 1
1187257 | 4 a V1 | 99.7298 | 12589.2 | Ūkio-buities nuotekos - F1 1
1187270 | 4 a V1 | 429.25 | 12604.3 | Ūkio-buities nuotekos - F1 1
1187345 | 4 a V1 | 1425.15 | 12709.7 | Ūkio-buities nuotekos - F1 1
1187460 | 4 a V1 | 28.6967 | 12681.3 | Ūkio-buities nuotekos - F1 1
1187475 | 4 a V1 | 139.32 | 12644.6 | Ūkio-buities nuotekos - F1 1
1187484 | 4 a V1 | 491.367 | 12685.7 | Ūkio-buities nuotekos - F1 1
1187531 | 4 a V1 | 352.287 | 12699.3 | Ūkio-buities nuotekos - F1 1
1187545 | 4 a V1 | 87.4809 | 14229.5 | Ūkio-buities nuotekos - F1 1
1187577 | 4 a V1 | 1331.68 | 12803.2 | Ūkio-buities nuotekos - F1 1
1187606 | 4 a V1 | 4560.57 | 12847.9 | Ūkio-buities nuotekos - F1 1
1187615 | 4 a V1 | 5174.84 | 12737 | Ūkio-buities nuotekos - F1 1
1187622 | 4 a V1 | 31.8801 | 12942.9 | Ūkio-buities nuotekos - F1 1
1187664 | 4 a V1 | 1094.49 | 13040.4 | Ūkio-buities nuotekos - F1 1
1187708 | 4 a V1 | 414.329 | 12644.3 | Ūkio-buities nuotekos - F1 1
1187723 | 4 a V1 | 2857.22 | 12498.6 | Ūkio-buities nuotekos - F1 1
1187848 | 4 a V1 | 935.855 | 12821 | Ūkio-buities nuotekos - F1 1
1187948 | 4 a V1 | 40.3769 | 12459.5 | Ūkio-buities nuotekos - F1 1
1187959 | 4 a V1 | 2041.28 | 12453.3 | Ūkio-buities nuotekos - F1 1
1188064 | 4 a V1 | 535.488 | 12584.9 | Ūkio-buities nuotekos - F1 1
1188140 | 4 a V1 | 1042.84 | 12717.2 | Ūkio-buities nuotekos - F1 1
1188196 | 4 a V1 | 2353.66 | 12734.2 | Ūkio-buities nuotekos - F1 1
1188267 | 4 a V1 | 4083.16 | 12497.3 | Ūkio-buities nuotekos - F1 1
1188276 | 4 a V1 | 891.727 | 12785.1 | Ūkio-buities nuotekos - F1 1
1188290 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 1
1188350 | 4 a V1 | 1235.1 | 12899.8 | Ūkio-buities nuotekos - F1 1
1188400 | 4 a V1 | 222.292 | 12736.8 | Ūkio-buities nuotekos - F1 1
1188409 | 4 a V1 | 3305.58 | 12665.7 | Ūkio-buities nuotekos - F1 1
1188541 | 4 a V1 | 44.2006 | 12745.1 | Ūkio-buities nuotekos - F1 1
1188619 | 4 a V1 | 1292.82 | 12842.8 | Ūkio-buities nuotekos - F1 1
1188696 | 4 a V1 | 222.293 | 12665.8 | Ūkio-buities nuotekos - F1 1
1188707 | 4 a V1 | 3461.42 | 12594 | Ūkio-buities nuotekos - F1 1
1188714 | 4 a V1 | 129.069 | 12674 | Ūkio-buities nuotekos - F1 1
1188728 | 4 a V1 | 67.4769 | 14229.5 | Ūkio-buities nuotekos - F1 1
1188800 | 4 a V1 | 1361.44 | 12773.4 | Ūkio-buities nuotekos - F1 1
1188829 | 4 a V1 | 6742.43 | 12745.1 | Ūkio-buities nuotekos - F1 1
1188846 | 4 a V1 | 38.0744 | 12581.6 | Ūkio-buities nuotekos - F1 1
1188855 | 4 a V1 | 453.481 | 12883.7 | Ūkio-buities nuotekos - F1 1
1188869 | 4 a V1 | 161.862 | 12896.8 | Ūkio-buities nuotekos - F1 1
1188926 | 4 a V1 | 1139.33 | 12996.9 | Ūkio-buities nuotekos - F1 1
1189176 | 4 a V1 | 6702.09 | 12608.6 | Ūkio-buities nuotekos - F1 1
1189267 | 4 a V1 | 10.1915 | 12747.7 | Ūkio-buities nuotekos - F1 1
1189275 | 4 a V1 | 57.9609 | 14229.5 | Ūkio-buities nuotekos - F1 1
1189316 | 4 a V1 | 1290.12 | 12844.7 | Ūkio-buities nuotekos - F1 1
1189440 | 4 a V1 | 57.9609 | 14229.5 | Ūkio-buities nuotekos - F1 40
1189464 | 4 a V1 | 19.7577 | 12610.3 | Ūkio-buities nuotekos - F1 1
1189473 | 4 a V1 | 320.014 | 12599.8 | Ūkio-buities nuotekos - F1 1
1189486 | 4 a V1 | 251.814 | 12606 | Ūkio-buities nuotekos - F1 1
1189533 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 1
1189555 | 4 a V1 | 1426.95 | 12707.9 | Ūkio-buities nuotekos - F1 1
1189644 | 4 a V1 | 204.14 | 12635.8 | Ūkio-buities nuotekos - F1 1
1189651 | 4 a V1 | 6.3071 | 12650.9 | Ūkio-buities nuotekos - F1 1
1189738 | 4 a V1 | 1112.12 | 12819.7 | Ūkio-buities nuotekos - F1 1
1189830 | 4 a V1 | 470.127 | 12657.4 | Ūkio-buities nuotekos - F1 1
1189841 | 4 a V1 | 194.177 | 12628.4 | Ūkio-buities nuotekos - F1 1
1189937 | 4 a V1 | 1027.05 | 12788.7 | Ūkio-buities nuotekos - F1 1
1190013 | 4 a V1 | 109.246 | 12659.6 | Ūkio-buities nuotekos - F1 1
1190022 | 4 a V1 | 6158.03 | 12502.5 | Ūkio-buities nuotekos - F1 1
1190031 | 4 a V1 | 40.1476 | 14229.5 | Ūkio-buities nuotekos - F1 1
1190103 | 4 a V1 | 1376.23 | 12758.6 | Ūkio-buities nuotekos - F1 1
1190323 | 4 a V1 | 340.438 | 12306 | Ūkio-buities nuotekos - F1 1
1190332 | 4 a V1 | 963.492 | 12299.4 | Ūkio-buities nuotekos - F1 1
1190337 | 4 a V1 | 1368.14 | 12318.5 | Ūkio-buities nuotekos - F1 1
1190351 | 4 a V1 | 223.898 | 12385.9 | Ūkio-buities nuotekos - F1 1
1190563 | 4 a V1 | 1198.06 | 12558.8 | Ūkio-buities nuotekos - F1 1
1190629 | 4 a V1 | 381.388 | 12373.8 | Ūkio-buities nuotekos - F1 1
1190638 | 4 a V1 | 382.467 | 12358.9 | Ūkio-buities nuotekos - F1 1
1190645 | 4 a V1 | 84.7533 | 14052.6 | Ūkio-buities nuotekos - F1 1
1190685 | 4 a V1 | 1382.02 | 12549.8 | Ūkio-buities nuotekos - F1 1
1190780 | 4 a V1 | 347.785 | 12376.8 | Ūkio-buities nuotekos - F1 1
1190795 | 4 a V1 | 195.015 | 12351.6 | Ūkio-buities nuotekos - F1 1
1190878 | 4 a V1 | 1340.47 | 12505.3 | Ūkio-buities nuotekos - F1 1
1190922 | 4 a V1 | 2046.7 | 12408.7 | Ūkio-buities nuotekos - F1 1
1190935 | 4 a V1 | 63.3114 | 12371 | Ūkio-buities nuotekos - F1 1
1190944 | 4 a V1 | 809.338 | 12453.4 | Ūkio-buities nuotekos - F1 1
1190958 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 1
1191031 | 4 a V1 | 1568.46 | 12566.4 | Ūkio-buities nuotekos - F1 1
1191149 | 4 a V1 | 509.406 | 12417.1 | Ūkio-buities nuotekos - F1 1
1191162 | 4 a V1 | 400.96 | 12375.1 | Ūkio-buities nuotekos - F1 1
1191185 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 1
1191211 | 4 a V1 | 1610.73 | 12524.1 | Ūkio-buities nuotekos - F1 1
1191312 | 4 a V1 | 386.715 | 12954.5 | K1 2
1191321 | 5 a V1 | 336.565 | 12923.3 | K1 2
1191330 | 4 a V1 | 1033.74 | 12963.8 | K1 2
1191375 | 4 a V1 | 198.79 | 12998.5 | K1 2
1191387 | 4 a V1 | 127.489 | 14229.5 | K1 2
1191448 | 4 a V1 | 1035.52 | 13099.3 | K1 2
1191489 | 4 a V1 | 554.785 | 13002.7 | K1 2
1191498 | 4 a V1 | 502.571 | 12986 | K1 2
1191505 | 4 a V1 | 111.824 | 13017.9 | K1 2
1191519 | 4 a V1 | 96.9894 | 14229.5 | K1 2
1191551 | 4 a V1 | 1017.91 | 13116.9 | K1 2
1191676 | 4 a V1 | 362.32 | 13030.5 | K1 2
1191687 | 4 a V1 | 1297.41 | 12998.7 | K1 2
1191694 | 4 a V1 | 269.264 | 13041.5 | K1 2
1191708 | 4 a V1 | 87.4809 | 14229.5 | K1 2
1191738 | 4 a V1 | 991.102 | 13143.7 | K1 2
1191784 | 4 a V1 | 996.721 | 13179.8 | K1 2
1191807 | 4 a V1 | 163.565 | 13068.7 | K1 2
1191816 | 4 a V1 | 69.1922 | 13203.5 | K1 2
1191946 | 4 a V1 | 107.485 | 14229.5 | K1 2
1191955 | 4 a V1 | 833.092 | 13301.8 | K1 2
1191997 | 4 a V1 | 100.21 | 13182.4 | K1 2
1192006 | 4 a V1 | 3572.2 | 13105.9 | K1 2
1192062 | 4 a V1 | 87.4489 | 14229.5 | K1 2
1192071 | 4 a V1 | 853.596 | 13281.3 | K1 2
1192102 | 4 a V1 | 735.077 | 12921.3 | Ūkio-buities nuotekos - F1 5
1192111 | 4 a V1 | 1084.31 | 12892.6 | Ūkio-buities nuotekos - F1 5
1192118 | 4 a V1 | 1223.53 | 12937.5 | Ūkio-buities nuotekos - F1 5
1192163 | 4 a V1 | 484.006 | 12999.9 | Ūkio-buities nuotekos - F1 5
1192175 | 4 a V1 | 271.875 | 13013.4 | Ūkio-buities nuotekos - F1 5
1192189 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 5
1192224 | 4 a V1 | 1019.16 | 13115.7 | Ūkio-buities nuotekos - F1 5
1192253 | 4 a V1 | 107.485 | 14229.5 | Ūkio-buities nuotekos - F1 5
1192262 | 4 a V1 | 1007.75 | 13127.1 | Ūkio-buities nuotekos - F1 5
1192265 | 4 a V1 | 464.832 | 12988.2 | Ūkio-buities nuotekos - F1 5
1192389 | 4 a V1 | 240.242 | 12993.2 | Ūkio-buities nuotekos - F1 5
1192400 | 4 a V1 | 1108.99 | 12963.5 | Ūkio-buities nuotekos - F1 5
1192407 | 4 a V1 | 67.4769 | 14229.5 | Ūkio-buities nuotekos - F1 5
1192444 | 4 a V1 | 1040.03 | 13094.8 | Ūkio-buities nuotekos - F1 5
1192473 | 4 a V1 | 299.806 | 12900.7 | Ūkio-buities nuotekos - F1 5
1192482 | 4 a V1 | 298.243 | 12889.7 | Ūkio-buities nuotekos - F1 5
1192495 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 5
1192558 | 4 a V1 | 1132.4 | 13002.4 | Ūkio-buities nuotekos - F1 5
1192680 | 4 a V1 | 320.254 | 12861.3 | Ūkio-buities nuotekos - F1 5
1192689 | 4 a V1 | 362.898 | 12849 | Ūkio-buities nuotekos - F1 5
1192764 | 4 a V1 | 1170.33 | 12964.5 | Ūkio-buities nuotekos - F1 5
1192835 | 4 a V1 | 330.545 | 13182.5 | Ūkio-buities nuotekos - F1 6
1192848 | 4 a V1 | 263.189 | 13172.2 | Ūkio-buities nuotekos - F1 6
1192885 | 4 a V1 | 87.4809 | 14229.5 | Ūkio-buities nuotekos - F1 6
1193079 | 4 a V1 | 854.202 | 13280.6 | Ūkio-buities nuotekos - F1 6
1193213 | 4 a V1 | 351.361 | 13183.4 | Ūkio-buities nuotekos - F1 6
1193224 | 4 a V1 | 107.186 | 13147.3 | Ūkio-buities nuotekos - F1 6
1193233 | 4 a V1 | 36.0803 | 13194.2 | Ūkio-buities nuotekos - F1 6
1193247 | 4 a V1 | 953.535 | 13196.5 | Ūkio-buities nuotekos - F1 6
1193292 | 4 a V1 | 510.101 | 13249.4 | Ūkio-buities nuotekos - F1 6
1193304 | 4 a V1 | 276.32 | 13263.4 | Ūkio-buities nuotekos - F1 6
1193318 | 4 a V1 | 98.2542 | 14229.5 | Ūkio-buities nuotekos - F1 6
1193356 | 4 a V1 | 769.094 | 13365.8 | Ūkio-buities nuotekos - F1 6
1193385 | 4 a V1 | 91.9433 | 14229.5 | Ūkio-buities nuotekos - F1 6
1193394 | 4 a V1 | 758.292 | 13376.6 | Ūkio-buities nuotekos - F1 6
1193397 | 4 a V1 | 935.155 | 13217.1 | Ūkio-buities nuotekos - F1 6
1193802 | 4 a V1 | 224.698 | 13240.9 | Ūkio-buities nuotekos - F1 6
1193811 | 4 a V1 | 432.518 | 13238.3 | Ūkio-buities nuotekos - F1 6
1193816 | 4 a V1 | 56.7043 | 14229.5 | Ūkio-buities nuotekos - F1 6
1193851 | 4 a V1 | 792.634 | 13342.2 | Ūkio-buities nuotekos - F1 6
1193880 | 4 a V1 | 478.3 | 13119.5 | Ūkio-buities nuotekos - F1 6
1193891 | 4 a V1 | 622.156 | 13102.1 | Ūkio-buities nuotekos - F1 6
1193898 | 4 a V1 | 702.734 | 13132.9 | Ūkio-buities nuotekos - F1 6
1193912 | 4 a V1 | 157.197 | 14229.5 | Ūkio-buities nuotekos - F1 6
1193985 | 4 a V1 | 891.061 | 13243.8 | Ūkio-buities nuotekos - F1 6
1194062 | 4 a V1 | 158.926 | 12861.7 | Ūkio-buities nuotekos - F1 7
1194071 | 4 a V1 | 518.854 | 12901.2 | Ūkio-buities nuotekos - F1 7
1194110 | 4 a V1 | 1434.15 | 12915.3 | Ūkio-buities nuotekos - F1 7
1194138 | 4 a V1 | 8.44025 | 12947.8 | Ūkio-buities nuotekos - F1 7
1194212 | 4 a V1 | 1090.03 | 13044.8 | Ūkio-buities nuotekos - F1 7
1194398 | 4 a V1 | 260.242 | 12923.8 | Ūkio-buities nuotekos - F1 7
1194411 | 4 a V1 | 567.442 | 12907.4 | Ūkio-buities nuotekos - F1 7
1194484 | 4 a V1 | 1109 | 13025.8 | Ūkio-buities nuotekos - F1 7
1194569 | 4 a V1 | 108.713 | 12579.6 | Ūkio-buities nuotekos - F1 9
1194580 | 4 a V1 | 619.59 | 12533.3 | Ūkio-buities nuotekos - F1 9
1194589 | 4 a V1 | 951.992 | 12585.6 | Ūkio-buities nuotekos - F1 9
1194677 | 4 a V1 | 1433.39 | 12701.5 | Ūkio-buities nuotekos - F1 9
1194712 | 4 a V1 | 108.579 | 13308.8 | Ūkio-buities nuotekos - F1 10
1194723 | 4 a V1 | 1100 | 13279.3 | Ūkio-buities nuotekos - F1 10
1194730 | 4 a V1 | 931.457 | 13314.7 | Ūkio-buities nuotekos - F1 10
1194744 | 4 a V1 | 208.808 | 13337.1 | Ūkio-buities nuotekos - F1 10
1194813 | 4 a V1 | 696.711 | 13438.1 | Ūkio-buities nuotekos - F1 10
1194848 | 4 a V1 | 283.444 | 13280.6 | Ūkio-buities nuotekos - F1 10
1194859 | 4 a V1 | 510.562 | 13265.4 | Ūkio-buities nuotekos - F1 10
1194928 | 4 a V1 | 751.712 | 13383.1 | Ūkio-buities nuotekos - F1 10
1195069 | 4 a V1 | 504.761 | 12632.6 | Ūkio-buities nuotekos - F1 8
1195080 | 4 a V1 | 2541.16 | 12536.9 | Ūkio-buities nuotekos - F1 8
1195089 | 4 a V1 | 691.94 | 12646.4 | Ūkio-buities nuotekos - F1 8
1195103 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 8
1195131 | 4 a V1 | 1377.75 | 12757.1 | Ūkio-buities nuotekos - F1 8
1195160 | 4 a V1 | 329 | 12643 | Ūkio-buities nuotekos - F1 8
1195169 | 4 a V1 | 420.84 | 12621.7 | Ūkio-buities nuotekos - F1 8
1195182 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 8
1195222 | 4 a V1 | 1392.38 | 12742.5 | Ūkio-buities nuotekos - F1 8
1195284 | 4 a V1 | 339.682 | 12645.4 | Ūkio-buities nuotekos - F1 8
1195293 | 4 a V1 | 627.675 | 12635.1 | Ūkio-buities nuotekos - F1 8
1195600 | 4 a V1 | 1393.49 | 12741.4 | Ūkio-buities nuotekos - F1 8
1195654 | 4 a V1 | 2962.84 | 12761.6 | Ūkio-buities nuotekos - F1 8
1195663 | 4 a V1 | 45.0081 | 12755.6 | Ūkio-buities nuotekos - F1 8
1195670 | 4 a V1 | 509.312 | 12824.6 | Ūkio-buities nuotekos - F1 8
1195684 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 8
1195750 | 4 a V1 | 1203.24 | 12931.6 | Ūkio-buities nuotekos - F1 8
1196277 | 5 a V1 | 271.444 | 17214.5 | K1 2
1196286 | 5 a V1 | 250.563 | 17140.1 | K1 2
1196295 | 5 a V1 | 189.248 | 17223.7 | K1 2
1196309 | 5 a V1 | 119.786 | 18729.5 | K1 2
1196352 | 5 a V1 | 1310.52 | 17324.3 | K1 2
1196381 | 5 a V1 | 3422.93 | 17217.1 | K1 2
1196392 | 5 a V1 | 2474.08 | 17162.6 | K1 2
1196399 | 5 a V1 | 3269.86 | 17289.3 | K1 2
1196413 | 5 a V1 | 46.3549 | 18439.5 | K1 2
1196459 | 5 a V1 | 893.318 | 17451.5 | K1 2
1196505 | 5 a V1 | 1165.9 | 17388.2 | Ūkio-buities nuotekos - F1 5
1196513 | 5 a V1 | 9.21224 | 17415.3 | Ūkio-buities nuotekos - F1 5
1196527 | 5 a V1 | 147.493 | 18729.5 | Ūkio-buities nuotekos - F1 5
1196577 | 5 a V1 | 1122.49 | 17512.4 | Ūkio-buities nuotekos - F1 5
1196777 | 5 a V1 | 731.246 | 18084.4 | Ūkio-buities nuotekos - F1 5
1196816 | 5 a V1 | 202.328 | 18552.6 | Ūkio-buities nuotekos - F1 5
1196850 | 5 a V1 | 164.413 | 18267.4 | Ūkio-buities nuotekos - F1 5
1196879 | 5 a V1 | 152.87 | 18115.6 | Ūkio-buities nuotekos - F1 5
1196892 | 5 a V1 | 183.899 | 18077.9 | Ūkio-buities nuotekos - F1 5
1196948 | 5 a V1 | 4436.13 | 17395.7 | Ūkio-buities nuotekos - F1 5
1196956 | 5 a V1 | 269.264 | 17488.2 | Ūkio-buities nuotekos - F1 5
1196970 | 5 a V1 | 227.509 | 18729.5 | Ūkio-buities nuotekos - F1 5
1197032 | 5 a V1 | 1044.46 | 17590.4 | Ūkio-buities nuotekos - F1 5
1197239 | 5 a V1 | 9.42189 | 16982.6 | Ūkio-buities nuotekos - F1 7
1197248 | 5 a V1 | 6592.54 | 17011.3 | Ūkio-buities nuotekos - F1 7
1197320 | 5 a V1 | 2242.18 | 17146.9 | Ūkio-buities nuotekos - F1 7
1197334 | 5 a V1 | 54.8158 | 18439.5 | Ūkio-buities nuotekos - F1 7
1197372 | 5 a V1 | 1056.26 | 17288.6 | Ūkio-buities nuotekos - F1 7
1197457 | 5 a V1 | 88.8205 | 17593.2 | Ūkio-buities nuotekos - F1 10
1197470 | 4 a V1 | 512.956 | 17562 | Ūkio-buities nuotekos - F1 10
1197493 | 5 a V1 | 592.056 | 17598.7 | Ūkio-buities nuotekos - F1 10
1197507 | 5 a V1 | 247.513 | 18729.5 | Ūkio-buities nuotekos - F1 10
1197546 | 5 a V1 | 927.438 | 17707.4 | Ūkio-buities nuotekos - F1 10
1197599 | 4 a V1 | 466.243 | 12425.1 | Ūkio-buities nuotekos - F1 12
1197621 | 4 a V1 | 148.372 | 14052.6 | Ūkio-buities nuotekos - F1 12
1197649 | 4 a V1 | 1329.03 | 12602.8 | Ūkio-buities nuotekos - F1 12
1197890 | 4 a V1 | 1257.99 | 12568.5 | Ūkio-buities nuotekos - F1 12
1198088 | 4 a V1 | 579.367 | 13166.8 | Ūkio-buities nuotekos - F1 12
1198248 | 4 a V1 | 1329.03 | 12894 | Ūkio-buities nuotekos - F1 12
1198264 | 4 a V1 | 947.468 | 12957.2 | Ūkio-buities nuotekos - F1 12
1198278 | 4 a V1 | 1672.31 | 12979.9 | Ūkio-buities nuotekos - F1 12
1198292 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 12
1198326 | 4 a V1 | 1024.64 | 13110.2 | Ūkio-buities nuotekos - F1 12
1198357 | 4 a V1 | 280.325 | 12962.2 | Ūkio-buities nuotekos - F1 12
1198368 | 4 a V1 | 1521.02 | 12924.3 | Ūkio-buities nuotekos - F1 12
1198375 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 12
1198401 | 4 a V1 | 1070.21 | 13064.6 | Ūkio-buities nuotekos - F1 12
1198441 | 4 a V1 | 260.013 | 12885 | Ūkio-buities nuotekos - F1 12
1198796 | 4 a V1 | 9.72047 | 12712.3 | Ūkio-buities nuotekos - F1 12
1198826 | 4 a V1 | 60.2015 | 12889.6 | Ūkio-buities nuotekos - F1 12
1198835 | 4 a V1 | 227.996 | 12878 | Ūkio-buities nuotekos - F1 12
1198842 | 4 a V1 | 102.802 | 14229.5 | Ūkio-buities nuotekos - F1 12
1198874 | 4 a V1 | 948.768 | 13186.1 | Ūkio-buities nuotekos - F1 12
1199111 | 4 a V1 | 85.8927 | 13137.2 | Ūkio-buities nuotekos - F1 12
1199120 | 4 a V1 | 81.8747 | 12862.8 | Ūkio-buities nuotekos - F1 12
1199272 | 4 a V1 | 12.9093 | 13144.6 | Ūkio-buities nuotekos - F1 12
1199333 | 4 a V1 | 618.603 | 13313.2 | Ūkio-buities nuotekos - F1 12
1199455 | 4 a V1 | 75.1478 | 12987.6 | Ūkio-buities nuotekos - F1 12
1199920 | 4 a V1 | 209.401 | 13188.8 | Ūkio-buities nuotekos - F1 12
1199928 | 4 a V1 | 68.6906 | 13196.8 | Ūkio-buities nuotekos - F1 12
1199942 | 4 a V1 | 1149.39 | 13201.9 | Ūkio-buities nuotekos - F1 12
1199956 | 4 a V1 | 131.828 | 13228.7 | Ūkio-buities nuotekos - F1 12
1200055 | 4 a V1 | 806.669 | 13328.2 | Ūkio-buities nuotekos - F1 12
1200118 | 4 a V1 | 172.411 | 12533.4 | Ūkio-buities nuotekos - F1 12
1200141 | 4 a V1 | 413.697 | 12578.6 | Ūkio-buities nuotekos - F1 12
1200234 | 4 a V1 | 1119.31 | 12708.5 | Ūkio-buities nuotekos - F1 12
1200312 | 4 a V1 | 2417.76 | 12593.4 | Ūkio-buities nuotekos - F1 12
1200327 | 4 a V1 | 823.465 | 12559.5 | Ūkio-buities nuotekos - F1 12
1200336 | 4 a V1 | 401.474 | 12660 | Ūkio-buities nuotekos - F1 12
1200350 | 4 a V1 | 31.6148 | 12671.8 | Ūkio-buities nuotekos - F1 12
1200364 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 12
1200392 | 4 a V1 | 1365.57 | 12769.3 | Ūkio-buities nuotekos - F1 12
1200439 | 4 a V1 | 1418.7 | 12662.6 | Ūkio-buities nuotekos - F1 12
1200450 | 4 a V1 | 599.322 | 12645.5 | Ūkio-buities nuotekos - F1 12
1200463 | 4 a V1 | 751.753 | 12679.8 | Ūkio-buities nuotekos - F1 12
1200510 | 4 a V1 | 103.954 | 14229.5 | Ūkio-buities nuotekos - F1 12
1200543 | 4 a V1 | 1343.15 | 12791.7 | Ūkio-buities nuotekos - F1 12
1200644 | 4 a V1 | 621.064 | 13124.3 | Ūkio-buities nuotekos - F1 13
1200844 | 4 a V1 | 1551.68 | 12970.6 | Ūkio-buities nuotekos - F1 13
1200856 | 4 a V1 | 191.923 | 13005.4 | Ūkio-buities nuotekos - F1 13
1200870 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 13
1200904 | 4 a V1 | 1028.78 | 13106.1 | Ūkio-buities nuotekos - F1 13
1201023 | 4 a V1 | 239.973 | 12898.2 | Ūkio-buities nuotekos - F1 13
1201032 | 4 a V1 | 134.196 | 12872.8 | Ūkio-buities nuotekos - F1 13
1201077 | 4 a V1 | 800.558 | 13024.6 | Ūkio-buities nuotekos - F1 13
1201145 | 4 a V1 | 760.599 | 12906.5 | Ūkio-buities nuotekos - F1 13
1201154 | 4 a V1 | 396.492 | 12889.9 | Ūkio-buities nuotekos - F1 13
1201167 | 4 a V1 | 109.282 | 14052.6 | Ūkio-buities nuotekos - F1 13
1201205 | 4 a V1 | 853.926 | 13077.9 | Ūkio-buities nuotekos - F1 13
1201244 | 4 a V1 | 780.187 | 12925.7 | Ūkio-buities nuotekos - F1 13
1201253 | 4 a V1 | 864.179 | 12902.3 | Ūkio-buities nuotekos - F1 13
1201266 | 4 a V1 | 129.286 | 14052.6 | Ūkio-buities nuotekos - F1 13
1201298 | 4 a V1 | 840.756 | 13091.1 | Ūkio-buities nuotekos - F1 13
1201337 | 4 a V1 | 249.969 | 12967.9 | Ūkio-buities nuotekos - F1 13
1201350 | 4 a V1 | 1056.3 | 12924 | Ūkio-buities nuotekos - F1 13
1201385 | 4 a V1 | 731.309 | 13094.5 | Ūkio-buities nuotekos - F1 13
1201603 | 4 a V1 | 430.097 | 13325 | Ūkio-buities nuotekos - F1 13
1201637 | 4 a V1 | 731.403 | 13121 | Ūkio-buities nuotekos - F1 13
1201646 | 4 a V1 | 141.497 | 13111.5 | Ūkio-buities nuotekos - F1 13
1201653 | 4 a V1 | 180.51 | 13141.4 | Ūkio-buities nuotekos - F1 13
1201675 | 4 a V1 | 180.515 | 14052.6 | Ūkio-buities nuotekos - F1 13
1201715 | 4 a V1 | 618.488 | 13313.3 | Ūkio-buities nuotekos - F1 13
1201760 | 4 a V1 | 493.216 | 13332.5 | Ūkio-buities nuotekos - F1 13
1201763 | 4 a V1 | 215.594 | 13118.8 | Ūkio-buities nuotekos - F1 13
1201810 | 4 a V1 | 64.0634 | 13112.2 | Ūkio-buities nuotekos - F1 13
1201821 | 4 a V1 | 83.2283 | 13074.2 | Ūkio-buities nuotekos - F1 13
1201830 | 4 a V1 | 171.304 | 13117.3 | Ūkio-buities nuotekos - F1 13
1201844 | 4 a V1 | 12.2319 | 13124.5 | Ūkio-buities nuotekos - F1 13
1201920 | 4 a V1 | 151.833 | 14229.5 | Ūkio-buities nuotekos - F1 13
1201931 | 4 a V1 | 913.285 | 13221.6 | Ūkio-buities nuotekos - F1 13
1201978 | 4 a V1 | 726.691 | 13107.7 | Ūkio-buities nuotekos - F1 13
1201989 | 4 a V1 | 45.0161 | 13070.5 | Ūkio-buities nuotekos - F1 13
1201998 | 4 a V1 | 354.131 | 13126 | Ūkio-buities nuotekos - F1 13
1202012 | 4 a V1 | 150.868 | 14229.5 | Ūkio-buities nuotekos - F1 13
1202050 | 4 a V1 | 904.876 | 13230 | Ūkio-buities nuotekos - F1 13
1202325 | 4 a V1 | 452.855 | 13088.1 | Ūkio-buities nuotekos - F1 13
1202338 | 4 a V1 | 401.408 | 13059 | Ūkio-buities nuotekos - F1 13
1202347 | 4 a V1 | 737.007 | 13101.6 | Ūkio-buities nuotekos - F1 13
1202363 | 4 a V1 | 310.784 | 13286.2 | Ūkio-buities nuotekos - F1 13
1202397 | 4 a V1 | 184.079 | 13083.5 | Ūkio-buities nuotekos - F1 13
1202408 | 4 a V1 | 74.5383 | 13048.1 | Ūkio-buities nuotekos - F1 13
1202417 | 4 a V1 | 424.69 | 13091 | Ūkio-buities nuotekos - F1 13
1202431 | 4 a V1 | 152.198 | 13103.2 | Ūkio-buities nuotekos - F1 13
1202445 | 4 a V1 | 123.185 | 14229.5 | Ūkio-buities nuotekos - F1 13
1202475 | 4 a V1 | 931.715 | 13203.1 | Ūkio-buities nuotekos - F1 13
1202676 | 4 a V1 | 886.763 | 13090.1 | Ūkio-buities nuotekos - F1 13
1202685 | 4 a V1 | 189.253 | 13052.4 | Ūkio-buities nuotekos - F1 13
1202694 | 4 a V1 | 542.052 | 13111.6 | Ūkio-buities nuotekos - F1 13
1202708 | 4 a V1 | 111.881 | 14229.5 | Ūkio-buities nuotekos - F1 13
1202738 | 4 a V1 | 915.538 | 13219.3 | Ūkio-buities nuotekos - F1 13
1202837 | 4 a V1 | 519.505 | 13228.3 | Ūkio-buities nuotekos - F1 14
1202883 | 4 a V1 | 73.1402 | 13071.4 | Ūkio-buities nuotekos - F1 14
1202901 | 4 a V1 | 344.561 | 13252.4 | Ūkio-buities nuotekos - F1 14
1202941 | 4 a V1 | 805.456 | 13033 | Ūkio-buities nuotekos - F1 14
1202981 | 4 a V1 | 465.755 | 13090.3 | Ūkio-buities nuotekos - F1 14
1202996 | 4 a V1 | 351.288 | 13075.5 | Ūkio-buities nuotekos - F1 14
1203005 | 4 a V1 | 201.434 | 13103.4 | Ūkio-buities nuotekos - F1 14
1203019 | 4 a V1 | 117.076 | 14229.5 | Ūkio-buities nuotekos - F1 14
1203062 | 4 a V1 | 930.553 | 13204.3 | Ūkio-buities nuotekos - F1 14
1203091 | 4 a V1 | 1041.38 | 13037.2 | Ūkio-buities nuotekos - F1 14
1203100 | 4 a V1 | 310.208 | 13022.4 | Ūkio-buities nuotekos - F1 14
1203107 | 4 a V1 | 139.628 | 14052.6 | Ūkio-buities nuotekos - F1 14
1203144 | 4 a V1 | 705.426 | 13226.4 | Ūkio-buities nuotekos - F1 14
1203205 | 4 a V1 | 210.82 | 13011.4 | Ūkio-buities nuotekos - F1 14
1203214 | 4 a V1 | 1846.97 | 12965.9 | Ūkio-buities nuotekos - F1 14
1203221 | 4 a V1 | 345.443 | 13021.4 | Ūkio-buities nuotekos - F1 14
1203235 | 4 a V1 | 137.829 | 14052.6 | Ūkio-buities nuotekos - F1 14
1203267 | 4 a V1 | 735.202 | 13196.6 | Ūkio-buities nuotekos - F1 14
1203296 | 4 a V1 | 452.846 | 13051.6 | Ūkio-buities nuotekos - F1 14
1203309 | 4 a V1 | 208.827 | 13007.2 | Ūkio-buities nuotekos - F1 14
1203318 | 4 a V1 | 178.842 | 13064.4 | Ūkio-buities nuotekos - F1 14
1203332 | 4 a V1 | 69.6466 | 13829.5 | Ūkio-buities nuotekos - F1 14
1203369 | 4 a V1 | 570.034 | 13164.8 | Ūkio-buities nuotekos - F1 14
1203398 | 4 a V1 | 222.296 | 13054.1 | Ūkio-buities nuotekos - F1 14
1203407 | 4 a V1 | 185.696 | 13045.4 | Ūkio-buities nuotekos - F1 14
1203414 | 4 a V1 | 19.622 | 13062.4 | Ūkio-buities nuotekos - F1 14
1203428 | 4 a V1 | 60.0565 | 14229.5 | Ūkio-buities nuotekos - F1 14
1203493 | 4 a V1 | 975.247 | 13159.6 | Ūkio-buities nuotekos - F1 14
1203522 | 4 a V1 | 429.31 | 13053.5 | Ūkio-buities nuotekos - F1 14
1203531 | 4 a V1 | 266.427 | 13014.2 | Ūkio-buities nuotekos - F1 14
1203540 | 4 a V1 | 117.079 | 14229.5 | Ūkio-buities nuotekos - F1 14
1203571 | 4 a V1 | 975.894 | 13159 | Ūkio-buities nuotekos - F1 14
1203601 | 4 a V1 | 272.749 | 12962.6 | Ūkio-buities nuotekos - F1 14
1203616 | 4 a V1 | 131.711 | 12951.4 | Ūkio-buities nuotekos - F1 14
1203629 | 4 a V1 | 442.961 | 12966.4 | Ūkio-buities nuotekos - F1 14
1203651 | 4 a V1 | 191.387 | 14052.6 | Ūkio-buities nuotekos - F1 14
1203676 | 4 a V1 | 788.216 | 13143.6 | Ūkio-buities nuotekos - F1 14
1203705 | 4 a V1 | 719.242 | 12997 | Ūkio-buities nuotekos - F1 14
1203720 | 4 a V1 | 231.107 | 12958.4 | Ūkio-buities nuotekos - F1 14
1203729 | 4 a V1 | 1202.45 | 13015.2 | Ūkio-buities nuotekos - F1 14
1203743 | 4 a V1 | 267.517 | 14229.5 | Ūkio-buities nuotekos - F1 14
1203775 | 4 a V1 | 998.783 | 13136.1 | Ūkio-buities nuotekos - F1 14
1203843 | 5 a V1 | 300.027 | 13462.2 | Ūkio-buities nuotekos - F1 16
1203876 | 4 a V1 | 34.7275 | 13307.5 | Ūkio-buities nuotekos - F1 16
1203918 | 4 a V1 | 118.853 | 13478.1 | Ūkio-buities nuotekos - F1 16
1203929 | 4 a V1 | 191.975 | 13284.4 | Ūkio-buities nuotekos - F1 16
1203969 | 4 a V1 | 252.938 | 13473.9 | Ūkio-buities nuotekos - F1 16
1204031 | 4 a V1 | 717.653 | 13333.6 | Ūkio-buities nuotekos - F1 16
1204054 | 4 a V1 | 1141.32 | 13288.5 | Ūkio-buities nuotekos - F1 16
1204077 | 4 a V1 | 14.9176 | 13351.7 | Ūkio-buities nuotekos - F1 16
1204091 | 4 a V1 | 121.903 | 14229.5 | Ūkio-buities nuotekos - F1 16
1204125 | 4 a V1 | 685.989 | 13448.9 | Ūkio-buities nuotekos - F1 16
1204162 | 4 a V1 | 79.1583 | 14052.6 | Ūkio-buities nuotekos - F1 16
1204171 | 4 a V1 | 420.285 | 13511.5 | Ūkio-buities nuotekos - F1 16
1204174 | 5 a V1 | 116.373 | 13264 | Ūkio-buities nuotekos - F1 16
1204262 | 4 a V1 | 357.568 | 13254.5 | Ūkio-buities nuotekos - F1 16
1204271 | 4 a V1 | 1813.46 | 13223.3 | Ūkio-buities nuotekos - F1 16
1204294 | 4 a V1 | 17.3995 | 13265.4 | Ūkio-buities nuotekos - F1 16
1204341 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 16
1204405 | 4 a V1 | 772.241 | 13362.6 | Ūkio-buities nuotekos - F1 16
1204565 | 4 a V1 | 409.611 | 13199.3 | Ūkio-buities nuotekos - F1 16
1204574 | 4 a V1 | 532.711 | 13165.9 | Ūkio-buities nuotekos - F1 16
1204599 | 4 a V1 | 219.63 | 13377.4 | Ūkio-buities nuotekos - F1 16
1204610 | 4 a V1 | 2026.29 | 13180 | Ūkio-buities nuotekos - F1 16
1204686 | 4 a V1 | 352.759 | 13139 | Ūkio-buities nuotekos - F1 16
1204695 | 4 a V1 | 381.388 | 13158.2 | Ūkio-buities nuotekos - F1 16
1204734 | 4 a V1 | 279.765 | 13170.2 | Ūkio-buities nuotekos - F1 16
1204748 | 4 a V1 | 174.716 | 13180.2 | Ūkio-buities nuotekos - F1 16
1204764 | 4 a V1 | 243.386 | 13353.6 | Ūkio-buities nuotekos - F1 16
1204790 | 4 a V1 | 108.805 | 13180 | Ūkio-buities nuotekos - F1 16
1204801 | 4 a V1 | 567.114 | 13148.8 | Ūkio-buities nuotekos - F1 16
1204913 | 4 a V1 | 855.862 | 13279 | Ūkio-buities nuotekos - F1 16
1205107 | 4 a V1 | 9.00462 | 13060.4 | Ūkio-buities nuotekos - F1 16
1205115 | 4 a V1 | 112.312 | 14229.5 | Ūkio-buities nuotekos - F1 16
1205142 | 4 a V1 | 977.405 | 13157.4 | Ūkio-buities nuotekos - F1 16
1205294 | 4 a V1 | 235.44 | 13044.9 | Ūkio-buities nuotekos - F1 16
1205303 | 4 a V1 | 1302.17 | 13015.4 | Ūkio-buities nuotekos - F1 16
1205310 | 4 a V1 | 86.7504 | 14229.5 | Ūkio-buities nuotekos - F1 16
1205337 | 4 a V1 | 988.379 | 13146.5 | Ūkio-buities nuotekos - F1 16
1205427 | 4 a V1 | 12.2859 | 13018 | Ūkio-buities nuotekos - F1 16
1205436 | 4 a V1 | 644.007 | 13000.1 | Ūkio-buities nuotekos - F1 16
1205443 | 4 a V1 | 124.439 | 13022 | Ūkio-buities nuotekos - F1 16
1205457 | 4 a V1 | 50.0978 | 14229.5 | Ūkio-buities nuotekos - F1 16
1205528 | 4 a V1 | 1013.48 | 13121.4 | Ūkio-buities nuotekos - F1 16
1205628 | 4 a V1 | 51.8037 | 13065.3 | Ūkio-buities nuotekos - F1 19
1205644 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 19
1205672 | 4 a V1 | 971.721 | 13163.1 | Ūkio-buities nuotekos - F1 19
1205795 | 4 a V1 | 10.1915 | 12994.3 | Ūkio-buities nuotekos - F1 19
1205804 | 4 a V1 | 637.71 | 12976.5 | Ūkio-buities nuotekos - F1 19
1205811 | 4 a V1 | 147.493 | 14229.5 | Ūkio-buities nuotekos - F1 19
1205832 | 4 a V1 | 1043.5 | 13091.4 | Ūkio-buities nuotekos - F1 19
1205958 | 4 a V1 | 680.325 | 12939.9 | Ūkio-buities nuotekos - F1 19
1205967 | 4 a V1 | 1156.81 | 12911.8 | Ūkio-buities nuotekos - F1 19
1205974 | 4 a V1 | 199.63 | 14229.5 | Ūkio-buities nuotekos - F1 19
1206008 | 4 a V1 | 1084.46 | 13050.4 | Ūkio-buities nuotekos - F1 19
1206085 | 4 a V1 | 89.2282 | 12792.5 | Ūkio-buities nuotekos - F1 20
1206133 | 4 a V1 | 1243.7 | 12891.2 | Ūkio-buities nuotekos - F1 20
1206179 | 4 a V1 | 109.205 | 12557.2 | Ūkio-buities nuotekos - F1 18
1206195 | 4 a V1 | 80.2012 | 14229.5 | Ūkio-buities nuotekos - F1 18
1206218 | 4 a V1 | 1478.59 | 12656.3 | Ūkio-buities nuotekos - F1 18
1206261 | 4 a V1 | 182.326 | 12617.2 | Ūkio-buities nuotekos - F1 18
1206274 | 4 a V1 | 3420.63 | 12546.2 | Ūkio-buities nuotekos - F1 18
1206281 | 4 a V1 | 39.2382 | 12624.6 | Ūkio-buities nuotekos - F1 18
1206446 | 4 a V1 | 127.489 | 14229.5 | Ūkio-buities nuotekos - F1 18
1206455 | 4 a V1 | 1412.64 | 12722.2 | Ūkio-buities nuotekos - F1 18
1206484 | 4 a V1 | 220.234 | 12696.6 | Ūkio-buities nuotekos - F1 18
1206493 | 4 a V1 | 94.1718 | 12688 | Ūkio-buities nuotekos - F1 18
1206500 | 4 a V1 | 87.4809 | 14229.5 | Ūkio-buities nuotekos - F1 18
1206559 | 4 a V1 | 1336.98 | 12797.9 | Ūkio-buities nuotekos - F1 18
1206624 | 4 a V1 | 209.352 | 12713.3 | Ūkio-buities nuotekos - F1 18
1206640 | 4 a V1 | 116.739 | 14229.5 | Ūkio-buities nuotekos - F1 18
1206674 | 4 a V1 | 1320.51 | 12814.3 | Ūkio-buities nuotekos - F1 18
1206727 | 4 a V1 | 20.1995 | 12717 | Ūkio-buities nuotekos - F1 18
1206736 | 4 a V1 | 1326.13 | 12685.4 | Ūkio-buities nuotekos - F1 18
1206769 | 4 a V1 | 1320.63 | 12814.2 | Ūkio-buities nuotekos - F1 18
1206819 | 4 a V1 | 94.1872 | 12792.2 | Ūkio-buities nuotekos - F1 18
1206957 | 4 a V1 | 101.009 | 14229.5 | Ūkio-buities nuotekos - F1 18
1206966 | 4 a V1 | 1243.9 | 12890.9 | Ūkio-buities nuotekos - F1 18
1207012 | 4 a V1 | 2420.14 | 12762.8 | Ūkio-buities nuotekos - F1 18
1207023 | 4 a V1 | 2171.18 | 12714.4 | Ūkio-buities nuotekos - F1 18
1207030 | 4 a V1 | 651.932 | 12815 | Ūkio-buities nuotekos - F1 18
1207044 | 4 a V1 | 161.53 | 14229.5 | Ūkio-buities nuotekos - F1 18
1207117 | 4 a V1 | 1209.95 | 12924.9 | Ūkio-buities nuotekos - F1 18
1209004 | 4 a V1 | 370.604 | 12596.3 | Ūkio-buities nuotekos - F1 16
1209155 | 4 a V1 | 657.354 | 12577.2 | Ūkio-buities nuotekos - F1 16
