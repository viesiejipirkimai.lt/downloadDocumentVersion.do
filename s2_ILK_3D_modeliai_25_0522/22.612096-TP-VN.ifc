Properties of the parts of a building model (IFC2X3), part 38 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1861220_0 | SOURCEANDSINK | K1 32
Port_1861220_1 | SOURCEANDSINK | K1 32
Port_1861278_0 | SOURCEANDSINK | F1 n.p. 1
Port_1861286_3 | SOURCEANDSINK | F1 n.p. 1
Port_1861278_1 | SOURCEANDSINK | F1 n.p. 1
Port_1861313_2 | SOURCEANDSINK | F1 n.p. 1
Port_1861286_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864179_0 | SOURCEANDSINK | F1 n.p. 1
Port_1861286_2 | SOURCEANDSINK | F1 n.p. 1
Port_1861287_1 | SOURCEANDSINK | F1 n.p. 1
Port_1861305_0 | SOURCEANDSINK | F1 n.p. 1
Port_1861313_1 | SOURCEANDSINK | F1 n.p. 1
Port_1861305_1 | SOURCEANDSINK | F1 n.p. 1
Port_1861323_1 | SOURCEANDSINK | F1 n.p. 1
Port_1861317_0 | SOURCEANDSINK | F1 n.p. 1
Port_1861323_2 | SOURCEANDSINK | F1 n.p. 1
Port_1861317_1 | SOURCEANDSINK | F1 n.p. 1
Port_1861876_2 | SOURCEANDSINK | F1 n.p. 2
Port_1861877_1 | SOURCEANDSINK | F1 n.p. 2
Port_1861876_3 | SOURCEANDSINK | F1 n.p. 2
Port_1861899_0 | SOURCEANDSINK | F1 n.p. 2
Port_1861899_1 | SOURCEANDSINK | F1 n.p. 2
Port_1861913_2 | SOURCEANDSINK | F1 n.p. 2
Port_1861907_0 | SOURCEANDSINK | F1 n.p. 2
Port_1861913_1 | SOURCEANDSINK | F1 n.p. 2
Port_1861907_1 | SOURCEANDSINK | F1 n.p. 2
Port_1861972_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862362_2 | SOURCEANDSINK | F1 n.p. 3
Port_1861972_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862070_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862078_2 | SOURCEANDSINK | F1 n.p. 3
Port_1862070_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862273_2 | SOURCEANDSINK | F1 n.p. 3
Port_1862078_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862363_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862234_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862269_2 | SOURCEANDSINK | F1 n.p. 3
Port_1862234_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862273_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862249_0 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862253_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862249_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862263_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862250_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862259_2 | SOURCEANDSINK | F1 n.p. 3
Port_1862250_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862269_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862253_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862254_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862259_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862263_2 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 69
Port_1862354_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862362_3 | SOURCEANDSINK | F1 n.p. 3
Port_1862354_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862389_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862362_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862363_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862381_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862389_2 | SOURCEANDSINK | F1 n.p. 3
Port_1862381_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862399_2 | SOURCEANDSINK | F1 n.p. 3
Port_1862393_0 | SOURCEANDSINK | F1 n.p. 3
Port_1862399_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862393_1 | SOURCEANDSINK | F1 n.p. 3
Port_1862476_0 | SOURCEANDSINK | K1 33
Port_1862791_2 | SOURCEANDSINK | K1 33
Port_1862476_1 | SOURCEANDSINK | K1 33
Port_1862656_0 | SOURCEANDSINK | K1 33
Port_1862791_1 | SOURCEANDSINK | K1 33
Port_1862656_1 | SOURCEANDSINK | K1 33
Port_1862677_1 | SOURCEANDSINK | K1 33
Port_1862671_0 | SOURCEANDSINK | K1 33
Port_1862677_2 | SOURCEANDSINK | K1 33
Port_1862671_1 | SOURCEANDSINK | K1 33
Port_1862690_1 | SOURCEANDSINK | K1 33
Port_1862681_0 | SOURCEANDSINK | K1 33
Port_1862690_2 | SOURCEANDSINK | K1 33
Port_1862681_1 | SOURCEANDSINK | K1 33
Port_1862734_0 | SOURCEANDSINK | K1 34
Port_1862734_1 | SOURCEANDSINK | K1 34
Port_1862748_2 | SOURCEANDSINK | K1 34
Port_1862742_0 | SOURCEANDSINK | K1 34
Port_1862748_1 | SOURCEANDSINK | K1 34
Port_1862742_1 | SOURCEANDSINK | K1 34
Port_1862817_0 | SOURCEANDSINK | K1 35
Port_1862817_1 | SOURCEANDSINK | K1 35
Port_1862885_1 | SOURCEANDSINK | K1 35
Port_1862874_0 | SOURCEANDSINK | K1 35
Port_1862885_2 | SOURCEANDSINK | K1 35
Port_1862874_1 | SOURCEANDSINK | K1 35
Port_1862960_0 | SOURCEANDSINK | K1 36
Port_1862960_1 | SOURCEANDSINK | K1 36
Port_1862974_2 | SOURCEANDSINK | K1 36
Port_1862968_0 | SOURCEANDSINK | K1 36
Port_1862974_1 | SOURCEANDSINK | K1 36
Port_1862968_1 | SOURCEANDSINK | K1 36
Port_1863006_0 | SOURCEANDSINK | K1 37
Port_1863054_1 | SOURCEANDSINK | K1 37
Port_1863006_1 | SOURCEANDSINK | K1 37
Port_1863018_2 | SOURCEANDSINK | K1 37
Port_1863012_0 | SOURCEANDSINK | K1 37
Port_1863018_1 | SOURCEANDSINK | K1 37
Port_1863012_1 | SOURCEANDSINK | K1 37
Port_1863028_1 | SOURCEANDSINK | K1 37
Port_1863022_0 | SOURCEANDSINK | K1 37
Port_1863028_2 | SOURCEANDSINK | K1 37
Port_1863022_1 | SOURCEANDSINK | K1 37
Port_1863046_0 | SOURCEANDSINK | K1 37
Port_1863054_2 | SOURCEANDSINK | K1 37
Port_1863046_1 | SOURCEANDSINK | K1 37
Port_1863092_0 | SOURCEANDSINK | F1 n.p. 2
Port_1863574_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863545_0 | SOURCEANDSINK | F1 n.p. 2
Port_1863574_3 | SOURCEANDSINK | F1 n.p. 2
Port_1863545_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863887_2 | SOURCEANDSINK | F1 n.p. 2
Port_1863574_2 | SOURCEANDSINK | F1 n.p. 2
Port_1863575_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863879_0 | SOURCEANDSINK | F1 n.p. 2
Port_1863976_2 | SOURCEANDSINK | F1 n.p. 2
Port_1863879_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863887_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863977_0 | SOURCEANDSINK | F1 n.p. 2
Port_1863934_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864092_2 | SOURCEANDSINK | F1 n.p. 2
Port_1863934_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863995_2 | SOURCEANDSINK | F1 n.p. 2
Port_1863976_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863977_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863976_3 | SOURCEANDSINK | F1 n.p. 2
Port_1864038_0 | SOURCEANDSINK | F1 n.p. 2
Port_1863984_0 | SOURCEANDSINK | F1 n.p. 2
Port_1863995_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863984_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864005_1 | SOURCEANDSINK | F1 n.p. 2
Port_1863999_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864005_2 | SOURCEANDSINK | F1 n.p. 2
Port_1863999_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864023_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864048_2 | SOURCEANDSINK | F1 n.p. 2
Port_1864023_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864033_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864037_3 | SOURCEANDSINK | F1 n.p. 2
Port_1864033_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864043_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864034_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864043_2 | SOURCEANDSINK | F1 n.p. 2
Port_1864034_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864048_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864037_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864038_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864037_2 | SOURCEANDSINK | F1 n.p. 2
Port_1864093_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864084_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864092_3 | SOURCEANDSINK | F1 n.p. 2
Port_1864084_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864105_2 | SOURCEANDSINK | F1 n.p. 2
Port_1864092_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864093_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864099_0 | SOURCEANDSINK | F1 n.p. 2
Port_1864105_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864099_1 | SOURCEANDSINK | F1 n.p. 2
Port_1864178_2 | SOURCEANDSINK | F1 n.p. 1
Port_1864179_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864178_3 | SOURCEANDSINK | F1 n.p. 1
Port_1864323_0 | SOURCEANDSINK | F1 n.p. 1
Port_1864323_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864339_2 | SOURCEANDSINK | F1 n.p. 1
Port_1864333_0 | SOURCEANDSINK | F1 n.p. 1
Port_1864339_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864333_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864349_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864343_0 | SOURCEANDSINK | F1 n.p. 1
Port_1864349_2 | SOURCEANDSINK | F1 n.p. 1
Port_1864343_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864359_2 | SOURCEANDSINK | F1 n.p. 1
Port_1864353_0 | SOURCEANDSINK | F1 n.p. 1
Port_1864359_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864353_1 | SOURCEANDSINK | F1 n.p. 1
Port_1864496_0 | SOURCEANDSINK | K1 38
Port_1864510_2 | SOURCEANDSINK | K1 38
Port_1864496_1 | SOURCEANDSINK | K1 38
Port_1864585_1 | SOURCEANDSINK | K1 38
Port_1864504_0 | SOURCEANDSINK | K1 38
Port_1864510_1 | SOURCEANDSINK | K1 38
Port_1864504_1 | SOURCEANDSINK | K1 38
Port_1864575_0 | SOURCEANDSINK | K1 38
Port_1864585_2 | SOURCEANDSINK | K1 38
Port_1864575_1 | SOURCEANDSINK | K1 38
Port_1864623_0 | SOURCEANDSINK | K1 39
Port_1864623_1 | SOURCEANDSINK | K1 39
Port_1864637_2 | SOURCEANDSINK | K1 39
Port_1864631_0 | SOURCEANDSINK | K1 39
Port_1864637_1 | SOURCEANDSINK | K1 39
Port_1864631_1 | SOURCEANDSINK | K1 39
Port_1864647_2 | SOURCEANDSINK | K1 39
Port_1864641_0 | SOURCEANDSINK | K1 39
Port_1864647_1 | SOURCEANDSINK | K1 39
Port_1864641_1 | SOURCEANDSINK | K1 39
Port_1864741_0 | SOURCEANDSINK | K1 40
Port_1864741_1 | SOURCEANDSINK | K1 40
Port_1864861_0 | SOURCEANDSINK | K1 41
Port_1864861_1 | SOURCEANDSINK | K1 41
Port_1864875_2 | SOURCEANDSINK | K1 41
Port_1864869_0 | SOURCEANDSINK | K1 41
Port_1864875_1 | SOURCEANDSINK | K1 41
Port_1864869_1 | SOURCEANDSINK | K1 41
Port_1864917_0 | SOURCEANDSINK | K1 42
Port_1865035_2 | SOURCEANDSINK | K1 42
Port_1864917_1 | SOURCEANDSINK | K1 42
Port_1865025_0 | SOURCEANDSINK | K1 42
Port_1865035_3 | SOURCEANDSINK | K1 42
Port_1865025_1 | SOURCEANDSINK | K1 42
Port_1865035_1 | SOURCEANDSINK | K1 42
Port_1865036_1 | SOURCEANDSINK | K1 42
Port_1865036_0 | SOURCEANDSINK | K1 42
Port_1865089_2 | SOURCEANDSINK | K1 42
Port_1865075_0 | SOURCEANDSINK | K1 42
Port_1865117_2 | SOURCEANDSINK | K1 42
Port_1865075_1 | SOURCEANDSINK | K1 42
Port_1865089_1 | SOURCEANDSINK | K1 42
Port_1865090_1 | SOURCEANDSINK | K1 42
Port_1865089_3 | SOURCEANDSINK | K1 42
Port_1865118_0 | SOURCEANDSINK | K1 42
Port_1865090_0 | SOURCEANDSINK | K1 42
Port_1865109_0 | SOURCEANDSINK | K1 42
Port_1865117_3 | SOURCEANDSINK | K1 42
Port_1865109_1 | SOURCEANDSINK | K1 42
Port_1865117_1 | SOURCEANDSINK | K1 42
Port_1865118_1 | SOURCEANDSINK | K1 42
Port_1865153_0 | SOURCEANDSINK | K1 43
Port_1865153_1 | SOURCEANDSINK | K1 43
Port_1865174_0 | SOURCEANDSINK | K1 44
Port_1865206_2 | SOURCEANDSINK | K1 44
Port_1865174_1 | SOURCEANDSINK | K1 44
Port_1865196_0 | SOURCEANDSINK | K1 44
Port_1865206_3 | SOURCEANDSINK | K1 44
Port_1865196_1 | SOURCEANDSINK | K1 44
Port_1865218_2 | SOURCEANDSINK | K1 44
Port_1865206_1 | SOURCEANDSINK | K1 44
Port_1865207_1 | SOURCEANDSINK | K1 44
Port_1865207_0 | SOURCEANDSINK | K1 44
Port_1865212_0 | SOURCEANDSINK | K1 44
Port_1865218_1 | SOURCEANDSINK | K1 44
Port_1865212_1 | SOURCEANDSINK | K1 44
Port_1865275_0 | SOURCEANDSINK | K1 45
Port_1865275_1 | SOURCEANDSINK | K1 45
Port_1865289_1 | SOURCEANDSINK | K1 45
Port_1865283_0 | SOURCEANDSINK | K1 45
Port_1865289_2 | SOURCEANDSINK | K1 45
Port_1865283_1 | SOURCEANDSINK | K1 45
Port_1865306_0 | SOURCEANDSINK | K1 45
Port_1865314_1 | SOURCEANDSINK | K1 45
Port_1865306_1 | SOURCEANDSINK | K1 45
Port_1865314_2 | SOURCEANDSINK | K1 45
Port_1865566_0 | SOURCEANDSINK | K1 46
Port_1865566_1 | SOURCEANDSINK | K1 46
Port_1865580_1 | SOURCEANDSINK | K1 46
Port_1865574_0 | SOURCEANDSINK | K1 46
Port_1865580_2 | SOURCEANDSINK | K1 46
Port_1865574_1 | SOURCEANDSINK | K1 46
Port_1865590_1 | SOURCEANDSINK | K1 46
Port_1865584_0 | SOURCEANDSINK | K1 46
Port_1865590_2 | SOURCEANDSINK | K1 46
Port_1865584_1 | SOURCEANDSINK | K1 46
Port_1865626_0 | SOURCEANDSINK | K1 47
Port_1865626_1 | SOURCEANDSINK | K1 47
Port_1865640_1 | SOURCEANDSINK | K1 47
Port_1865634_0 | SOURCEANDSINK | K1 47
Port_1865640_2 | SOURCEANDSINK | K1 47
Port_1865634_1 | SOURCEANDSINK | K1 47
Port_1865650_1 | SOURCEANDSINK | K1 47
Port_1865644_0 | SOURCEANDSINK | K1 47
Port_1865650_2 | SOURCEANDSINK | K1 47
Port_1865644_1 | SOURCEANDSINK | K1 47
Port_1865660_2 | SOURCEANDSINK | K1 47
Port_1865660_1 | SOURCEANDSINK | K1 47
Port_1865749_0 | SOURCEANDSINK | K1 48
Port_1865749_1 | SOURCEANDSINK | K1 48
Port_1865763_1 | SOURCEANDSINK | K1 48
Port_1865757_0 | SOURCEANDSINK | K1 48
Port_1865763_2 | SOURCEANDSINK | K1 48
Port_1865757_1 | SOURCEANDSINK | K1 48
Port_1865773_1 | SOURCEANDSINK | K1 48
Port_1865767_0 | SOURCEANDSINK | K1 48
Port_1865773_2 | SOURCEANDSINK | K1 48
Port_1865767_1 | SOURCEANDSINK | K1 48
Port_1865790_0 | SOURCEANDSINK | K1 49
Port_1865790_1 | SOURCEANDSINK | K1 49
Port_1865829_0 | SOURCEANDSINK | K1 50
Port_1865829_1 | SOURCEANDSINK | K1 50
Port_1865856_0 | SOURCEANDSINK | K1 51
Port_1865856_1 | SOURCEANDSINK | K1 51
Port_1865903_0 | SOURCEANDSINK | K1 52
Port_1865903_1 | SOURCEANDSINK | K1 52
Port_1865941_0 | SOURCEANDSINK | K1 53
Port_1865941_1 | SOURCEANDSINK | K1 53
Port_1867264_1 | SOURCEANDSINK | K1 53
Port_1867251_0 | SOURCEANDSINK | K1 53
Port_1867264_2 | SOURCEANDSINK | K1 53
Port_1867251_1 | SOURCEANDSINK | K1 53
Port_1867328_0 | SOURCEANDSINK | K1 54
Port_1867615_2 | SOURCEANDSINK | K1 54
Port_1867328_1 | SOURCEANDSINK | K1 54
Port_1867332_1 | SOURCEANDSINK | K1 54
Port_1867330_0 | SOURCEANDSINK | K1 54
Port_1867332_2 | SOURCEANDSINK | K1 54
Port_1867330_1 | SOURCEANDSINK | K1 54
Port_1867402_0 | SOURCEANDSINK | K1 55
Port_1867402_1 | SOURCEANDSINK | K1 55
Port_1867416_2 | SOURCEANDSINK | K1 55
Port_1867410_0 | SOURCEANDSINK | K1 55
Port_1867416_1 | SOURCEANDSINK | K1 55
Port_1867410_1 | SOURCEANDSINK | K1 55
Port_1867478_0 | SOURCEANDSINK | K1 56
Port_1867478_1 | SOURCEANDSINK | K1 56
Port_1867492_1 | SOURCEANDSINK | K1 56
Port_1867486_0 | SOURCEANDSINK | K1 56
Port_1867492_2 | SOURCEANDSINK | K1 56
Port_1867486_1 | SOURCEANDSINK | K1 56
Port_1867609_0 | SOURCEANDSINK | K1 54
Port_1867622_2 | SOURCEANDSINK | K1 54
Port_1867609_1 | SOURCEANDSINK | K1 54
Port_1867615_1 | SOURCEANDSINK | K1 54
Port_1867616_1 | SOURCEANDSINK | K1 54
Port_1867615_3 | SOURCEANDSINK | K1 54
Port_1867622_1 | SOURCEANDSINK | K1 54
Port_1867616_0 | SOURCEANDSINK | K1 54
Port_1867638_0 | SOURCEANDSINK | K1 57
Port_1867677_2 | SOURCEANDSINK | K1 57
Port_1867638_1 | SOURCEANDSINK | K1 57
Port_1867663_0 | SOURCEANDSINK | K1 57
Port_1867689_2 | SOURCEANDSINK | K1 57
Port_1867663_1 | SOURCEANDSINK | K1 57
Port_1867673_0 | SOURCEANDSINK | K1 57
Port_1867677_3 | SOURCEANDSINK | K1 57
Port_1867673_1 | SOURCEANDSINK | K1 57
Port_1867684_1 | SOURCEANDSINK | K1 57
Port_1867674_0 | SOURCEANDSINK | K1 57
Port_1867684_2 | SOURCEANDSINK | K1 57
Port_1867674_1 | SOURCEANDSINK | K1 57
Port_1867689_1 | SOURCEANDSINK | K1 57
Port_1867677_1 | SOURCEANDSINK | K1 57
Port_1867678_1 | SOURCEANDSINK | K1 57
Port_1867678_0 | SOURCEANDSINK | K1 57
Port_1867899_0 | SOURCEANDSINK | K1 59
Port_1868047_2 | SOURCEANDSINK | K1 59
Port_1867899_1 | SOURCEANDSINK | K1 59
Port_1868033_0 | SOURCEANDSINK | K1 59
Port_1868044_2 | SOURCEANDSINK | K1 59
Port_1868033_1 | SOURCEANDSINK | K1 59
Port_1868047_1 | SOURCEANDSINK | K1 59
Port_1868035_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1868036_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1868035_3 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1868044_1 | SOURCEANDSINK | Ūkio-buities nuotekos - F1 5
Port_1868121_0 | SOURCEANDSINK | K1 60
Port_1868121_1 | SOURCEANDSINK | K1 60
Port_1868135_2 | SOURCEANDSINK | K1 60
Port_1868129_0 | SOURCEANDSINK | K1 60
Port_1868135_1 | SOURCEANDSINK | K1 60
Port_1868129_1 | SOURCEANDSINK | K1 60
Port_1868202_0 | SOURCEANDSINK | K1 58
Port_1868202_1 | SOURCEANDSINK | K1 58
Port_1868206_2 | SOURCEANDSINK | K1 58
Port_1868204_0 | SOURCEANDSINK | K1 58
Port_1868206_1 | SOURCEANDSINK | K1 58
Port_1868204_1 | SOURCEANDSINK | K1 58
Port_1868217_0 | SOURCEANDSINK | K1 61
Port_1868217_1 | SOURCEANDSINK | K1 61
Port_1868286_1 | SOURCEANDSINK | K1 61
Port_1868219_0 | SOURCEANDSINK | K1 61
Port_1868286_2 | SOURCEANDSINK | K1 61
Port_1868219_1 | SOURCEANDSINK | K1 61
Port_1868316_0 | SOURCEANDSINK | K1 62
Port_1868316_1 | SOURCEANDSINK | K1 62
Port_1868320_2 | SOURCEANDSINK | K1 62
Port_1868318_0 | SOURCEANDSINK | K1 62
Port_1868320_1 | SOURCEANDSINK | K1 62
Port_1868318_1 | SOURCEANDSINK | K1 62
Port_1868399_0 | SOURCEANDSINK | K1 63
Port_1868399_1 | SOURCEANDSINK | K1 63
Port_1868444_0 | SOURCEANDSINK | K1 64
Port_1868444_1 | SOURCEANDSINK | K1 64

# IfcFlowFitting: Geberit_PipeFitting_Mapress_StSt_Adapter_Union_Nut:Default DN, Geberit_PipeFitting_Mapress_StSt_Adapter_Union_Nut:Default DN:1832141
In: 0 a
Type - Description: Mapress St-Steel Adapter Union Nut; PredefinedType: CONNECTOR; Material: Geberit_Paint Finish,Blue, Geberit_Mapress_St-Steel
Type - Pset_ElementShading - Color: St Steel
Type - Pset_FlowFittingDuctFitting - Color: St Steel
Type - Pset_FlowFittingPipeFitting - Color: St Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit; ProductionYear: 2018
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: D2090800 Uniformat (Uniformat); Group: V2 5
Pset_DistributionFlowElementCommon - Reference: Default DN; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.
Pset_ManufacturerTypeInformation - ArticleNumber: 35039; ModelReference: Coupler/Adapter

# IfcFlowFitting: Geberit_PipeFitting_Mapress_StSt_Adapter_Union_Nut:Default DN (9)
Type - Description: Mapress St-Steel Adapter Union Nut; PredefinedType: CONNECTOR; Material: Geberit_Paint Finish,Blue, Geberit_Mapress_St-Steel, Aluminum, Anodized Red
Type - Pset_ElementShading - Color: St Steel
Type - Pset_FlowFittingDuctFitting - Color: St Steel
Type - Pset_FlowFittingPipeFitting - Color: St Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit; ProductionYear: 2018
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: D2090800 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Default DN; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.
Pset_ManufacturerTypeInformation - ArticleNumber: 0; ModelReference: Coupler/Adapter
Name (Geberit_PipeFitting_Mapress_StSt_Adapter_Union_Nut:Default DN:...) | In | Group
1832170 | 0 a | V2 5
1834368 | 0 a | V2 2
1835829 | 1 a +-152.84 | V2 7
1836118 | 1 a +-152.84 | V2 7
1836754 | 1 a +-152.84 | V2 7
1838358 | 2 a | V2 7
1838672 | 2 a | V2 7
1841631 | 2 a | V2 44
1845482 | 2 a | V2 23

# IfcFlowFitting: Geberit_PipeFitting_Mapress_StSt_Bend:Default DN (306)
Type - Description: Mapress St-Steel Bend; PredefinedType: BEND; Material: Geberit_Paint Finish,Blue, Geberit_Mapress_St-Steel
Type - Pset_ElementShading - Color: St Steel
Type - Pset_FlowFittingDuctFitting - Color: St Steel
Type - Pset_FlowFittingPipeFitting - Color: St Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit; ProductionYear: 2018
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: D2090800 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Default DN; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.
Pset_ManufacturerTypeInformation - ModelReference: Bend
Name (Geberit_PipeFitting_Mapress_StSt_Bend:Default DN:...) | In | ArticleNumber | Group
1830319 | 0 a | 31111 | V2 7
1830330 | 0 a | 31111 | V2 7
1830455 | 0 a | 31111 | V2 7
1830492 | 0 a | 31111 | V2 7
1830539 | 0 a | 31111 | V2 7
1830551 | 0 a | 31111 | V2 7
1830655 | 1 a +-152.84 | 31111 | V2 7
1830718 | 1 a +-152.84 | 31111 | V2 7
1830755 | 0 a | 31111 | V2 7
1830884 | 0 a | 31111 | V2 7
1830888 | 0 a | 31111 | V2 7
1830914 | 0 a | 31111 | V2 7
1830980 | 0 a | 31109 | V2 3
1831478 | 0 a | 31111 | V2 7
1831527 | 0 a | 31110 | V2 5
1831557 | 0 a | 31110 | V2 5
1831598 | 0 a | 31110 | V2 5
1831627 | 0 a | 31110 | V2 5
1831720 | 0 a | 31109 | V2 4
1831724 | 0 a | 31109 | V2 4
1832051 | 0 a | 31109 | V2 5
1832103 | 0 a | 31109 | V2 5
1832105 | 0 a | 31109 | V2 5
1832139 | 0 a | 31109 | V2 5
1832168 | 0 a | 31109 | V2 5
1832763 | 1 a +-152.84 | 31111 | V2 7
1832765 | 1 a +-152.84 | 31111 | V2 7
1832796 | 1 a +-152.84 | 31111 | V2 7
1832804 | 1 a +-152.84 | 31111 | V2 7
1832814 | 1 a +-152.84 | 31111 | V2 7
1832822 | 1 a +-152.84 | 31111 | V2 7
1832871 | 1 a +-152.84 | 31111 | V2 7
1833178 | 1 a +-152.84 | 31110 | V2 2
1833292 | 1 a +-152.84 | 31110 | V2 2
1833332 | 0 a | 31110 | V2 2
1833348 | 0 a | 31110 | V2 2
1833356 | 0 a | 31110 | V2 2
1833368 | 0 a | 31110 | V2 2
1833376 | 0 a | 31110 | V2 2
1833386 | 0 a | 31110 | V2 2
1833441 | 0 a | 31110 | V2 2
1833482 | 1 a +-152.84 | 31110 | V2 2
1833631 | 0 a | 31109 | V2 8
1833639 | 0 a | 31109 | V2 8
1833681 | 0 a | 31109 | V2 8
1833716 | 0 a | 31109 | V2 8
1833756 | 0 a | 31109 | V2 8
1833772 | 0 a | 31109 | V2 8
1833786 | 0 a | 31109 | V2 8
1833796 | 0 a | 31109 | V2 8
1833869 | 0 a | 31109 | V2 9
1833911 | 0 a | 31109 | V2 9
1833913 | 0 a | 31109 | V2 9
1834050 | 0 a | 31109 | V2 10
1834054 | 0 a | 31109 | V2 10
1834313 | 0 a | 31109 | V2 11
1834317 | 0 a | 31109 | V2 11
1834377 | 0 a | 31109 | V2 2
1834448 | 0 a | 31109 | V2 2
1834452 | 0 a | 31109 | V2 2
1834816 | 0 a | 31110 | V2 2
1835170 | 1 a +-152.84 | 31109 | V2 12
1835213 | 1 a +-152.84 | 31109 | V2 12
1835217 | 1 a +-152.84 | 31109 | V2 12
1835580 | 1 a +-152.84 | 31109 | V2 12
1835584 | 1 a +-152.84 | 31109 | V2 12
1835658 | 1 a +-152.84 | 31109 | V2 13
1835724 | 1 a +-152.84 | 31109 | V2 13
1835768 | 1 a +-152.84 | 31109 | V2 13
1835772 | 1 a +-152.84 | 31109 | V2 13
1835872 | 1 a +-152.84 | 31109 | V2 7
1835874 | 1 a +-152.84 | 31109 | V2 7
1836127 | 1 a +-152.84 | 31109 | V2 7
1836137 | 1 a +-152.84 | 31109 | V2 7
1836207 | 1 a +-152.84 | 31109 | V2 7
1836211 | 1 a +-152.84 | 31109 | V2 7
1836245 | 1 a +-152.84 | 31109 | V2 7
1836255 | 1 a +-152.84 | 31109 | V2 7
1836263 | 1 a +-152.84 | 31109 | V2 7
1836273 | 1 a +-152.84 | 31109 | V2 7
1836281 | 1 a +-152.84 | 31109 | V2 7
1836339 | 1 a +-152.84 | 31109 | V2 7
1836341 | 1 a +-152.84 | 31109 | V2 7
1836501 | 1 a +-152.84 | 31109 | V2 14
1836503 | 1 a +-152.84 | 31109 | V2 14
1836609 | 1 a +-152.84 | 31109 | V2 15
1836613 | 1 a +-152.84 | 31109 | V2 15
1836674 | 1 a +-152.84 | 31109 | V2 16
1836676 | 1 a +-152.84 | 31109 | V2 16
1836809 | 1 a +-152.84 | 31109 | V2 7
1836813 | 1 a +-152.84 | 31109 | V2 7
1836975 | 1 a +-152.84 | 31109 | V2 7
1836985 | 1 a +-152.84 | 31109 | V2 7
1837028 | 1 a +-152.84 | 31109 | V2 7
1837030 | 1 a +-152.84 | 31109 | V2 7
1837094 | 1 a +-152.84 | 31109 | V2 7
1837106 | 1 a +-152.84 | 31109 | V2 7
1837231 | 1 a +-152.84 | 31109 | V2 7
1837269 | 1 a +-152.84 | 31109 | V2 7
1837374 | 1 a +-152.84 | 31109 | V2 18
1837378 | 1 a +-152.84 | 31109 | V2 18
1837531 | 2 a | 31109 | V2 21
1837543 | 2 a | 31109 | V2 53
1837594 | 2 a | 31109 | V2 53
1837782 | 2 a | 31109 | V2 22
1837786 | 2 a | 31109 | V2 22
1837836 | 2 a | 31109 | V2 25
1837879 | 2 a | 31109 | V2 28
1838039 | 2 a | 31109 | V2 7
1838043 | 2 a | 31109 | V2 7
1838157 | 2 a | 31109 | V2 7
1838194 | 2 a | 31109 | V2 7
1838196 | 2 a | 31109 | V2 7
1838289 | 2 a | 31109 | V2 29
1838293 | 2 a | 31109 | V2 29
1838400 | 2 a | 31109 | V2 7
1838404 | 2 a | 31109 | V2 7
1838497 | 2 a | 31109 | V2 30
1838501 | 2 a | 31109 | V2 30
1838713 | 2 a | 31109 | V2 7
1838717 | 2 a | 31109 | V2 7
1838816 | 2 a | 31109 | V2 31
1838818 | 2 a | 31109 | V2 31
1838962 | 2 a | 31109 | V2 32
1838964 | 2 a | 31109 | V2 32
1839079 | 2 a | 31109 | V2 33
1839109 | 2 a | 31109 | V2 33
1839113 | 2 a | 31109 | V2 33
1839212 | 2 a | 31111 | V2 7
1839247 | 2 a | 31111 | V2 7
1839507 | 2 a | 31111 | V2 7
1839515 | 2 a | 31111 | V2 7
1839525 | 2 a | 31111 | V2 7
1839574 | 2 a | 31110 | V2 35
1839584 | 2 a | 31110 | V2 35
1839628 | 2 a | 31109 | V2 36
1839702 | 2 a | 31109 | V2 37
1839712 | 2 a | 31109 | V2 37
1839806 | 2 a | 31109 | V2 36
1839890 | 2 a | 31109 | V2 36
1839915 | 2 a | 31109 | V2 36
1839946 | 2 a | 31109 | V2 38
1839952 | 2 a | 31109 | V2 38
1839954 | 2 a | 31109 | V2 38
1839972 | 2 a | 31109 | V2 39
1839978 | 2 a | 31109 | V2 39
1839980 | 2 a | 31109 | V2 39
1840012 | 2 a | 31109 | V2 37
1840045 | 2 a | 31109 | V2 37
1840143 | 2 a | 31109 | V2 40
1840147 | 2 a | 31109 | V2 40
1840247 | 2 a | 31109 | V2 41
1840251 | 2 a | 31109 | V2 41
1840368 | 2 a | 31111 | V2 7
1840561 | 2 a | 31109 | V2 42
1840569 | 2 a | 31109 | V2 42
1840615 | 2 a | 31109 | V2 42
1840619 | 2 a | 31109 | V2 42
1840720 | 2 a | 31109 | V2 42
1840724 | 2 a | 31109 | V2 42
1840809 | 2 a | 31109 | V2 42
1841085 | 2 a | 31109 | V2 43
1841095 | 2 a | 31109 | V2 43
1841125 | 2 a | 31109 | V2 43
1841129 | 2 a | 31109 | V2 43
1841240 | 2 a | 31109 | V2 43
1841244 | 2 a | 31109 | V2 43
1841393 | 3 a | 31109 | V2 45
1841403 | 3 a | 31109 | V2 45
1841456 | 3 a | 31109 | V2 45
1841508 | 3 a | 31109 | V2 45
1841512 | 3 a | 31109 | V2 45
1841764 | 3 a | 31109 | V2 44
1841846 | 3 a | 31109 | V2 44
1841850 | 3 a | 31109 | V2 44
1841912 | 3 a | 31109 | V2 44
1841954 | 3 a | 31109 | V2 44
1841958 | 3 a | 31109 | V2 44
1842033 | 3 a | 31109 | V2 44
1842037 | 3 a | 31109 | V2 44
1842277 | 1 a +-152.84 | 31109 | V2 47
1842292 | 3 a | 31109 | V2 47
1842302 | 3 a | 31109 | V2 47
1842525 | 3 a | 31109 | V2 47
1842588 | 3 a | 31109 | V2 47
1842649 | 3 a | 31109 | V2 47
1842653 | 3 a | 31109 | V2 47
1842703 | 3 a | 31109 | V2 47
1842713 | 3 a | 31109 | V2 47
1842721 | 3 a | 31109 | V2 47
1842731 | 3 a | 31109 | V2 47
1842956 | 3 a | 31109 | V2 47
1842994 | 3 a | 31109 | V2 47
1843121 | 2 a | 31111 | V2 7
1843159 | 2 a | 31111 | V2 7
1843344 | 3 a | 31111 | V2 7
1844336 | 3 a | 31109 | V2 46
1844346 | 3 a | 31109 | V2 46
1844598 | 3 a | 31109 | V2 46
1844602 | 3 a | 31109 | V2 46
1844637 | 3 a | 31109 | V2 46
1844647 | 3 a | 31109 | V2 46
1844713 | 3 a | 31109 | V2 46
1844717 | 3 a | 31109 | V2 46
1844762 | 3 a | 31109 | V2 46
1844772 | 3 a | 31109 | V2 46
1844782 | 3 a | 31109 | V2 46
1844792 | 3 a | 31109 | V2 46
1844800 | 3 a | 31109 | V2 46
1844810 | 3 a | 31109 | V2 46
1844818 | 3 a | 31109 | V2 46
1844856 | 3 a | 31109 | V2 46
1844860 | 3 a | 31109 | V2 46
1845163 | 3 a | 31109 | V2 34
1845202 | 3 a | 31109 | V2 34
1845206 | 3 a | 31109 | V2 34
1845269 | 3 a | 31109 | V2 34
1845350 | 3 a | 31109 | V2 34
1845354 | 3 a | 31109 | V2 34
1845633 | 4 a V1 | 31109 | V2 23
1845637 | 4 a V1 | 31109 | V2 23
1845711 | 4 a V1 | 31109 | V2 23
1845758 | 4 a V1 | 31109 | V2 23
1845762 | 4 a V1 | 31109 | V2 23
1845810 | 4 a V1 | 31109 | V2 23
1845843 | 4 a V1 | 31109 | V2 23
1845847 | 4 a V1 | 31109 | V2 23
1845968 | 2 a | 31111 | V2 48
1845976 | 4 a V1 | 31111 | V2 48
1846400 | 1 a +-152.84 | 31111 | V2 7
1846570 | 4 a V1 | 31111 | V2 48
1846686 | 1 a +-152.84 | 31111 | V2 7
1846802 | 1 a +-152.84 | 31109 | V2 49
1846810 | 4 a V1 | 31109 | V2 49
1846822 | 4 a V1 | 31109 | V2 49
1846832 | 4 a V1 | 31109 | V2 49
1846842 | 4 a V1 | 31109 | V2 49
1846908 | 4 a V1 | 31109 | V2 49
1846912 | 4 a V1 | 31109 | V2 49
1846949 | 4 a V1 | 31109 | V2 49
1846979 | 4 a V1 | 31109 | V2 49
1846983 | 4 a V1 | 31109 | V2 49
1847025 | 4 a V1 | 31109 | V2 49
1847033 | 4 a V1 | 31109 | V2 49
1847045 | 4 a V1 | 31109 | V2 49
1847053 | 4 a V1 | 31109 | V2 49
1847063 | 4 a V1 | 31109 | V2 49
1847136 | 4 a V1 | 31109 | V2 49
1847140 | 4 a V1 | 31109 | V2 49
1847257 | 4 a V1 | 31109 | V2 23
1847269 | 4 a V1 | 31109 | V2 23
1847277 | 4 a V1 | 31109 | V2 23
1847295 | 4 a V1 | 31109 | V2 23
1847331 | 4 a V1 | 31109 | V2 23
1847335 | 4 a V1 | 31109 | V2 23
1847938 | 3 a | 31111 | V2 7
1847942 | 3 a | 31111 | V2 7
1848495 | 2 a | 31111 | V2 7
1848499 | 4 a V1 | 31111 | V2 7
1848744 | 4 a V1 | 31109 | V2 50
1848754 | 4 a V1 | 31109 | V2 50
1848772 | 4 a V1 | 31109 | V2 50
1848780 | 4 a V1 | 31109 | V2 50
1848803 | 4 a V1 | 31109 | V2 50
1848813 | 4 a V1 | 31109 | V2 50
1848848 | 4 a V1 | 31109 | V2 50
1848852 | 4 a V1 | 31109 | V2 50
1848922 | 4 a V1 | 31109 | V2 50
1848930 | 4 a V1 | 31109 | V2 50
1848959 | 4 a V1 | 31109 | V2 50
1848963 | 4 a V1 | 31109 | V2 50
1849038 | 4 a V1 | 31109 | V2 50
1849048 | 4 a V1 | 31109 | V2 50
1849081 | 4 a V1 | 31109 | V2 50
1849085 | 4 a V1 | 31109 | V2 50
1849399 | 4 a V1 | 31109 | V2 51
1849419 | 4 a V1 | 31109 | V2 51
1849427 | 4 a V1 | 31109 | V2 51
1849437 | 4 a V1 | 31109 | V2 51
1849445 | 4 a V1 | 31109 | V2 51
1849484 | 4 a V1 | 31109 | V2 51
1849488 | 4 a V1 | 31109 | V2 51
1849627 | 4 a V1 | 31109 | V2 51
1849637 | 4 a V1 | 31109 | V2 51
1849682 | 4 a V1 | 31109 | V2 51
1849686 | 4 a V1 | 31109 | V2 51
1849776 | 5 a V1 | 31109 | V2 23
1849801 | 5 a V1 | 31109 | V2 23
1849805 | 5 a V1 | 31109 | V2 23
1849910 | 5 a V1 | 31109 | V2 23
1849936 | 5 a V1 | 31109 | V2 23
1849940 | 5 a V1 | 31109 | V2 23
1850022 | 5 a V1 | 31109 | V2 23
1850058 | 5 a V1 | 31109 | V2 23
1850062 | 5 a V1 | 31109 | V2 23
1850129 | 5 a V1 | 31109 | V2 23
1850141 | 5 a V1 | 31109 | V2 23
1850188 | 5 a V1 | 31109 | V2 23
1850192 | 5 a V1 | 31109 | V2 23
1850260 | 5 a V1 | 31109 | V2 50
1850289 | 5 a V1 | 31109 | V2 50
1850293 | 5 a V1 | 31109 | V2 50
1850376 | 5 a V1 | 31109 | V2 50
1850420 | 5 a V1 | 31109 | V2 50
1850424 | 5 a V1 | 31109 | V2 50
1850550 | 5 a V1 | 31109 | V2 50

# IfcFlowFitting: Geberit_PipeFitting_Mapress_StSt_TPieceEqual:Default DN (84)
Type - Description: Mapress St-Steel T-piece Equal; PredefinedType: JUNCTION; Material: Geberit_Paint Finish,Blue, Geberit_Mapress_St-Steel
Type - Pset_ElementShading - Color: St Steel
Type - Pset_FlowFittingDuctFitting - Color: St Steel
Type - Pset_FlowFittingPipeFitting - Color: St Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit; ProductionYear: 2018
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: D2090800 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Default DN; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.
Pset_ManufacturerTypeInformation - ModelReference: T-piece Equal
Name (Geberit_PipeFitting_Mapress_StSt_TPieceEqual:Default DN:...) | In | ArticleNumber | Group
1830877 | 0 a | 31011 | V2 7
1830910 | 0 a | 31011 | V2 7
1830920 | 0 a | 31011 | V2 7
1830954 | 0 a | 31011 | V2 7
1831510 | 0 a | 31011 | V2 7
1831777 | 0 a | 31010 | V2 5
1831882 | 0 a | 31010 | V2 5
1832784 | 1 a +-152.84 | 31011 | V2 7
1833484 | 1 a +-152.84 | 31011 | V2 7
1833585 | 0 a | 31010 | V2 2
1833850 | 0 a | 31010 | V2 2
1833971 | 0 a | 31010 | V2 2
1834196 | 0 a | 31010 | V2 2
1834360 | 0 a | 31010 | V2 2
1834615 | 0 a | 31011 | V2 7
1835148 | 1 a +-152.84 | 31011 | V2 7
1835499 | 1 a +-152.84 | 31009 | V2 12
1835639 | 1 a +-152.84 | 31011 | V2 7
1835821 | 1 a +-152.84 | 31011 | V2 7
1836110 | 1 a +-152.84 | 31011 | V2 7
1836235 | 1 a +-152.84 | 31009 | V2 7
1836438 | 1 a +-152.84 | 31011 | V2 7
1836533 | 1 a +-152.84 | 31011 | V2 7
1836668 | 1 a +-152.84 | 31011 | V2 17
1836746 | 1 a +-152.84 | 31011 | V2 7
1836948 | 1 a +-152.84 | 31009 | V2 7
1837084 | 1 a +-152.84 | 31009 | V2 7
1837326 | 1 a +-152.84 | 31011 | V2 7
1837503 | 2 a | 31011 | V2 7
1837738 | 2 a | 31011 | V2 7
1837830 | 2 a | 31011 | V2 24
1837873 | 2 a | 31011 | V2 27
1837961 | 2 a | 31009 | V2 7
1838145 | 2 a | 31009 | V2 7
1838245 | 2 a | 31010 | V2 2
1838350 | 2 a | 31011 | V2 7
1838449 | 2 a | 31011 | V2 7
1838664 | 2 a | 31011 | V2 7
1838764 | 2 a | 31011 | V2 7
1838916 | 2 a | 31011 | V2 7
1839057 | 2 a | 31010 | V2 2
1839202 | 2 a | 31011 | V2 7
1839350 | 2 a | 31011 | V2 7
1839681 | 2 a | 31010 | V2 35
1840049 | 2 a | 31009 | V2 37
1840096 | 2 a | 31011 | V2 7
1840198 | 2 a | 31011 | V2 7
1840314 | 2 a | 31011 | V2 7
1840467 | 2 a | 31011 | V2 7
1840676 | 2 a | 31009 | V2 42
1840824 | 2 a | 31011 | V2 7
1840949 | 2 a | 31011 | V2 23
1841206 | 2 a | 31009 | V2 43
1841302 | 2 a | 31011 | V2 23
1841595 | 2 a | 31010 | V2 44
1841883 | 3 a | 31009 | V2 44
1841988 | 3 a | 31009 | V2 44
1842233 | 1 a +-152.84 | 31011 | V2 7
1842568 | 3 a | 31009 | V2 47
1842676 | 3 a | 31009 | V2 47
1844249 | 3 a | 31011 | V2 7
1844627 | 3 a | 31009 | V2 46
1844741 | 3 a | 31009 | V2 46
1845091 | 2 a | 31011 | V2 7
1845286 | 3 a | 31009 | V2 34
1845474 | 2 a | 31011 | V2 23
1845672 | 4 a V1 | 31009 | V2 23
1845781 | 4 a V1 | 31009 | V2 23
1846749 | 1 a +-152.84 | 31011 | V2 7
1846939 | 4 a V1 | 31009 | V2 49
1847013 | 4 a V1 | 31009 | V2 49
1847230 | 2 a | 31009 | V2 23
1848531 | 3 a | 31011 | V2 7
1848902 | 4 a V1 | 31009 | V2 50
1849011 | 4 a V1 | 31009 | V2 50
1849206 | 2 a | 31011 | V2 7
1849600 | 4 a V1 | 31009 | V2 51
1849764 | 5 a V1 | 31009 | V2 23
1849883 | 4 a V1 | 31009 | V2 23
1849985 | 4 a V1 | 31009 | V2 23
1850102 | 5 a V1 | 31009 | V2 23
1850231 | 4 a V1 | 31009 | V2 50
1850347 | 4 a V1 | 31009 | V2 50
1850515 | 5 a V1 | 31009 | V2 50

# IfcFlowFitting: M_Elbow - Welded - Generic:Standard (97)
Type - Material: <Unnamed>
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Elbow - Welded - Generic:Standard:...) | In | NominalDiameter | Group
1115749 | 0 a | 200 | vanduo šaltas - V1 1
1115777 | 0 a | 200 | vanduo šaltas - V1 1
1115808 | 0 a | 200 | vanduo šaltas - V1 1
1115816 | 0 a | 200 | vanduo šaltas - V1 1
1425655 | 0 a | 150 | vanduo šaltas - V1 1
1425657 | 0 a | 150 | vanduo šaltas - V1 1
1857092 | 5 a V1 | 25 | K1 3
1857132 | 5 a V1 | 25 | K1 3
1857137 | 5 a V1 | 25 | K1 3
1857147 | 5 a V1 | 25 | K1 3
1857186 | 5 a V1 | 25 | K1 3
1857228 | 5 a V1 | 25 | K1 3
1858680 | 4 a V1 | 100 | F1 n.p. 1
1858723 | 4 a V1 | 100 | F1 n.p. 1
1858807 | 4 a V1 | 100 | F1 n.p. 1
1858964 | 4 a V1 | 100 | F1 n.p. 2
1858985 | 4 a V1 | 100 | F1 n.p. 2
1858995 | 4 a V1 | 100 | F1 n.p. 2
1859003 | 4 a V1 | 100 | F1 n.p. 2
1859379 | 4 a V1 | 100 | F1 n.p. 2
1859389 | 4 a V1 | 100 | F1 n.p. 2
1859399 | 4 a V1 | 100 | F1 n.p. 2
1859563 | 0 a | 100 | F1 n.p. 2
1859570 | 0 a | 100 | F1 n.p. 2
1859669 | 4 a V1 | 100 | F1 n.p. 1
1859673 | 0 a | 100 | F1 n.p. 1
1859974 | 0 a | 100 | F1 n.p. 2
1860044 | 4 a V1 | 100 | F1 n.p. 2
1860152 | 4 a V1 | 100 | F1 n.p. 2
1860160 | 4 a V1 | 100 | F1 n.p. 2
1860225 | 4 a V1 | 100 | F1 n.p. 2
1860235 | 0 a | 100 | F1 n.p. 2
1860264 | 0 a | 100 | F1 n.p. 2
1860269 | 0 a | 100 | F1 n.p. 2
1860277 | 0 a | 100 | F1 n.p. 2
1860335 | 0 a | 25 | K1 5
1860389 | 0 a | 25 | K1 6
1860405 | 0 a | 25 | K1 7
1860425 | 0 a | 25 | K1 8
1860445 | 0 a | 25 | K1 9
1860463 | 0 a | 25 | K1 10
1860483 | 0 a | 25 | K1 11
1860814 | 4 a V1 | 25 | K1 12
1860825 | 4 a V1 | 25 | K1 12
1861313 | 4 a V1 | 100 | F1 n.p. 1
1861323 | 3 a | 100 | F1 n.p. 1
1861913 | 3 a | 100 | F1 n.p. 2
1862078 | 3 a | 100 | F1 n.p. 3
1862269 | 0 a | 100 | F1 n.p. 3
1862273 | 3 a | 100 | F1 n.p. 3
1862389 | 3 a | 100 | F1 n.p. 3
1862399 | 3 a | 100 | F1 n.p. 3
1862677 | 3 a | 25 | K1 33
1862690 | 3 a | 25 | K1 33
1862748 | 3 a | 25 | K1 34
1862791 | 3 a | 25 | K1 33
1862885 | 3 a | 25 | K1 35
1862974 | 3 a | 25 | K1 36
1863018 | 3 a | 25 | K1 37
1863028 | 3 a | 25 | K1 37
1863054 | 3 a | 25 | K1 37
1863533 | 4 a V1 | 100 | F1 n.p. 2
1863887 | 4 a V1 | 100 | F1 n.p. 2
1863995 | 2 a | 100 | F1 n.p. 2
1864005 | 2 a | 100 | F1 n.p. 2
1864043 | 2 a | 100 | F1 n.p. 2
1864048 | 2 a | 100 | F1 n.p. 2
1864105 | 2 a | 100 | F1 n.p. 2
1864339 | 2 a | 100 | F1 n.p. 1
1864349 | 2 a | 100 | F1 n.p. 1
1864359 | 2 a | 100 | F1 n.p. 1
1864510 | 2 a | 25 | K1 38
1864585 | 2 a | 25 | K1 38
1864637 | 2 a | 25 | K1 39
1864647 | 2 a | 25 | K1 39
1864875 | 2 a | 25 | K1 41
1865218 | 2 a | 25 | K1 44
1865289 | 2 a | 25 | K1 45
1865314 | 2 a | 25 | K1 45
1865580 | 2 a | 25 | K1 46
1865590 | 2 a | 25 | K1 46
1865640 | 2 a | 25 | K1 47
1865650 | 2 a | 25 | K1 47
1865660 | 2 a | 25 | K1 47
1865763 | 2 a | 25 | K1 48
1865773 | 2 a | 25 | K1 48
1867264 | 2 a | 25 | K1 53
1867332 | 2 a | 25 | K1 54
1867416 | 1 a +-152.84 | 25 | K1 55
1867492 | 1 a +-152.84 | 25 | K1 56
1867684 | 1 a +-152.84 | 25 | K1 57
1867689 | 1 a +-152.84 | 25 | K1 57
1868047 | 1 a +-152.84 | 25 | K1 59
1868135 | 1 a +-152.84 | 25 | K1 60
1868206 | 1 a +-152.84 | 25 | K1 58
1868286 | 1 a +-152.84 | 25 | K1 61
1868320 | 1 a +-152.84 | 25 | K1 62

# IfcFlowFitting: M_Tee - Welded - Generic:Standard (23)
Type - Material: <Unnamed>
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Tee - Welded - Generic:Standard:...) | In | NominalDiameter | Group
1117424 | 0 a | 200 | vanduo šaltas - V1 1
1117449 | 0 a | 200 | vanduo šaltas - V1 1
1117576 | 0 a | 200 | vanduo šaltas - V1 1
1117769 | 0 a | 200 | vanduo šaltas - V1 1
1857127 | 5 a V1 | 25 | K1 3
1857173 | 5 a V1 | 25 | K1 3
1857216 | 5 a V1 | 25 | K1 3
1860259 | 0 a | 100 | F1 n.p. 2
1861286 | 4 a V1 | 100 | F1 n.p. 1
1861876 | 4 a V1 | 100 | F1 n.p. 2
1862362 | 3 a | 100 | F1 n.p. 3
1863574 | 4 a V1 | 100 | F1 n.p. 2
1863976 | 2 a | 100 | F1 n.p. 2
1864037 | 2 a | 100 | F1 n.p. 2
1864092 | 2 a | 100 | F1 n.p. 2
1864178 | 4 a V1 | 100 | F1 n.p. 1
1865035 | 2 a | 25 | K1 42
1865089 | 2 a | 25 | K1 42
1865117 | 2 a | 25 | K1 42
1865206 | 2 a | 25 | K1 44
1867615 | 1 a +-152.84 | 25 | K1 54
1867677 | 1 a +-152.84 | 25 | K1 57
1868035 | 1 a +-152.84 | 75 | Ūkio-buities nuotekos - F1 5

# IfcFlowFitting: M_Transition - Welded - Generic:Standard (7)
Type - Material: <Unnamed>
Type - Pset_DuctConnection - ConnectionType: Generic
Type - Pset_PipeConnection - ConnectionType: Generic
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Transition - Welded - Generic:Standard:...) | In | Group
1117432 | 0 a | vanduo šaltas - V1 1
1117457 | 0 a | vanduo šaltas - V1 1
1117584 | 0 a | vanduo šaltas - V1 1
1117777 | 0 a | vanduo šaltas - V1 1
1857177 | 5 a V1 | K1 3
1867622 | 1 a +-152.84 | K1 54
1868044 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 5; K1 59

# IfcFlowFitting: PIF_AS+_MultiReducer _Wavin:socket end White (90)
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end White; sets with these values: 2
Name (PIF_AS+_MultiReducer _Wavin:socket end White:...) | In | Group
1112423 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1121332 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1128107 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1129681 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1130194 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1131320 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1139426 | 5 a V1 | K1 2
1139658 | 5 a V1 | K1 2
1143911 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144137 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1150799 | 5 a V1 | Lietaus nuotekos - L1 8
1151895 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152464 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152824 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1165577 | 4 a V1 | K1 2
1173295 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1177567 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1186151 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186667 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187132 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187264 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189480 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1192489 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192879 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1195176 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195324 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1198448 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200457 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1201161 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201260 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1203623 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1213641 | 3 a | Ūkio-buities nuotekos - F1 14
1217412 | 3 a | Ūkio-buities nuotekos - F1 13
1217628 | 3 a | Ūkio-buities nuotekos - F1 13
1223528 | 3 a | Ūkio-buities nuotekos - F1 12
1229356 | 3 a | K1 2
1231060 | 3 a | Ūkio-buities nuotekos - F1 1
1234353 | 3 a | Ūkio-buities nuotekos - F1 1
1236149 | 3 a | Ūkio-buities nuotekos - F1 1
1245702 | 2 a | Ūkio-buities nuotekos - F1 1
1245915 | 2 a | Ūkio-buities nuotekos - F1 1
1247331 | 2 a | Ūkio-buities nuotekos - F1 1
1251161 | 2 a | Ūkio-buities nuotekos - F1 12
1251535 | 2 a | Ūkio-buities nuotekos - F1 12
1252189 | 2 a | Ūkio-buities nuotekos - F1 12
1258022 | 2 a | Ūkio-buities nuotekos - F1 18
1266030 | 2 a | Ūkio-buities nuotekos - F1 71
1273458 | 2 a | Ūkio-buities nuotekos - F1 72
1283285 | 2 a | nuotekos ūkio-buities - F1 1
1283680 | 2 a | Ūkio-buities nuotekos - F1 75
1283860 | 2 a | Ūkio-buities nuotekos - F1 75
1287988 | 2 a | nuotekos ūkio-buities - F1 4
1288214 | 2 a | nuotekos ūkio-buities - F1 4
1292746 | 2 a | Ūkio-buities nuotekos - F1 16
1293186 | 2 a | Ūkio-buities nuotekos - F1 16
1296006 | 2 a | Ūkio-buities nuotekos - F1 16
1296368 | 2 a | Ūkio-buities nuotekos - F1 16
1296584 | 2 a | Ūkio-buities nuotekos - F1 16
1298150 | 2 a | Ūkio-buities nuotekos - F1 19
1298576 | 2 a | Ūkio-buities nuotekos - F1 19
1305606 | 0 a | Ūkio-buities nuotekos - F1 2
1307374 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 71
1308173 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1310154 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313482 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 87
1313583 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1313858 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 84
1317612 | 1 a +-152.84 | K1 2
1415798 | 0 a | nuotekos ūkio-buities - F1 1
1416882 | 0 a | nuotekos ūkio-buities - F1 4
1503669 | 0 a | nuotekos ūkio-buities - F1 4
1506137 | 0 a | Ūkio-buities nuotekos - F1 12
1856425 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1857771 | 5 a V1 | K1 4
1857773 | 5 a V1 | K1 4
1857775 | 5 a V1 | K1 4
1857777 | 5 a V1 | K1 4
1857779 | 5 a V1 | K1 4
1857781 | 5 a V1 | K1 4
1857783 | 5 a V1 | K1 4
1857785 | 5 a V1 | K1 4
1857787 | 5 a V1 | K1 4
1857789 | 5 a V1 | K1 4
1857791 | 5 a V1 | K1 4
1857793 | 5 a V1 | K1 1
1857795 | 5 a V1 | K1 1
1857797 | 5 a V1 | K1 1
1859557 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1859654 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1862263 | 2 a | Ūkio-buities nuotekos - F1 69

# IfcFlowFitting: PIF_AS+_MultiReducer _Wavin:socket end White (3)
In: 0 a
Type - Material: Aluminum, Anodized Red, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end White; sets with these values: 2
Name (PIF_AS+_MultiReducer _Wavin:socket end White:...) | Group
1414059 | Ūkio-buities nuotekos - F1 75
1415509 | nuotekos ūkio-buities - F1 1
1416802 | nuotekos ūkio-buities - F1 4

# IfcFlowFitting: PIF_AS+_Socket_Plug_Wavin:Pravala (85)
Type - Description: End Cap; PredefinedType: CONNECTOR; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pravala; sets with these values: 2
Name (PIF_AS+_Socket_Plug_Wavin:Pravala:...) | In | Group
1139848 | 5 a V1 | K1 2
1142922 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1143237 | 0 a | Lietaus nuotekos - L1 11
1144104 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144346 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145739 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1152423 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155288 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156533 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159059 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159673 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1166216 | 4 a V1 | K1 2
1167381 | 4 a V1 | K1 2
1167801 | 4 a V1 | K1 2
1169517 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171199 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1172521 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173462 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173881 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1177258 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178340 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1179883 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180767 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1183427 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1187885 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188187 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190605 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1198112 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200668 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201627 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202861 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203867 | 5 a V1 | Ūkio-buities nuotekos - F1 16
1204016 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1218318 | 3 a | Ūkio-buities nuotekos - F1 13
1225273 | 3 a | Ūkio-buities nuotekos - F1 8
1228120 | 3 a | Ūkio-buities nuotekos - F1 5
1228976 | 3 a | K1 2
1231644 | 3 a | Ūkio-buities nuotekos - F1 1
1232750 | 3 a | Ūkio-buities nuotekos - F1 1
1233848 | 3 a | Ūkio-buities nuotekos - F1 1
1237407 | 3 a | Ūkio-buities nuotekos - F1 2
1238771 | 3 a | Ūkio-buities nuotekos - F1 2
1239023 | 3 a | Ūkio-buities nuotekos - F1 2
1239732 | 3 a | Ūkio-buities nuotekos - F1 2
1241228 | 2 a | Ūkio-buities nuotekos - F1 2
1243023 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1243029 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1246164 | 2 a | Ūkio-buities nuotekos - F1 1
1247881 | 2 a | K1 2
1251018 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1251899 | 2 a | Ūkio-buities nuotekos - F1 12
1253406 | 2 a | Ūkio-buities nuotekos - F1 12
1254053 | 2 a | Ūkio-buities nuotekos - F1 17
1254247 | 2 a | Ūkio-buities nuotekos - F1 17
1255869 | 2 a | Ūkio-buities nuotekos - F1 17
1256026 | 2 a | Ūkio-buities nuotekos - F1 17
1256377 | 2 a | Ūkio-buities nuotekos - F1 17
1256785 | 2 a | Ūkio-buities nuotekos - F1 18
1260807 | 2 a | Ūkio-buities nuotekos - F1 13
1261916 | 2 a | Ūkio-buities nuotekos - F1 69
1261980 | 2 a | Ūkio-buities nuotekos - F1 69
1264283 | 2 a | Ūkio-buities nuotekos - F1 71
1264335 | 2 a | Ūkio-buities nuotekos - F1 71
1267538 | 2 a | Ūkio-buities nuotekos - F1 71
1269184 | 2 a | Ūkio-buities nuotekos - F1 72
1269736 | 2 a | Ūkio-buities nuotekos - F1 72
1271864 | 2 a | Ūkio-buities nuotekos - F1 72
1272032 | 2 a | Ūkio-buities nuotekos - F1 72
1275015 | 2 a | Ūkio-buities nuotekos - F1 72
1275104 | 2 a | Ūkio-buities nuotekos - F1 72
1277594 | 2 a | Ūkio-buities nuotekos - F1 75
1278026 | 2 a | Ūkio-buities nuotekos - F1 75
1282536 | 2 a | nuotekos ūkio-buities - F1 1
1283243 | 2 a | nuotekos ūkio-buities - F1 1
1283551 | 2 a | nuotekos ūkio-buities - F1 1
1283655 | 2 a | nuotekos ūkio-buities - F1 1
1286101 | 2 a | nuotekos ūkio-buities - F1 4
1295314 | 2 a | Ūkio-buities nuotekos - F1 16
1297737 | 2 a | Ūkio-buities nuotekos - F1 19
1305929 | 2 a | Ūkio-buities nuotekos - F1 71
1313384 | 2 a | Ūkio-buities nuotekos - F1 87
1316352 | 1 a +-152.84 | K1 2
1417778 | 0 a | Ūkio-buities nuotekos - F1 16
1856476 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1856486 | 5 a V1 | Ūkio-buities nuotekos - F1 10

# IfcFlowFitting: PIF_AS+_Super_Bend_Wavin:socket end (1994)
Type - Description: Pipe segment - double bend; PredefinedType: BEND; Material: PP, White, RAL 9100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 52.21 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: socket end; sets with these values: 2
Name (PIF_AS+_Super_Bend_Wavin:socket end:...) | In | Group
1104145 | 0 a | Lietaus nuotekos - L1 1
1104315 | 0 a | Lietaus nuotekos - L1 1
1104321 | 0 a | Lietaus nuotekos - L1 1
1104416 | 0 a | Lietaus nuotekos - L1 2
1104545 | 0 a | Lietaus nuotekos - L1 2
1104551 | 0 a | Lietaus nuotekos - L1 2
1104639 | 0 a | Lietaus nuotekos - L1 4
1104653 | 0 a | Lietaus nuotekos - L1 4
1104732 | 0 a | Lietaus nuotekos - L1 6
1104772 | 0 a | Lietaus nuotekos - L1 6
1104778 | 0 a | Lietaus nuotekos - L1 6
1104830 | 0 a | Lietaus nuotekos - L1 4
1104892 | 0 a | Lietaus nuotekos - L1 4
1104898 | 0 a | Lietaus nuotekos - L1 4
1104958 | 0 a | Lietaus nuotekos - L1 8
1105079 | 0 a | Lietaus nuotekos - L1 8
1105085 | 0 a | Lietaus nuotekos - L1 8
1106747 | 0 a | Lietaus nuotekos - L1 3
1106761 | 0 a | Lietaus nuotekos - L1 3
1106879 | 0 a | Lietaus nuotekos - L1 3
1107026 | 0 a | Lietaus nuotekos - L1 3
1107071 | 0 a | Lietaus nuotekos - L1 3
1107130 | 0 a | Lietaus nuotekos - L1 3
1107136 | 0 a | Lietaus nuotekos - L1 3
1107359 | 0 a | Lietaus nuotekos - L1 9
1107373 | 0 a | Lietaus nuotekos - L1 9
1107475 | 0 a | Lietaus nuotekos - L1 9
1107521 | 0 a | Lietaus nuotekos - L1 9
1107533 | 0 a | Lietaus nuotekos - L1 9
1107757 | 0 a | Lietaus nuotekos - L1 9
1107973 | 0 a | Lietaus nuotekos - L1 11
1108001 | 0 a | Lietaus nuotekos - L1 11
1108183 | 0 a | Lietaus nuotekos - L1 11
1108195 | 0 a | Lietaus nuotekos - L1 11
1108246 | 0 a | Lietaus nuotekos - L1 11
1108252 | 0 a | Lietaus nuotekos - L1 11
1108362 | 0 a | Lietaus nuotekos - L1 11
1108376 | 0 a | Lietaus nuotekos - L1 11
1109135 | 0 a | Lietaus nuotekos - L1 13
1109687 | 5 a V1 | Lietaus nuotekos - L1 13
1109723 | 0 a | Lietaus nuotekos - L1 13
1109735 | 0 a | Lietaus nuotekos - L1 13
1110880 | 2 a | Lietaus nuotekos - L1 20
1111146 | 0 a | Lietaus nuotekos - L1 20
1111158 | 0 a | Lietaus nuotekos - L1 20
1111252 | 2 a | Lietaus nuotekos - L1 20
1111306 | 2 a | Lietaus nuotekos - L1 20
1111338 | 2 a | Lietaus nuotekos - L1 20
1111375 | 2 a | Lietaus nuotekos - L1 5
1111444 | 2 a | Lietaus nuotekos - L1 5
1111456 | 0 a | Lietaus nuotekos - L1 5
1111612 | 2 a | Lietaus nuotekos - L1 5
1111644 | 2 a | Lietaus nuotekos - L1 5
1111676 | 2 a | Lietaus nuotekos - L1 5
1112233 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1112470 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1112565 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1112602 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1112933 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1118471 | 0 a | Lietaus nuotekos - L1 8
1118529 | 0 a | Lietaus nuotekos - L1 8
1118594 | 5 a V1 | Lietaus nuotekos - L1 8
1118767 | 0 a | Lietaus nuotekos - L1 6
1118781 | 0 a | Lietaus nuotekos - L1 6
1119457 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1119916 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1121196 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1121210 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1121494 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1121508 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1121574 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1121588 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1121669 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1121683 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1122100 | 5 a V1 | Lietaus nuotekos - L1 10
1122515 | 5 a V1 | Lietaus nuotekos - L1 10
1122624 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1122638 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1123237 | 5 a V1 | Lietaus nuotekos - L1 10
1124061 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1124075 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1125096 | 5 a V1 | Lietaus nuotekos - L1 10
1125255 | 5 a V1 | Lietaus nuotekos - L1 10
1125457 | 5 a V1 | Lietaus nuotekos - L1 10
1125926 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1126263 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1126299 | 5 a V1 | Ūkio-buities nuotekos - F1 16
1127283 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1127337 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1127614 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1127628 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1128288 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128429 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128443 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128620 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128634 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128852 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1128902 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1129212 | 5 a V1 | Lietaus nuotekos - L1 7
1129242 | 5 a V1 | Lietaus nuotekos - L1 7
1129352 | 5 a V1 | Lietaus nuotekos - L1 7
1129388 | 5 a V1 | Lietaus nuotekos - L1 7
1129793 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1129908 | 4 a V1 | Ūkio-buities nuotekos - F1 20
1130063 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130077 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130091 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130235 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130282 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130354 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1130598 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1130640 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1130700 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1130828 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1130840 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1130900 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1131265 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1131376 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1131631 | 5 a V1 | K1 2
1131645 | 5 a V1 | K1 2
1131659 | 5 a V1 | K1 2
1131673 | 5 a V1 | K1 2
1131925 | 5 a V1 | K1 2
1131966 | 5 a V1 | K1 2
1132344 | 5 a V1 | K1 2
1132475 | 5 a V1 | K1 2
1139521 | 5 a V1 | K1 2
1139562 | 5 a V1 | K1 2
1139670 | 5 a V1 | K1 2
1139794 | 5 a V1 | K1 2
1139802 | 5 a V1 | K1 2
1140060 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1140074 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1140088 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1140171 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1140179 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1141270 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1141424 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1141432 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1141651 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1141856 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1143125 | 0 a | Lietaus nuotekos - L1 11
1143161 | 5 a V1 | Lietaus nuotekos - L1 11
1143199 | 0 a | Lietaus nuotekos - L1 11
1143205 | 5 a V1 | Lietaus nuotekos - L1 11
1143209 | 5 a V1 | Lietaus nuotekos - L1 11
1143761 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1143981 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1143995 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144030 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144149 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144232 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144238 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144452 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144460 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144571 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1144579 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145036 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145181 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145238 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145369 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145407 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145614 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145704 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145712 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1145942 | 5 a V1 | Ūkio-buities nuotekos - F1 8
1151773 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1151958 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152080 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152371 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152691 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152944 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1152960 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153077 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153091 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153105 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153165 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153171 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153294 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153300 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153547 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153606 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153612 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1153634 | 4 a V1 | Ūkio-buities nuotekos - F1 21
1154149 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1154199 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1154207 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155037 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155105 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155211 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155409 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155498 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155518 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155526 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155833 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155847 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155867 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1155875 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156058 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156160 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156180 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156212 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156224 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156353 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156403 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156409 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156430 | 4 a V1 | Ūkio-buities nuotekos - F1 22
1156496 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156582 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156693 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156699 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156733 | 4 a V1 | Ūkio-buities nuotekos - F1 23
1156843 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156855 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156869 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1156881 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157036 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157262 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157320 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157332 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157346 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157358 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157506 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157950 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157956 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1157999 | 4 a V1 | Ūkio-buities nuotekos - F1 24
1158126 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158188 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158194 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158222 | 4 a V1 | Ūkio-buities nuotekos - F1 25
1158329 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158341 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158373 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158385 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158399 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158411 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158635 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158729 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158741 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158817 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158829 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158843 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158873 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1158940 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159011 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159106 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159159 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159165 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159186 | 4 a V1 | Ūkio-buities nuotekos - F1 26
1159590 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159636 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159748 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159798 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159804 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159971 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1159977 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160031 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160131 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160137 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160332 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160391 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160397 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160518 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160526 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160627 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160682 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160688 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160863 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160871 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1160918 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1161010 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1161016 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1161532 | 4 a V1 | K1 2
1161707 | 4 a V1 | K1 2
1161748 | 5 a V1 | K1 2
1161982 | 5 a V1 | K1 2
1162125 | 4 a V1 | K1 2
1162141 | 5 a V1 | K1 2
1162149 | 5 a V1 | K1 2
1162299 | 0 a | Lietaus nuotekos - L1 3
1162328 | 0 a | Lietaus nuotekos - L1 3
1162507 | 5 a V1 | Lietaus nuotekos - L1 3
1162560 | 5 a V1 | Lietaus nuotekos - L1 3
1162712 | 0 a | Lietaus nuotekos - L1 3
1162720 | 5 a V1 | Lietaus nuotekos - L1 3
1162728 | 5 a V1 | Lietaus nuotekos - L1 3
1163232 | 4 a V1 | K1 2
1163240 | 4 a V1 | K1 2
1163478 | 4 a V1 | Ūkio-buities nuotekos - F1 27
