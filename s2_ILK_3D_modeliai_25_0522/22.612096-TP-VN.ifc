Properties of the parts of a building model (IFC2X3), part 39 of 57

# IfcFlowFitting: PIF_AS+_Super_Bend_Wavin:socket end (1994)
Name (PIF_AS+_Super_Bend_Wavin:socket end:...) | In | Group
1163592 | 4 a V1 | K1 2
1163600 | 4 a V1 | K1 2
1165589 | 4 a V1 | K1 2
1165611 | 4 a V1 | K1 2
1166090 | 4 a V1 | K1 2
1166169 | 4 a V1 | K1 2
1166451 | 4 a V1 | K1 2
1166457 | 4 a V1 | K1 2
1166792 | 4 a V1 | K1 2
1166845 | 4 a V1 | K1 2
1166853 | 4 a V1 | K1 2
1167177 | 4 a V1 | K1 2
1167324 | 4 a V1 | K1 2
1167492 | 4 a V1 | K1 2
1167498 | 4 a V1 | K1 2
1167736 | 4 a V1 | K1 2
1167862 | 4 a V1 | K1 2
1167915 | 4 a V1 | K1 2
1167923 | 4 a V1 | K1 2
1167944 | 4 a V1 | Ūkio-buities nuotekos - F1 28
1168501 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1168644 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1168871 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169190 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1169266 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169282 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1169288 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1169412 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1169426 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169480 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169661 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169667 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169796 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169852 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1169860 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170253 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170546 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170552 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170666 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170766 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170827 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1170835 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171040 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171046 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171183 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171281 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171289 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171310 | 4 a V1 | Ūkio-buities nuotekos - F1 29
1171352 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171411 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171417 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171530 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171631 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171639 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1171666 | 4 a V1 | Ūkio-buities nuotekos - F1 30
1171929 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1172078 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1172340 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172362 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172484 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172651 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172657 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172744 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172867 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172908 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1172929 | 4 a V1 | Ūkio-buities nuotekos - F1 31
1173231 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173307 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173329 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173411 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173548 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173562 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173637 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173651 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173706 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173714 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173735 | 4 a V1 | Ūkio-buities nuotekos - F1 32
1173781 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173844 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173979 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1173985 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174054 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174145 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174153 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174260 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174400 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174581 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174587 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174732 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174780 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1174788 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1175095 | 4 a V1 | K1 2
1175103 | 4 a V1 | K1 2
1175257 | 4 a V1 | Ūkio-buities nuotekos - F1 34
1175263 | 4 a V1 | Ūkio-buities nuotekos - F1 34
1175489 | 0 a | Lietaus nuotekos - L1 11
1175503 | 5 a V1 | Lietaus nuotekos - L1 11
1175540 | 5 a V1 | Lietaus nuotekos - L1 11
1175813 | 0 a | Lietaus nuotekos - L1 11
1175860 | 5 a V1 | Lietaus nuotekos - L1 11
1175898 | 5 a V1 | Lietaus nuotekos - L1 11
1176012 | 0 a | Lietaus nuotekos - L1 11
1176020 | 4 a V1 | Lietaus nuotekos - L1 11
1176389 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1176403 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1176495 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1176752 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1176784 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1176812 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177208 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177348 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177354 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177579 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177658 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177666 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1177717 | 4 a V1 | Ūkio-buities nuotekos - F1 33
1178032 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178289 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178457 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178463 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178598 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178827 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178835 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1178956 | 4 a V1 | Ūkio-buities nuotekos - F1 35
1179199 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1179472 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1179858 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1179950 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1179956 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180142 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180201 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180209 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180490 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1180750 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1180882 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1180947 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1180955 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1181159 | 4 a V1 | Ūkio-buities nuotekos - F1 36
1181271 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1181285 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1181382 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1181715 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1181828 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1182049 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1182177 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1182333 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1182421 | 0 a | Lietaus nuotekos - L1 13
1182631 | 5 a V1 | Lietaus nuotekos - L1 13
1182727 | 5 a V1 | Lietaus nuotekos - L1 13
1183023 | 5 a V1 | Lietaus nuotekos - L1 13
1183401 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1183497 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1183551 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1183559 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1183577 | 4 a V1 | Ūkio-buities nuotekos - F1 37
1183785 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184008 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184072 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184143 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184151 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1184168 | 4 a V1 | Ūkio-buities nuotekos - F1 38
1184385 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1185455 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1185502 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1185516 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1185753 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1185761 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186163 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186254 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186293 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186422 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186500 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186506 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186575 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186589 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186624 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186630 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186679 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186755 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186761 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186905 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186956 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1186962 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187144 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187218 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187226 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187276 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187347 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187353 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187490 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187537 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187579 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187585 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187628 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187666 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187672 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187850 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1187970 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188142 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188282 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188352 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188360 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188422 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188621 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188627 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188720 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188802 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188808 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188861 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188875 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188928 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1188934 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189318 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189324 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189423 | 4 a V1 | Ūkio-buities nuotekos - F1 39
1189442 | 4 a V1 | Ūkio-buities nuotekos - F1 40
1189448 | 4 a V1 | Ūkio-buities nuotekos - F1 42
1189492 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189557 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189563 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189740 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189748 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1189939 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190105 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190113 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190343 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190357 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190565 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190687 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190693 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190880 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1190950 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191033 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191041 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191213 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191219 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1191336 | 4 a V1 | K1 2
1191381 | 4 a V1 | K1 2
1191450 | 4 a V1 | K1 2
1191456 | 4 a V1 | K1 2
1191511 | 4 a V1 | K1 2
1191553 | 4 a V1 | K1 2
1191559 | 4 a V1 | K1 2
1191700 | 4 a V1 | K1 2
1191740 | 4 a V1 | K1 2
1191746 | 4 a V1 | K1 2
1191822 | 4 a V1 | K1 2
1191957 | 4 a V1 | K1 2
1191965 | 4 a V1 | K1 2
1192073 | 4 a V1 | K1 2
1192081 | 4 a V1 | K1 2
1192157 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192169 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192181 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192226 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192232 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192296 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192446 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192452 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192560 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192599 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192766 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1192772 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1193081 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193120 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193239 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193286 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193310 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193358 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193364 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193404 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193778 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193853 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193859 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193904 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193987 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1193993 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1194116 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194130 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194214 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194220 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194486 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194492 | 4 a V1 | Ūkio-buities nuotekos - F1 7
1194595 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1194679 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1194685 | 4 a V1 | Ūkio-buities nuotekos - F1 9
1194736 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1194750 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1194815 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1194821 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1194930 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1194936 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1195095 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195133 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195139 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195224 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195263 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195602 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195610 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195676 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195752 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1195758 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1196301 | 5 a V1 | K1 2
1196354 | 5 a V1 | K1 2
1196360 | 5 a V1 | K1 2
1196405 | 5 a V1 | K1 2
1196461 | 5 a V1 | K1 2
1196469 | 5 a V1 | K1 2
1196519 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1196579 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1196585 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1196808 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1196852 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1196858 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1196962 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1197034 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1197040 | 5 a V1 | Ūkio-buities nuotekos - F1 5
1197326 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1197374 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1197382 | 5 a V1 | Ūkio-buities nuotekos - F1 7
1197499 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1197548 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1197556 | 5 a V1 | Ūkio-buities nuotekos - F1 10
1197651 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1197657 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1197892 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198122 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198270 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198284 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198328 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198336 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198403 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198411 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198805 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198876 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1198884 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199181 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199335 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199343 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199934 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199948 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1199962 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200057 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200065 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200236 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200342 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200356 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200394 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200400 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200469 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200545 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200553 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1200652 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1200862 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1200906 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1200914 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201079 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201207 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201223 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201300 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201316 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201387 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201611 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201659 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201717 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201723 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201836 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201850 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201933 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1201939 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202004 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202052 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202058 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202365 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202373 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202423 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202437 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202477 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202483 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202504 | 4 a V1 | Ūkio-buities nuotekos - F1 41
1202700 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202740 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202746 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1202845 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1202903 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203011 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203064 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203070 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203146 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203154 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203227 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203269 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203275 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203324 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203371 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203377 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203420 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203495 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203501 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203573 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203579 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203635 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203678 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203684 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203735 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203777 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203783 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1203851 | 5 a V1 | Ūkio-buities nuotekos - F1 16
1203920 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1203971 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204083 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204127 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204133 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204181 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204300 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204407 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204413 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204601 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204740 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204766 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204774 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204915 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204921 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1204954 | 4 a V1 | Ūkio-buities nuotekos - F1 43
1205019 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205144 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205183 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205339 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205347 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205449 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205530 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205536 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1205636 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1205674 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1205713 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1205834 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1205840 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1206010 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1206016 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1206093 | 4 a V1 | Ūkio-buities nuotekos - F1 20
1206135 | 4 a V1 | Ūkio-buities nuotekos - F1 20
1206143 | 4 a V1 | Ūkio-buities nuotekos - F1 20
1206187 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206220 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206228 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206287 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206457 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206463 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206561 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206567 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206632 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206676 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206682 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206771 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206779 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206825 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206968 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1206974 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1207036 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1207119 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1207125 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1208447 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1209134 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1209221 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1209416 | 4 a V1 | Ūkio-buities nuotekos - F1 15
1209424 | 4 a V1 | Ūkio-buities nuotekos - F1 15
1209740 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1209754 | 3 a | Ūkio-buities nuotekos - F1 16
1209829 | 3 a | Ūkio-buities nuotekos - F1 16
1209835 | 3 a | Ūkio-buities nuotekos - F1 16
1210600 | 3 a | Ūkio-buities nuotekos - F1 16
1210606 | 3 a | Ūkio-buities nuotekos - F1 16
1210695 | 3 a | Ūkio-buities nuotekos - F1 16
1210709 | 3 a | Ūkio-buities nuotekos - F1 16
1210769 | 3 a | Ūkio-buities nuotekos - F1 16
1210775 | 3 a | Ūkio-buities nuotekos - F1 16
1210927 | 3 a | Ūkio-buities nuotekos - F1 16
1210980 | 3 a | Ūkio-buities nuotekos - F1 16
1210986 | 3 a | Ūkio-buities nuotekos - F1 16
1211021 | 3 a | Ūkio-buities nuotekos - F1 44
1211094 | 3 a | Ūkio-buities nuotekos - F1 16
1211184 | 3 a | Ūkio-buities nuotekos - F1 16
1211190 | 3 a | Ūkio-buities nuotekos - F1 16
1211223 | 3 a | Ūkio-buities nuotekos - F1 45
1211813 | 3 a | Ūkio-buities nuotekos - F1 16
1211827 | 3 a | Ūkio-buities nuotekos - F1 16
1212102 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1212215 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1212247 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1212335 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1212971 | 4 a V1 | Ūkio-buities nuotekos - F1 14
1213009 | 3 a | Ūkio-buities nuotekos - F1 14
1213106 | 3 a | Ūkio-buities nuotekos - F1 14
1213112 | 3 a | Ūkio-buities nuotekos - F1 14
1213300 | 3 a | Ūkio-buities nuotekos - F1 14
1213314 | 3 a | Ūkio-buities nuotekos - F1 14
1213559 | 3 a | Ūkio-buities nuotekos - F1 14
1213565 | 3 a | Ūkio-buities nuotekos - F1 14
1213653 | 3 a | Ūkio-buities nuotekos - F1 14
1213739 | 3 a | Ūkio-buities nuotekos - F1 14
1213809 | 3 a | Ūkio-buities nuotekos - F1 14
1213817 | 3 a | Ūkio-buities nuotekos - F1 14
1213935 | 3 a | Ūkio-buities nuotekos - F1 14
1213949 | 3 a | Ūkio-buities nuotekos - F1 14
1214024 | 3 a | Ūkio-buities nuotekos - F1 14
1214032 | 3 a | Ūkio-buities nuotekos - F1 14
1214299 | 5 a V1 | Lietaus nuotekos - L1 10
1214362 | 5 a V1 | Lietaus nuotekos - L1 10
1214425 | 4 a V1 | Lietaus nuotekos - L1 10
1214485 | 4 a V1 | Lietaus nuotekos - L1 10
1214667 | 4 a V1 | Lietaus nuotekos - L1 10
1214697 | 4 a V1 | Lietaus nuotekos - L1 10
1214719 | 5 a V1 | Lietaus nuotekos - L1 10
1214727 | 3 a | Lietaus nuotekos - L1 10
1215448 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1215483 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1215497 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1215535 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1215724 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1216632 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1216720 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1216734 | 3 a | Ūkio-buities nuotekos - F1 13
1216858 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1216866 | 3 a | Ūkio-buities nuotekos - F1 13
1217155 | 3 a | Ūkio-buities nuotekos - F1 13
1217367 | 3 a | Ūkio-buities nuotekos - F1 13
1217373 | 3 a | Ūkio-buities nuotekos - F1 13
1217424 | 3 a | Ūkio-buities nuotekos - F1 13
1217509 | 3 a | Ūkio-buities nuotekos - F1 13
1217515 | 3 a | Ūkio-buities nuotekos - F1 13
1217536 | 3 a | Ūkio-buities nuotekos - F1 46
1217739 | 3 a | Ūkio-buities nuotekos - F1 13
1217859 | 3 a | Ūkio-buities nuotekos - F1 13
1217865 | 3 a | Ūkio-buities nuotekos - F1 13
1217902 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1217984 | 2 a | Ūkio-buities nuotekos - F1 13
1218084 | 2 a | Ūkio-buities nuotekos - F1 13
1218183 | 4 a V1 | Ūkio-buities nuotekos - F1 13
1218278 | 3 a | Ūkio-buities nuotekos - F1 13
1218357 | 3 a | Ūkio-buities nuotekos - F1 13
1218371 | 3 a | Ūkio-buities nuotekos - F1 13
1218417 | 3 a | Ūkio-buities nuotekos - F1 13
1218425 | 3 a | Ūkio-buities nuotekos - F1 13
1218473 | 3 a | Ūkio-buities nuotekos - F1 13
1218487 | 3 a | Ūkio-buities nuotekos - F1 13
1218501 | 3 a | Ūkio-buities nuotekos - F1 13
1218586 | 3 a | Ūkio-buities nuotekos - F1 13
1218592 | 3 a | Ūkio-buities nuotekos - F1 13
1218670 | 3 a | Ūkio-buities nuotekos - F1 13
1218676 | 3 a | Ūkio-buities nuotekos - F1 13
1218697 | 3 a | Ūkio-buities nuotekos - F1 47
1219296 | 3 a | Ūkio-buities nuotekos - F1 11
1219310 | 3 a | Ūkio-buities nuotekos - F1 11
1219365 | 3 a | Ūkio-buities nuotekos - F1 11
1219371 | 3 a | Ūkio-buities nuotekos - F1 11
1219539 | 3 a | Ūkio-buities nuotekos - F1 11
1219578 | 3 a | Ūkio-buities nuotekos - F1 11
1219761 | 3 a | Ūkio-buities nuotekos - F1 11
1219843 | 3 a | Ūkio-buities nuotekos - F1 11
1219849 | 3 a | Ūkio-buities nuotekos - F1 11
1220028 | 0 a | Lietaus nuotekos - L1 13
1220521 | 0 a | Lietaus nuotekos - L1 13
1220527 | 0 a | Lietaus nuotekos - L1 13
1220596 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1220963 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1221110 | 4 a V1 | Ūkio-buities nuotekos - F1 10
1221230 | 3 a | Ūkio-buities nuotekos - F1 10
1221281 | 3 a | Ūkio-buities nuotekos - F1 10
1221289 | 3 a | Ūkio-buities nuotekos - F1 10
1221629 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1221765 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1221785 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1221793 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1221896 | 5 a V1 | Lietaus nuotekos - L1 7
1221935 | 5 a V1 | Lietaus nuotekos - L1 7
1222012 | 4 a V1 | Lietaus nuotekos - L1 7
1222142 | 5 a V1 | Lietaus nuotekos - L1 7
1222807 | 4 a V1 | Lietaus nuotekos - L1 7
1222813 | 4 a V1 | Lietaus nuotekos - L1 7
1222914 | 3 a | Ūkio-buities nuotekos - F1 12
1222994 | 3 a | Ūkio-buities nuotekos - F1 12
1223000 | 3 a | Ūkio-buities nuotekos - F1 12
1223125 | 3 a | Ūkio-buities nuotekos - F1 12
1223137 | 3 a | Ūkio-buities nuotekos - F1 12
1223323 | 3 a | Ūkio-buities nuotekos - F1 12
1223337 | 3 a | Ūkio-buities nuotekos - F1 12
1223432 | 3 a | Ūkio-buities nuotekos - F1 12
1223438 | 3 a | Ūkio-buities nuotekos - F1 12
1223492 | 3 a | Ūkio-buities nuotekos - F1 48
1223578 | 3 a | Ūkio-buities nuotekos - F1 12
1223617 | 3 a | Ūkio-buities nuotekos - F1 12
1223915 | 3 a | Ūkio-buities nuotekos - F1 12
1223921 | 3 a | Ūkio-buities nuotekos - F1 12
1224044 | 3 a | Ūkio-buities nuotekos - F1 12
1224058 | 3 a | Ūkio-buities nuotekos - F1 12
1224144 | 3 a | Ūkio-buities nuotekos - F1 12
1224216 | 3 a | Ūkio-buities nuotekos - F1 12
1224222 | 3 a | Ūkio-buities nuotekos - F1 12
1224341 | 3 a | Ūkio-buities nuotekos - F1 9
1224355 | 3 a | Ūkio-buities nuotekos - F1 9
1224400 | 3 a | Ūkio-buities nuotekos - F1 9
1224408 | 3 a | Ūkio-buities nuotekos - F1 9
1224460 | 3 a | Ūkio-buities nuotekos - F1 9
1224503 | 3 a | Ūkio-buities nuotekos - F1 9
1224511 | 3 a | Ūkio-buities nuotekos - F1 9
1224533 | 3 a | Ūkio-buities nuotekos - F1 49
1224798 | 3 a | Ūkio-buities nuotekos - F1 8
1225175 | 3 a | Ūkio-buities nuotekos - F1 8
1225183 | 3 a | Ūkio-buities nuotekos - F1 8
1225220 | 3 a | Ūkio-buities nuotekos - F1 50
1225331 | 3 a | Ūkio-buities nuotekos - F1 8
1225345 | 3 a | Ūkio-buities nuotekos - F1 8
1225430 | 3 a | Ūkio-buities nuotekos - F1 8
1225438 | 3 a | Ūkio-buities nuotekos - F1 8
1225606 | 3 a | Ūkio-buities nuotekos - F1 8
1225706 | 3 a | Ūkio-buities nuotekos - F1 8
1225753 | 3 a | Ūkio-buities nuotekos - F1 8
1225761 | 3 a | Ūkio-buities nuotekos - F1 8
1225808 | 3 a | Ūkio-buities nuotekos - F1 8
1225822 | 3 a | Ūkio-buities nuotekos - F1 8
1225892 | 3 a | Ūkio-buities nuotekos - F1 8
1225900 | 3 a | Ūkio-buities nuotekos - F1 8
1226524 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1226538 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1226574 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1226966 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1227118 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1227293 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1227453 | 2 a | Ūkio-buities nuotekos - F1 6
1227516 | 2 a | Ūkio-buities nuotekos - F1 6
1227546 | 2 a | Ūkio-buities nuotekos - F1 6
1227560 | 3 a | Ūkio-buities nuotekos - F1 6
1227676 | 3 a | Ūkio-buities nuotekos - F1 6
1227684 | 3 a | Ūkio-buities nuotekos - F1 6
1228016 | 4 a V1 | Ūkio-buities nuotekos - F1 5
1228074 | 3 a | Ūkio-buities nuotekos - F1 5
1228249 | 3 a | Ūkio-buities nuotekos - F1 5
1228257 | 3 a | Ūkio-buities nuotekos - F1 5
1228279 | 3 a | Ūkio-buities nuotekos - F1 51
1228409 | 3 a | Ūkio-buities nuotekos - F1 5
1228417 | 3 a | Ūkio-buities nuotekos - F1 5
1228441 | 3 a | Ūkio-buities nuotekos - F1 52
1228495 | 3 a | Ūkio-buities nuotekos - F1 5
1228550 | 3 a | Ūkio-buities nuotekos - F1 5
1228558 | 3 a | Ūkio-buities nuotekos - F1 5
1228579 | 3 a | Ūkio-buities nuotekos - F1 53
1228629 | 3 a | Ūkio-buities nuotekos - F1 5
1228685 | 3 a | Ūkio-buities nuotekos - F1 5
1228693 | 3 a | Ūkio-buities nuotekos - F1 5
1228859 | 4 a V1 | K1 2
1228939 | 3 a | K1 2
1229024 | 3 a | K1 2
1229095 | 3 a | K1 2
1229101 | 3 a | K1 2
1229402 | 3 a | K1 2
1229441 | 3 a | K1 2
1229545 | 3 a | K1 2
1229553 | 3 a | K1 2
1229667 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1229681 | 3 a | Ūkio-buities nuotekos - F1 1
1229734 | 3 a | Ūkio-buities nuotekos - F1 1
1229742 | 3 a | Ūkio-buities nuotekos - F1 1
1230087 | 3 a | Ūkio-buities nuotekos - F1 1
1230304 | 3 a | Ūkio-buities nuotekos - F1 1
1230371 | 3 a | Ūkio-buities nuotekos - F1 1
1230379 | 3 a | Ūkio-buities nuotekos - F1 1
1230903 | 3 a | Ūkio-buities nuotekos - F1 1
1231003 | 3 a | Ūkio-buities nuotekos - F1 1
1231009 | 3 a | Ūkio-buities nuotekos - F1 1
1231072 | 3 a | Ūkio-buities nuotekos - F1 1
1231148 | 3 a | Ūkio-buities nuotekos - F1 1
1231154 | 3 a | Ūkio-buities nuotekos - F1 1
1231363 | 3 a | Ūkio-buities nuotekos - F1 1
1231377 | 3 a | Ūkio-buities nuotekos - F1 1
1231424 | 3 a | Ūkio-buities nuotekos - F1 1
1231430 | 3 a | Ūkio-buities nuotekos - F1 1
1231490 | 3 a | Ūkio-buities nuotekos - F1 1
1231653 | 3 a | Ūkio-buities nuotekos - F1 1
1231706 | 3 a | Ūkio-buities nuotekos - F1 1
1231834 | 3 a | Ūkio-buities nuotekos - F1 1
1231946 | 3 a | Ūkio-buities nuotekos - F1 1
1231996 | 3 a | Ūkio-buities nuotekos - F1 1
1232002 | 3 a | Ūkio-buities nuotekos - F1 1
1232033 | 3 a | Ūkio-buities nuotekos - F1 54
1232090 | 3 a | Ūkio-buities nuotekos - F1 1
1232136 | 3 a | Ūkio-buities nuotekos - F1 1
1232142 | 3 a | Ūkio-buities nuotekos - F1 1
1232274 | 3 a | Ūkio-buities nuotekos - F1 1
1232357 | 3 a | Ūkio-buities nuotekos - F1 1
1232363 | 3 a | Ūkio-buities nuotekos - F1 1
1232405 | 3 a | Ūkio-buities nuotekos - F1 55
1232453 | 3 a | Ūkio-buities nuotekos - F1 1
1232581 | 3 a | Ūkio-buities nuotekos - F1 1
1232595 | 3 a | Ūkio-buities nuotekos - F1 1
1232667 | 3 a | Ūkio-buities nuotekos - F1 1
1232782 | 3 a | Ūkio-buities nuotekos - F1 1
1232906 | 3 a | Ūkio-buities nuotekos - F1 1
1232962 | 3 a | Ūkio-buities nuotekos - F1 1
1232970 | 3 a | Ūkio-buities nuotekos - F1 1
1233217 | 3 a | Ūkio-buities nuotekos - F1 1
1233296 | 3 a | Ūkio-buities nuotekos - F1 1
1233317 | 3 a | Ūkio-buities nuotekos - F1 56
1233389 | 3 a | Ūkio-buities nuotekos - F1 1
1233813 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1233945 | 3 a | Ūkio-buities nuotekos - F1 1
1234244 | 3 a | Ūkio-buities nuotekos - F1 1
1234250 | 3 a | Ūkio-buities nuotekos - F1 1
1234460 | 3 a | Ūkio-buities nuotekos - F1 1
1234499 | 3 a | Ūkio-buities nuotekos - F1 1
1234656 | 3 a | Ūkio-buities nuotekos - F1 1
1234703 | 3 a | Ūkio-buities nuotekos - F1 1
1234709 | 3 a | Ūkio-buities nuotekos - F1 1
1234800 | 3 a | Ūkio-buities nuotekos - F1 1
1235315 | 3 a | Ūkio-buities nuotekos - F1 1
1235356 | 3 a | Ūkio-buities nuotekos - F1 1
1235724 | 3 a | Ūkio-buities nuotekos - F1 1
1235850 | 3 a | Ūkio-buities nuotekos - F1 1
1235950 | 3 a | Ūkio-buities nuotekos - F1 1
1236075 | 3 a | Ūkio-buities nuotekos - F1 1
1236081 | 3 a | Ūkio-buities nuotekos - F1 1
1236111 | 3 a | Ūkio-buities nuotekos - F1 57
1236161 | 3 a | Ūkio-buities nuotekos - F1 1
1236284 | 3 a | Ūkio-buities nuotekos - F1 1
1236290 | 3 a | Ūkio-buities nuotekos - F1 1
1236390 | 3 a | Ūkio-buities nuotekos - F1 58
1236438 | 3 a | Ūkio-buities nuotekos - F1 1
1236452 | 3 a | Ūkio-buities nuotekos - F1 1
1236504 | 3 a | Ūkio-buities nuotekos - F1 1
1236580 | 3 a | Ūkio-buities nuotekos - F1 1
1236604 | 3 a | Ūkio-buities nuotekos - F1 59
1237032 | 3 a | Ūkio-buities nuotekos - F1 1
1237314 | 3 a | Ūkio-buities nuotekos - F1 2
1237328 | 3 a | Ūkio-buities nuotekos - F1 2
1237417 | 3 a | Ūkio-buities nuotekos - F1 2
1237453 | 3 a | Ūkio-buities nuotekos - F1 2
1237540 | 3 a | Ūkio-buities nuotekos - F1 2
1237546 | 3 a | Ūkio-buities nuotekos - F1 2
1237672 | 3 a | Ūkio-buities nuotekos - F1 2
1237678 | 3 a | Ūkio-buities nuotekos - F1 2
1237973 | 3 a | Ūkio-buities nuotekos - F1 2
1238179 | 3 a | Ūkio-buities nuotekos - F1 2
1238520 | 3 a | Ūkio-buities nuotekos - F1 2
1238600 | 3 a | Ūkio-buities nuotekos - F1 2
1238606 | 3 a | Ūkio-buities nuotekos - F1 2
1238735 | 3 a | Ūkio-buities nuotekos - F1 2
1238822 | 3 a | Ūkio-buities nuotekos - F1 2
1238974 | 3 a | Ūkio-buities nuotekos - F1 2
1239060 | 3 a | Ūkio-buities nuotekos - F1 2
1239106 | 3 a | Ūkio-buities nuotekos - F1 2
1239112 | 3 a | Ūkio-buities nuotekos - F1 2
1239183 | 3 a | Ūkio-buities nuotekos - F1 2
1239252 | 3 a | Ūkio-buities nuotekos - F1 2
1239258 | 3 a | Ūkio-buities nuotekos - F1 2
1239301 | 3 a | Ūkio-buities nuotekos - F1 2
1239348 | 3 a | Ūkio-buities nuotekos - F1 2
1239390 | 3 a | Ūkio-buities nuotekos - F1 2
1239396 | 3 a | Ūkio-buities nuotekos - F1 2
1239519 | 3 a | Ūkio-buities nuotekos - F1 2
1239596 | 3 a | Ūkio-buities nuotekos - F1 2
1239602 | 3 a | Ūkio-buities nuotekos - F1 2
1239688 | 3 a | Ūkio-buities nuotekos - F1 2
1239831 | 3 a | Ūkio-buities nuotekos - F1 2
1239837 | 3 a | Ūkio-buities nuotekos - F1 2
1240167 | 3 a | Ūkio-buities nuotekos - F1 2
1240245 | 3 a | Ūkio-buities nuotekos - F1 2
1240251 | 3 a | Ūkio-buities nuotekos - F1 2
1240279 | 3 a | Ūkio-buities nuotekos - F1 60
1240370 | 3 a | Ūkio-buities nuotekos - F1 2
1240417 | 3 a | Ūkio-buities nuotekos - F1 2
1240462 | 3 a | Ūkio-buities nuotekos - F1 2
1240468 | 3 a | Ūkio-buities nuotekos - F1 2
1241092 | 4 a V1 | Ūkio-buities nuotekos - F1 2
1241193 | 2 a | Ūkio-buities nuotekos - F1 2
1241297 | 2 a | Ūkio-buities nuotekos - F1 2
1241305 | 2 a | Ūkio-buities nuotekos - F1 2
1241410 | 2 a | Ūkio-buities nuotekos - F1 2
1241468 | 2 a | Ūkio-buities nuotekos - F1 2
1241474 | 2 a | Ūkio-buities nuotekos - F1 2
1241622 | 2 a | Ūkio-buities nuotekos - F1 2
1241628 | 2 a | Ūkio-buities nuotekos - F1 2
1241720 | 2 a | Ūkio-buities nuotekos - F1 2
1241726 | 2 a | Ūkio-buities nuotekos - F1 2
1241823 | 2 a | Ūkio-buities nuotekos - F1 2
1241876 | 2 a | Ūkio-buities nuotekos - F1 2
1241882 | 2 a | Ūkio-buities nuotekos - F1 2
1241950 | 2 a | Ūkio-buities nuotekos - F1 2
1241958 | 2 a | Ūkio-buities nuotekos - F1 2
1242192 | 2 a | Ūkio-buities nuotekos - F1 2
1242318 | 2 a | Ūkio-buities nuotekos - F1 2
1242324 | 2 a | Ūkio-buities nuotekos - F1 2
1242370 | 2 a | Ūkio-buities nuotekos - F1 2
1242409 | 2 a | Ūkio-buities nuotekos - F1 2
1242415 | 2 a | Ūkio-buities nuotekos - F1 2
1242461 | 2 a | Ūkio-buities nuotekos - F1 2
1242507 | 2 a | Ūkio-buities nuotekos - F1 2
1242515 | 2 a | Ūkio-buities nuotekos - F1 2
1242561 | 2 a | Ūkio-buities nuotekos - F1 2
1242575 | 2 a | Ūkio-buities nuotekos - F1 2
1242655 | 2 a | Ūkio-buities nuotekos - F1 2
1242663 | 2 a | Ūkio-buities nuotekos - F1 2
1242950 | 2 a | Ūkio-buities nuotekos - F1 2
1242958 | 2 a | Ūkio-buities nuotekos - F1 2
1243787 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1243795 | 4 a V1 | Ūkio-buities nuotekos - F1 1
1243949 | 2 a | Ūkio-buities nuotekos - F1 2
1244005 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1244019 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1244048 | 1 a +-152.84 | Ūkio-buities nuotekos - F1 2
1244062 | 2 a | Ūkio-buities nuotekos - F1 2
1244076 | 2 a | Ūkio-buities nuotekos - F1 2
1244119 | 2 a | Ūkio-buities nuotekos - F1 2
1244127 | 2 a | Ūkio-buities nuotekos - F1 2
1244213 | 2 a | Ūkio-buities nuotekos - F1 2
1244291 | 2 a | Ūkio-buities nuotekos - F1 2
1244451 | 2 a | Ūkio-buities nuotekos - F1 2
1244459 | 2 a | Ūkio-buities nuotekos - F1 2
1244814 | 2 a | Ūkio-buities nuotekos - F1 2
1244822 | 2 a | Ūkio-buities nuotekos - F1 2
1245005 | 2 a | Ūkio-buities nuotekos - F1 1
1245214 | 2 a | Ūkio-buities nuotekos - F1 1
1245254 | 2 a | Ūkio-buities nuotekos - F1 1
1245262 | 2 a | Ūkio-buities nuotekos - F1 1
1245593 | 2 a | Ūkio-buities nuotekos - F1 1
1245599 | 2 a | Ūkio-buities nuotekos - F1 1
1245783 | 2 a | Ūkio-buities nuotekos - F1 1
1245822 | 2 a | Ūkio-buities nuotekos - F1 1
1245987 | 2 a | Ūkio-buities nuotekos - F1 1
1246026 | 2 a | Ūkio-buities nuotekos - F1 1
1246127 | 2 a | Ūkio-buities nuotekos - F1 1
1246236 | 2 a | Ūkio-buities nuotekos - F1 1
1246450 | 2 a | Ūkio-buities nuotekos - F1 1
1246604 | 2 a | Ūkio-buities nuotekos - F1 1
1246612 | 2 a | Ūkio-buities nuotekos - F1 1
1246790 | 2 a | Ūkio-buities nuotekos - F1 1
1246804 | 2 a | Ūkio-buities nuotekos - F1 1
1246861 | 2 a | Ūkio-buities nuotekos - F1 1
1246869 | 2 a | Ūkio-buities nuotekos - F1 1
1247162 | 2 a | Ūkio-buities nuotekos - F1 1
1247253 | 2 a | Ūkio-buities nuotekos - F1 1
1247261 | 2 a | Ūkio-buities nuotekos - F1 1
1247410 | 2 a | Ūkio-buities nuotekos - F1 1
1247451 | 2 a | Ūkio-buities nuotekos - F1 1
1247724 | 2 a | K1 2
1247736 | 2 a | K1 2
1247843 | 2 a | K1 2
1247980 | 2 a | K1 2
1248152 | 2 a | K1 2
1248158 | 2 a | K1 2
1248206 | 2 a | K1 2
1248254 | 2 a | K1 2
1248262 | 2 a | K1 2
1248315 | 2 a | K1 2
1248361 | 2 a | K1 2
1248369 | 2 a | K1 2
1248524 | 2 a | K1 2
1248530 | 2 a | K1 2
1248672 | 2 a | K1 2
1248680 | 2 a | K1 2
1248782 | 2 a | K1 2
1248845 | 2 a | K1 2
1248853 | 2 a | K1 2
1249001 | 2 a | Ūkio-buities nuotekos - F1 61
1249057 | 2 a | K1 2
1249071 | 2 a | K1 2
1249221 | 2 a | K1 2
1249227 | 2 a | K1 2
1249513 | 2 a | Ūkio-buities nuotekos - F1 5
1249558 | 2 a | Ūkio-buities nuotekos - F1 5
1249566 | 2 a | Ūkio-buities nuotekos - F1 5
1249610 | 2 a | Ūkio-buities nuotekos - F1 5
1249658 | 2 a | Ūkio-buities nuotekos - F1 5
1249664 | 2 a | Ūkio-buities nuotekos - F1 5
1249758 | 2 a | Ūkio-buities nuotekos - F1 62
1249778 | 2 a | Ūkio-buities nuotekos - F1 63
1249932 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1249946 | 2 a | Ūkio-buities nuotekos - F1 6
1249992 | 2 a | Ūkio-buities nuotekos - F1 6
1249998 | 2 a | Ūkio-buities nuotekos - F1 6
1250101 | 2 a | Ūkio-buities nuotekos - F1 6
1250107 | 2 a | Ūkio-buities nuotekos - F1 6
1250159 | 2 a | Ūkio-buities nuotekos - F1 6
1250165 | 2 a | Ūkio-buities nuotekos - F1 6
1250270 | 2 a | Ūkio-buities nuotekos - F1 6
1250278 | 2 a | Ūkio-buities nuotekos - F1 6
1250316 | 2 a | Ūkio-buities nuotekos - F1 64
1250366 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1250426 | 4 a V1 | Ūkio-buities nuotekos - F1 6
1250778 | 4 a V1 | Ūkio-buities nuotekos - F1 8
1250792 | 2 a | Ūkio-buities nuotekos - F1 8
1250847 | 2 a | Ūkio-buities nuotekos - F1 8
1250855 | 2 a | Ūkio-buities nuotekos - F1 8
1250896 | 2 a | Ūkio-buities nuotekos - F1 65
1251002 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1251049 | 2 a | Ūkio-buities nuotekos - F1 12
1251100 | 2 a | Ūkio-buities nuotekos - F1 12
1251106 | 2 a | Ūkio-buities nuotekos - F1 12
1251201 | 2 a | Ūkio-buities nuotekos - F1 12
1251215 | 2 a | Ūkio-buities nuotekos - F1 12
1251326 | 2 a | Ūkio-buities nuotekos - F1 12
1251381 | 2 a | Ūkio-buities nuotekos - F1 12
1251389 | 2 a | Ūkio-buities nuotekos - F1 12
1251441 | 2 a | Ūkio-buities nuotekos - F1 12
1251489 | 2 a | Ūkio-buities nuotekos - F1 12
1251497 | 2 a | Ūkio-buities nuotekos - F1 12
1251617 | 2 a | Ūkio-buities nuotekos - F1 12
1251658 | 2 a | Ūkio-buities nuotekos - F1 12
1251862 | 2 a | Ūkio-buities nuotekos - F1 12
1251931 | 2 a | Ūkio-buities nuotekos - F1 12
1251974 | 2 a | Ūkio-buities nuotekos - F1 12
1252059 | 2 a | Ūkio-buities nuotekos - F1 12
1252143 | 2 a | Ūkio-buities nuotekos - F1 12
1252151 | 2 a | Ūkio-buities nuotekos - F1 12
1252201 | 2 a | Ūkio-buities nuotekos - F1 12
1252278 | 2 a | Ūkio-buities nuotekos - F1 12
1252286 | 2 a | Ūkio-buities nuotekos - F1 12
1252366 | 4 a V1 | Ūkio-buities nuotekos - F1 12
1252449 | 2 a | Ūkio-buities nuotekos - F1 12
1252457 | 2 a | Ūkio-buities nuotekos - F1 12
1253194 | 2 a | Ūkio-buities nuotekos - F1 12
1253275 | 2 a | Ūkio-buities nuotekos - F1 12
1253370 | 2 a | Ūkio-buities nuotekos - F1 12
1253376 | 2 a | Ūkio-buities nuotekos - F1 12
1253424 | 2 a | Ūkio-buities nuotekos - F1 12
1253476 | 2 a | Ūkio-buities nuotekos - F1 12
1253490 | 2 a | Ūkio-buities nuotekos - F1 12
1253568 | 2 a | Ūkio-buities nuotekos - F1 12
1253576 | 2 a | Ūkio-buities nuotekos - F1 12
1253603 | 2 a | Ūkio-buities nuotekos - F1 66
1253661 | 2 a | Ūkio-buities nuotekos - F1 12
1253675 | 2 a | Ūkio-buities nuotekos - F1 12
1253712 | 2 a | Ūkio-buities nuotekos - F1 12
1253720 | 2 a | Ūkio-buities nuotekos - F1 12
1253766 | 2 a | Ūkio-buities nuotekos - F1 12
1253772 | 2 a | Ūkio-buities nuotekos - F1 12
1253784 | 2 a | Ūkio-buities nuotekos - F1 12
1253836 | 2 a | Ūkio-buities nuotekos - F1 12
1253844 | 2 a | Ūkio-buities nuotekos - F1 12
1253953 | 4 a V1 | Ūkio-buities nuotekos - F1 17
1254018 | 2 a | Ūkio-buities nuotekos - F1 17
1254158 | 2 a | Ūkio-buities nuotekos - F1 17
1254212 | 2 a | Ūkio-buities nuotekos - F1 17
1254372 | 2 a | Ūkio-buities nuotekos - F1 17
1254380 | 2 a | Ūkio-buities nuotekos - F1 17
1254422 | 2 a | Ūkio-buities nuotekos - F1 67
1254504 | 2 a | Ūkio-buities nuotekos - F1 17
1254512 | 2 a | Ūkio-buities nuotekos - F1 17
1254750 | 2 a | Ūkio-buities nuotekos - F1 17
1254803 | 2 a | Ūkio-buities nuotekos - F1 17
1254875 | 2 a | Ūkio-buities nuotekos - F1 17
1254883 | 2 a | Ūkio-buities nuotekos - F1 17
1255033 | 2 a | Ūkio-buities nuotekos - F1 17
1255039 | 2 a | Ūkio-buities nuotekos - F1 17
1255081 | 2 a | Ūkio-buities nuotekos - F1 17
1255261 | 2 a | Ūkio-buities nuotekos - F1 17
1255267 | 2 a | Ūkio-buities nuotekos - F1 17
1255386 | 2 a | Ūkio-buities nuotekos - F1 17
1255441 | 2 a | Ūkio-buities nuotekos - F1 17
1255447 | 2 a | Ūkio-buities nuotekos - F1 17
1255815 | 2 a | Ūkio-buities nuotekos - F1 17
1255989 | 2 a | Ūkio-buities nuotekos - F1 17
1256113 | 2 a | Ūkio-buities nuotekos - F1 17
1256196 | 2 a | Ūkio-buities nuotekos - F1 17
1256202 | 2 a | Ūkio-buities nuotekos - F1 17
1256338 | 2 a | Ūkio-buities nuotekos - F1 17
1256621 | 4 a V1 | Ūkio-buities nuotekos - F1 18
1256768 | 2 a | Ūkio-buities nuotekos - F1 18
1256864 | 2 a | Ūkio-buities nuotekos - F1 18
1256876 | 2 a | Ūkio-buities nuotekos - F1 18
1257142 | 2 a | Ūkio-buities nuotekos - F1 18
1257148 | 2 a | Ūkio-buities nuotekos - F1 18
1257242 | 2 a | Ūkio-buities nuotekos - F1 18
1257254 | 2 a | Ūkio-buities nuotekos - F1 18
1257979 | 2 a | Ūkio-buities nuotekos - F1 18
1257985 | 2 a | Ūkio-buities nuotekos - F1 18
1258092 | 2 a | Ūkio-buities nuotekos - F1 18
1258108 | 2 a | Ūkio-buities nuotekos - F1 18
1258248 | 2 a | Ūkio-buities nuotekos - F1 18
1258256 | 2 a | Ūkio-buities nuotekos - F1 18
1258458 | 2 a | Ūkio-buities nuotekos - F1 18
1258466 | 2 a | Ūkio-buities nuotekos - F1 18
1258553 | 2 a | Ūkio-buities nuotekos - F1 18
1258561 | 2 a | Ūkio-buities nuotekos - F1 18
1258634 | 2 a | Ūkio-buities nuotekos - F1 18
1258688 | 2 a | Ūkio-buities nuotekos - F1 18
1258696 | 2 a | Ūkio-buities nuotekos - F1 18
1258747 | 2 a | Ūkio-buities nuotekos - F1 18
1258798 | 2 a | Ūkio-buities nuotekos - F1 18
1258804 | 2 a | Ūkio-buities nuotekos - F1 18
1258861 | 2 a | Ūkio-buities nuotekos - F1 18
1258925 | 2 a | Ūkio-buities nuotekos - F1 18
1258931 | 2 a | Ūkio-buities nuotekos - F1 18
1259238 | 2 a | Ūkio-buities nuotekos - F1 18
1259250 | 2 a | Ūkio-buities nuotekos - F1 18
1259302 | 2 a | Ūkio-buities nuotekos - F1 18
1259379 | 2 a | Ūkio-buities nuotekos - F1 18
1259815 | 2 a | Ūkio-buities nuotekos - F1 13
1259871 | 2 a | Ūkio-buities nuotekos - F1 13
1260103 | 2 a | Ūkio-buities nuotekos - F1 13
1260683 | 2 a | Ūkio-buities nuotekos - F1 13
1260770 | 2 a | Ūkio-buities nuotekos - F1 13
1260981 | 2 a | Ūkio-buities nuotekos - F1 13
1260987 | 2 a | Ūkio-buities nuotekos - F1 13
1261038 | 2 a | Ūkio-buities nuotekos - F1 68
1261077 | 2 a | Ūkio-buities nuotekos - F1 13
1261140 | 2 a | Ūkio-buities nuotekos - F1 13
1261168 | 2 a | Ūkio-buities nuotekos - F1 13
1261234 | 2 a | Ūkio-buities nuotekos - F1 13
1261242 | 2 a | Ūkio-buities nuotekos - F1 13
1261426 | 2 a | Ūkio-buities nuotekos - F1 13
1261482 | 2 a | Ūkio-buities nuotekos - F1 13
1261575 | 2 a | Ūkio-buities nuotekos - F1 13
1261583 | 2 a | Ūkio-buities nuotekos - F1 13
1261963 | 2 a | Ūkio-buities nuotekos - F1 69
1262017 | 2 a | Ūkio-buities nuotekos - F1 69
1262031 | 2 a | Ūkio-buities nuotekos - F1 69
1262043 | 2 a | Ūkio-buities nuotekos - F1 69
1262090 | 2 a | Ūkio-buities nuotekos - F1 69
1262096 | 2 a | Ūkio-buities nuotekos - F1 69
1262947 | 2 a | Ūkio-buities nuotekos - F1 69
1262955 | 2 a | Ūkio-buities nuotekos - F1 69
1263070 | 2 a | Ūkio-buities nuotekos - F1 69
1263129 | 2 a | Ūkio-buities nuotekos - F1 69
1263135 | 2 a | Ūkio-buities nuotekos - F1 69
1263267 | 2 a | Ūkio-buities nuotekos - F1 69
1263315 | 2 a | Ūkio-buities nuotekos - F1 69
1263321 | 2 a | Ūkio-buities nuotekos - F1 69
1263439 | 2 a | Ūkio-buities nuotekos - F1 69
1263451 | 2 a | Ūkio-buities nuotekos - F1 69
1264151 | 2 a | Ūkio-buities nuotekos - F1 69
1264157 | 2 a | Ūkio-buities nuotekos - F1 69
1264185 | 2 a | Ūkio-buities nuotekos - F1 70
1264317 | 2 a | Ūkio-buities nuotekos - F1 71
1264487 | 2 a | Ūkio-buities nuotekos - F1 71
1264499 | 2 a | Ūkio-buities nuotekos - F1 71
1264638 | 2 a | Ūkio-buities nuotekos - F1 71
1264712 | 2 a | Ūkio-buities nuotekos - F1 71
1264724 | 2 a | Ūkio-buities nuotekos - F1 71
1265116 | 2 a | Ūkio-buities nuotekos - F1 71
1265351 | 2 a | Ūkio-buities nuotekos - F1 71
1265709 | 2 a | Ūkio-buities nuotekos - F1 71
1265715 | 2 a | Ūkio-buities nuotekos - F1 71
1265898 | 2 a | Ūkio-buities nuotekos - F1 71
1265979 | 2 a | Ūkio-buities nuotekos - F1 71
1265985 | 2 a | Ūkio-buities nuotekos - F1 71
1266159 | 2 a | Ūkio-buities nuotekos - F1 71
1266200 | 2 a | Ūkio-buities nuotekos - F1 71
1266275 | 2 a | Ūkio-buities nuotekos - F1 71
1266289 | 2 a | Ūkio-buities nuotekos - F1 71
1266369 | 2 a | Ūkio-buities nuotekos - F1 71
1266375 | 2 a | Ūkio-buities nuotekos - F1 71
1266672 | 2 a | Ūkio-buities nuotekos - F1 71
1266678 | 2 a | Ūkio-buities nuotekos - F1 71
1267030 | 2 a | Ūkio-buities nuotekos - F1 71
1267084 | 2 a | Ūkio-buities nuotekos - F1 71
1267096 | 2 a | Ūkio-buities nuotekos - F1 71
1267167 | 2 a | Ūkio-buities nuotekos - F1 71
1267173 | 2 a | Ūkio-buities nuotekos - F1 71
1267223 | 2 a | Ūkio-buities nuotekos - F1 71
1267450 | 2 a | Ūkio-buities nuotekos - F1 71
1267503 | 2 a | Ūkio-buities nuotekos - F1 71
1267640 | 2 a | Ūkio-buities nuotekos - F1 71
1267648 | 2 a | Ūkio-buities nuotekos - F1 71
1267824 | 2 a | Ūkio-buities nuotekos - F1 71
1267998 | 2 a | Ūkio-buities nuotekos - F1 71
1268084 | 2 a | Ūkio-buities nuotekos - F1 71
1268090 | 2 a | Ūkio-buities nuotekos - F1 71
1268184 | 2 a | Ūkio-buities nuotekos - F1 71
1268190 | 2 a | Ūkio-buities nuotekos - F1 71
1268326 | 2 a | Ūkio-buities nuotekos - F1 71
1268332 | 2 a | Ūkio-buities nuotekos - F1 71
1268453 | 2 a | Ūkio-buities nuotekos - F1 71
1268461 | 2 a | Ūkio-buities nuotekos - F1 71
1268600 | 2 a | Ūkio-buities nuotekos - F1 72
1268676 | 2 a | Ūkio-buities nuotekos - F1 72
1268945 | 2 a | Ūkio-buities nuotekos - F1 72
1269008 | 2 a | Ūkio-buities nuotekos - F1 72
1269167 | 2 a | Ūkio-buities nuotekos - F1 72
1269222 | 2 a | Ūkio-buities nuotekos - F1 72
1269308 | 2 a | Ūkio-buities nuotekos - F1 72
1269537 | 2 a | Ūkio-buities nuotekos - F1 72
1269543 | 2 a | Ūkio-buities nuotekos - F1 72
1269705 | 2 a | Ūkio-buities nuotekos - F1 72
1270078 | 2 a | Ūkio-buities nuotekos - F1 72
1270092 | 2 a | Ūkio-buities nuotekos - F1 72
1270137 | 2 a | Ūkio-buities nuotekos - F1 72
1270145 | 2 a | Ūkio-buities nuotekos - F1 72
1270322 | 2 a | Ūkio-buities nuotekos - F1 72
1270496 | 2 a | Ūkio-buities nuotekos - F1 72
1270502 | 2 a | Ūkio-buities nuotekos - F1 72
1270575 | 2 a | Ūkio-buities nuotekos - F1 72
1270641 | 2 a | Ūkio-buities nuotekos - F1 72
1270649 | 2 a | Ūkio-buities nuotekos - F1 72
1270742 | 2 a | Ūkio-buities nuotekos - F1 72
1270748 | 2 a | Ūkio-buities nuotekos - F1 72
1271001 | 2 a | Ūkio-buities nuotekos - F1 72
1271041 | 2 a | Ūkio-buities nuotekos - F1 72
1271047 | 2 a | Ūkio-buities nuotekos - F1 72
1271827 | 2 a | Ūkio-buities nuotekos - F1 72
1271979 | 2 a | Ūkio-buities nuotekos - F1 72
1272098 | 2 a | Ūkio-buities nuotekos - F1 72
1272138 | 2 a | Ūkio-buities nuotekos - F1 72
1272275 | 2 a | Ūkio-buities nuotekos - F1 72
1272314 | 2 a | Ūkio-buities nuotekos - F1 72
1272355 | 2 a | Ūkio-buities nuotekos - F1 73
1272454 | 2 a | Ūkio-buities nuotekos - F1 72
1272573 | 2 a | Ūkio-buities nuotekos - F1 72
1272877 | 2 a | Ūkio-buities nuotekos - F1 72
1272981 | 2 a | Ūkio-buities nuotekos - F1 72
1272995 | 2 a | Ūkio-buities nuotekos - F1 72
1273042 | 2 a | Ūkio-buities nuotekos - F1 72
1273050 | 2 a | Ūkio-buities nuotekos - F1 72
1273151 | 2 a | Ūkio-buities nuotekos - F1 74
1273212 | 2 a | Ūkio-buities nuotekos - F1 72
1273226 | 2 a | Ūkio-buities nuotekos - F1 72
1273277 | 2 a | Ūkio-buities nuotekos - F1 72
1273285 | 2 a | Ūkio-buities nuotekos - F1 72
1273411 | 2 a | Ūkio-buities nuotekos - F1 72
1273417 | 2 a | Ūkio-buities nuotekos - F1 72
1273470 | 2 a | Ūkio-buities nuotekos - F1 72
1273566 | 2 a | Ūkio-buities nuotekos - F1 72
1273572 | 2 a | Ūkio-buities nuotekos - F1 72
1273859 | 2 a | Ūkio-buities nuotekos - F1 72
1273867 | 2 a | Ūkio-buities nuotekos - F1 72
1274019 | 2 a | Ūkio-buities nuotekos - F1 72
1274258 | 2 a | Ūkio-buities nuotekos - F1 72
1274379 | 2 a | Ūkio-buities nuotekos - F1 72
1274391 | 2 a | Ūkio-buities nuotekos - F1 72
1274930 | 2 a | Ūkio-buities nuotekos - F1 72
1274936 | 2 a | Ūkio-buities nuotekos - F1 72
1275217 | 2 a | Ūkio-buities nuotekos - F1 72
1275229 | 2 a | Ūkio-buities nuotekos - F1 72
1275323 | 2 a | Ūkio-buities nuotekos - F1 72
1275335 | 2 a | Ūkio-buities nuotekos - F1 72
1275484 | 2 a | Ūkio-buities nuotekos - F1 72
1275490 | 2 a | Ūkio-buities nuotekos - F1 72
1275667 | 2 a | Ūkio-buities nuotekos - F1 72
1275681 | 2 a | Ūkio-buities nuotekos - F1 72
1275695 | 2 a | Ūkio-buities nuotekos - F1 72
1275734 | 2 a | Ūkio-buities nuotekos - F1 72
1275742 | 2 a | Ūkio-buities nuotekos - F1 72
1275999 | 2 a | Ūkio-buities nuotekos - F1 75
1276076 | 2 a | Ūkio-buities nuotekos - F1 75
1276140 | 2 a | Ūkio-buities nuotekos - F1 75
1276735 | 2 a | Ūkio-buities nuotekos - F1 75
1276749 | 2 a | Ūkio-buities nuotekos - F1 75
1277463 | 2 a | Ūkio-buities nuotekos - F1 75
1277571 | 2 a | Ūkio-buities nuotekos - F1 75
1277695 | 2 a | Ūkio-buities nuotekos - F1 75
1277703 | 2 a | Ūkio-buities nuotekos - F1 75
1277897 | 2 a | Ūkio-buities nuotekos - F1 75
1277940 | 2 a | Ūkio-buities nuotekos - F1 75
1277946 | 2 a | Ūkio-buities nuotekos - F1 75
1277999 | 2 a | Ūkio-buities nuotekos - F1 75
1278124 | 2 a | Ūkio-buities nuotekos - F1 75
1278197 | 2 a | Ūkio-buities nuotekos - F1 75
1278277 | 2 a | Ūkio-buities nuotekos - F1 75
1278414 | 2 a | Ūkio-buities nuotekos - F1 75
1278470 | 2 a | Ūkio-buities nuotekos - F1 75
1278476 | 2 a | Ūkio-buities nuotekos - F1 75
1278499 | 2 a | Ūkio-buities nuotekos - F1 76
1278546 | 2 a | Ūkio-buities nuotekos - F1 75
1278657 | 2 a | Ūkio-buities nuotekos - F1 77
1279297 | 2 a | Ūkio-buities nuotekos - F1 75
1279384 | 2 a | Ūkio-buities nuotekos - F1 75
1279446 | 2 a | Ūkio-buities nuotekos - F1 75
1279452 | 2 a | Ūkio-buities nuotekos - F1 75
1279673 | 2 a | Ūkio-buities nuotekos - F1 71
1279747 | 2 a | Ūkio-buities nuotekos - F1 71
1279753 | 2 a | Ūkio-buities nuotekos - F1 71
1281250 | 2 a | Lietaus nuotekos - L1 20
1281559 | 2 a | Lietaus nuotekos - L1 20
1282142 | 2 a | Lietaus nuotekos - L1 20
1282239 | 2 a | Lietaus nuotekos - L1 20
1282276 | 3 a | Lietaus nuotekos - L1 20
1282282 | 2 a | Lietaus nuotekos - L1 20
1282464 | 2 a | nuotekos ūkio-buities - F1 1
1282490 | 2 a | nuotekos ūkio-buities - F1 1
1282520 | 2 a | nuotekos ūkio-buities - F1 1
1282563 | 2 a | nuotekos ūkio-buities - F1 1
1282679 | 2 a | nuotekos ūkio-buities - F1 1
1282700 | 2 a | nuotekos ūkio-buities - F1 1
1283227 | 2 a | nuotekos ūkio-buities - F1 1
1283297 | 2 a | nuotekos ūkio-buities - F1 1
1283350 | 2 a | nuotekos ūkio-buities - F1 1
1283356 | 2 a | nuotekos ūkio-buities - F1 1
1283403 | 2 a | nuotekos ūkio-buities - F1 1
1283504 | 2 a | nuotekos ūkio-buities - F1 1
1283618 | 2 a | nuotekos ūkio-buities - F1 1
1283692 | 2 a | Ūkio-buities nuotekos - F1 75
1283769 | 2 a | Ūkio-buities nuotekos - F1 75
1283775 | 2 a | Ūkio-buities nuotekos - F1 75
1283816 | 2 a | Ūkio-buities nuotekos - F1 75
1283872 | 2 a | Ūkio-buities nuotekos - F1 75
1284079 | 2 a | Ūkio-buities nuotekos - F1 75
1284085 | 2 a | Ūkio-buities nuotekos - F1 75
1284156 | 2 a | nuotekos ūkio-buities - F1 1
1284170 | 2 a | nuotekos ūkio-buities - F1 1
1284239 | 2 a | nuotekos ūkio-buities - F1 1
1284278 | 2 a | nuotekos ūkio-buities - F1 1
1284384 | 2 a | nuotekos ūkio-buities - F1 1
1284675 | 2 a | nuotekos ūkio-buities - F1 1
1284831 | 2 a | nuotekos ūkio-buities - F1 1
1284883 | 2 a | nuotekos ūkio-buities - F1 1
1284891 | 2 a | nuotekos ūkio-buities - F1 1
1285292 | 2 a | nuotekos ūkio-buities - F1 1
1285417 | 2 a | nuotekos ūkio-buities - F1 1
1285457 | 2 a | nuotekos ūkio-buities - F1 1
1285679 | 2 a | nuotekos ūkio-buities - F1 1
1285718 | 2 a | nuotekos ūkio-buities - F1 1
1285799 | 2 a | nuotekos ūkio-buities - F1 2
1285862 | 2 a | nuotekos ūkio-buities - F1 1
1285887 | 2 a | nuotekos ūkio-buities - F1 3
1286039 | 2 a | nuotekos ūkio-buities - F1 4
1286065 | 2 a | nuotekos ūkio-buities - F1 4
1286085 | 2 a | nuotekos ūkio-buities - F1 4
1286128 | 2 a | nuotekos ūkio-buities - F1 4
1286154 | 2 a | nuotekos ūkio-buities - F1 4
1286174 | 2 a | nuotekos ūkio-buities - F1 4
1286378 | 2 a | nuotekos ūkio-buities - F1 4
1286444 | 1 a +-152.84 | nuotekos ūkio-buities - F1 4
1286738 | 2 a | nuotekos ūkio-buities - F1 4
1286839 | 2 a | nuotekos ūkio-buities - F1 4
1286845 | 2 a | nuotekos ūkio-buities - F1 4
1287006 | 2 a | nuotekos ūkio-buities - F1 4
1287014 | 2 a | nuotekos ūkio-buities - F1 4
1287235 | 2 a | nuotekos ūkio-buities - F1 4
1287274 | 2 a | nuotekos ūkio-buities - F1 4
1287282 | 2 a | nuotekos ūkio-buities - F1 4
1287431 | 2 a | nuotekos ūkio-buities - F1 4
1287439 | 2 a | nuotekos ūkio-buities - F1 4
1287504 | 2 a | nuotekos ūkio-buities - F1 4
1287518 | 2 a | nuotekos ūkio-buities - F1 4
1287807 | 2 a | nuotekos ūkio-buities - F1 4
1287813 | 2 a | nuotekos ūkio-buities - F1 4
1288040 | 2 a | nuotekos ūkio-buities - F1 4
1288081 | 2 a | nuotekos ūkio-buities - F1 4
1288226 | 2 a | nuotekos ūkio-buities - F1 4
1288304 | 2 a | nuotekos ūkio-buities - F1 4
1288310 | 2 a | nuotekos ūkio-buities - F1 4
1288830 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1288872 | 4 a V1 | Ūkio-buities nuotekos - F1 16
1288959 | 3 a | Ūkio-buities nuotekos - F1 16
1289837 | 3 a | Ūkio-buities nuotekos - F1 16
1289851 | 3 a | Ūkio-buities nuotekos - F1 16
1290150 | 3 a | Ūkio-buities nuotekos - F1 16
1290199 | 3 a | Ūkio-buities nuotekos - F1 16
1290251 | 2 a | Ūkio-buities nuotekos - F1 16
1291792 | 2 a | Ūkio-buities nuotekos - F1 16
1291872 | 2 a | Ūkio-buities nuotekos - F1 16
1291878 | 2 a | Ūkio-buities nuotekos - F1 16
1291958 | 2 a | Ūkio-buities nuotekos - F1 16
1292037 | 2 a | Ūkio-buities nuotekos - F1 16
1292043 | 2 a | Ūkio-buities nuotekos - F1 16
1292083 | 2 a | Ūkio-buities nuotekos - F1 16
1292248 | 2 a | Ūkio-buities nuotekos - F1 16
1292304 | 2 a | Ūkio-buities nuotekos - F1 16
1292455 | 2 a | Ūkio-buities nuotekos - F1 16
1292461 | 2 a | Ūkio-buities nuotekos - F1 16
1292533 | 2 a | Ūkio-buities nuotekos - F1 16
1292539 | 2 a | Ūkio-buities nuotekos - F1 16
1292701 | 2 a | Ūkio-buities nuotekos - F1 16
1292856 | 2 a | Ūkio-buities nuotekos - F1 16
1293057 | 2 a | Ūkio-buities nuotekos - F1 16
1293141 | 2 a | Ūkio-buities nuotekos - F1 16
1293149 | 2 a | Ūkio-buities nuotekos - F1 16
1293233 | 2 a | Ūkio-buities nuotekos - F1 16
1293270 | 2 a | Ūkio-buities nuotekos - F1 16
1293278 | 2 a | Ūkio-buities nuotekos - F1 16
1293353 | 2 a | Ūkio-buities nuotekos - F1 16
1293361 | 2 a | Ūkio-buities nuotekos - F1 16
1293410 | 2 a | Ūkio-buities nuotekos - F1 16
1293483 | 2 a | Ūkio-buities nuotekos - F1 16
1293858 | 2 a | Ūkio-buities nuotekos - F1 16
1293872 | 2 a | Ūkio-buities nuotekos - F1 16
1294142 | 2 a | Ūkio-buities nuotekos - F1 16
1294148 | 2 a | Ūkio-buities nuotekos - F1 16
1294304 | 2 a | Ūkio-buities nuotekos - F1 16
1294341 | 2 a | Ūkio-buities nuotekos - F1 16
1294556 | 2 a | Ūkio-buities nuotekos - F1 16
1294589 | 2 a | Ūkio-buities nuotekos - F1 16
1294595 | 2 a | Ūkio-buities nuotekos - F1 16
1294637 | 2 a | Ūkio-buities nuotekos - F1 16
1294782 | 2 a | Ūkio-buities nuotekos - F1 16
1294796 | 2 a | Ūkio-buities nuotekos - F1 16
1294910 | 2 a | Ūkio-buities nuotekos - F1 16
1294994 | 2 a | Ūkio-buities nuotekos - F1 16
1295039 | 2 a | Ūkio-buities nuotekos - F1 16
1295045 | 2 a | Ūkio-buities nuotekos - F1 16
1295569 | 2 a | Ūkio-buities nuotekos - F1 16
1295601 | 2 a | Ūkio-buities nuotekos - F1 16
1295613 | 2 a | Ūkio-buities nuotekos - F1 16
1295695 | 2 a | Ūkio-buities nuotekos - F1 16
1295764 | 2 a | Ūkio-buities nuotekos - F1 16
1295799 | 2 a | Ūkio-buities nuotekos - F1 16
1295842 | 2 a | Ūkio-buities nuotekos - F1 16
1295848 | 2 a | Ūkio-buities nuotekos - F1 16
1295901 | 2 a | Ūkio-buities nuotekos - F1 16
1295959 | 2 a | Ūkio-buities nuotekos - F1 16
1295967 | 2 a | Ūkio-buities nuotekos - F1 16
1296037 | 2 a | Ūkio-buities nuotekos - F1 16
1296076 | 2 a | Ūkio-buities nuotekos - F1 16
1296135 | 2 a | Ūkio-buities nuotekos - F1 16
1296270 | 2 a | Ūkio-buities nuotekos - F1 16
1296380 | 2 a | Ūkio-buities nuotekos - F1 16
1296427 | 2 a | Ūkio-buities nuotekos - F1 16
1296511 | 2 a | Ūkio-buities nuotekos - F1 16
1296517 | 2 a | Ūkio-buities nuotekos - F1 16
1296629 | 2 a | Ūkio-buities nuotekos - F1 16
1296670 | 2 a | Ūkio-buities nuotekos - F1 16
1296940 | 2 a | Ūkio-buities nuotekos - F1 16
1297015 | 2 a | Ūkio-buities nuotekos - F1 16
1297023 | 2 a | Ūkio-buities nuotekos - F1 16
1297102 | 2 a | Ūkio-buities nuotekos - F1 16
1297177 | 2 a | Ūkio-buities nuotekos - F1 16
1297183 | 2 a | Ūkio-buities nuotekos - F1 16
1297312 | 4 a V1 | Ūkio-buities nuotekos - F1 19
1297467 | 2 a | Ūkio-buities nuotekos - F1 19
1297553 | 2 a | Ūkio-buities nuotekos - F1 19
1297653 | 2 a | Ūkio-buities nuotekos - F1 19
1297838 | 2 a | Ūkio-buities nuotekos - F1 19
1297844 | 2 a | Ūkio-buities nuotekos - F1 19
1297953 | 2 a | Ūkio-buities nuotekos - F1 19
