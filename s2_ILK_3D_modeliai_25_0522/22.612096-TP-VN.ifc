Properties of the parts of a building model (IFC2X3), part 21 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1388202_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388200_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388206_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388224_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388234_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388273_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388234_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388235_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388235_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388303_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388238_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388277_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388271_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388273_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388271_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388277_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388293_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388303_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388293_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388351_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388303_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388304_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388304_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388379_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388307_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388355_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388307_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388349_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388351_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388349_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388371_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388514_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388371_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388389_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388379_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388380_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388379_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388515_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388383_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388389_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388383_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388484_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388391_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388488_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388391_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388482_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388484_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388482_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388488_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388504_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388514_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388504_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388549_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388514_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388518_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388553_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388547_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388549_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388547_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388553_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388569_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388585_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388569_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388597_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388585_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388586_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388586_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388589_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388597_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388589_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388634_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388599_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388638_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388599_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388634_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388638_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388660_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388672_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388660_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388715_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388672_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388673_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388673_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388836_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388676_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388719_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388713_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388715_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388814_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388931_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388814_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388848_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388836_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388836_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389090_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388837_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389277_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388840_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388850_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388840_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388900_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388848_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388850_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388854_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388904_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388854_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388898_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388900_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388898_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388919_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388931_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388919_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388976_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388931_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388932_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388932_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389006_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388935_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388980_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388935_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388974_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388976_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388974_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388980_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388996_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389006_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1388996_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389059_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389006_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389007_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389007_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389089_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389010_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389063_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389010_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389057_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389059_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389057_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389063_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389079_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389089_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389079_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389148_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389089_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389090_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389093_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389152_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389093_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389146_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389148_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389146_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389152_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389174_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389182_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389174_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389182_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389183_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389186_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389241_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389186_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389235_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389237_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389235_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389241_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389261_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389277_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389261_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389289_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389277_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389281_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389289_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389281_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389324_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389291_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389328_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389291_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389322_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389324_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389322_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389328_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389365_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389833_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389365_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389459_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389440_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389441_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389440_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390107_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389449_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389457_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389449_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389501_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389457_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389459_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389463_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389505_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389463_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389499_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389501_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389499_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389505_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389617_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389631_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389617_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389647_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389631_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389834_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389631_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389920_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389635_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389647_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389635_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389679_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389649_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389683_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389649_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389677_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389679_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389677_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389683_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389825_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389833_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389825_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389843_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389833_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389834_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389837_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389843_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389837_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389887_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389845_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389891_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389845_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389885_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389887_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389885_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389891_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389912_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389920_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389912_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389963_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389920_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389921_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389921_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389924_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389967_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389961_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389963_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389967_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389983_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389991_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389983_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390039_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389991_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389992_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389992_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390218_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389995_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390043_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1389995_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390037_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390039_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390037_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390043_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390098_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390106_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390098_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390116_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390106_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390219_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390106_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390107_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390110_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390116_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390110_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390118_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390126_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390118_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390175_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390128_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390179_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390128_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390173_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390175_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390179_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390210_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390218_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390210_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390228_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390218_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390219_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390222_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390228_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390238_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390230_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390332_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390230_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390260_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390602_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390240_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390262_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390240_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390298_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390260_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390266_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390302_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390266_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390296_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390298_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390296_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390320_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390332_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390320_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390344_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390332_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390333_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390333_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390336_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390344_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390336_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390346_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390352_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390346_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390396_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390354_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390400_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390354_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390394_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390396_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390394_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390400_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390424_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390434_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390485_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390434_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390435_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390435_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390517_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390438_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390489_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390438_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390483_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390485_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390483_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390505_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390517_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390505_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390571_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390517_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390518_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390518_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390601_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390521_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390575_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390521_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390569_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390571_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390569_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390575_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390591_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390601_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390591_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390601_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390602_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390605_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390613_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390605_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390668_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390615_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390672_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390666_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390668_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390666_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390716_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390716_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392102_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390717_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390787_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390787_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390788_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390787_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390910_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390812_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390909_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390812_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390828_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390820_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390828_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390820_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390882_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390830_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390886_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390830_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390880_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390882_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390880_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390886_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390901_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390909_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390901_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390957_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390909_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390910_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390913_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390961_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390913_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390955_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390957_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390955_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390979_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391923_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390979_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391003_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390991_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391290_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1390991_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391093_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391001_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391003_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391001_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391711_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391007_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391093_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391007_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391103_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391097_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391103_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391097_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391113_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391105_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391113_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391105_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391169_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391115_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391173_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391167_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391169_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391167_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391173_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391202_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391212_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391224_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391212_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391291_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391212_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391213_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391213_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391454_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391216_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391224_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391216_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391258_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391226_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391262_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391226_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391256_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391258_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391256_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391262_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391278_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391384_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391278_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391302_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391290_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391291_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391290_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391385_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391294_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391302_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391294_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391356_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391304_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391360_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391304_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391354_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391356_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391354_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391376_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391384_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391376_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391424_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391384_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391385_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391388_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391428_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391388_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391422_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391424_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391422_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391444_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391454_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391444_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391491_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391454_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391526_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391458_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391495_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391458_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391489_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391491_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391489_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391495_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391511_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391628_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391511_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391596_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391526_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391576_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391576_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391577_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391576_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391629_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391577_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391710_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391581_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391600_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391581_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391594_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391596_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391594_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391618_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391628_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391618_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391638_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391628_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391629_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391632_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391638_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391632_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391672_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391640_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391676_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391640_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391670_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391672_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391670_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391676_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391692_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391813_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391692_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391722_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391710_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391711_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391710_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391814_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391714_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391722_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391714_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391766_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391724_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391770_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391724_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391764_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391766_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391764_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391770_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391805_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391813_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391805_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391859_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391813_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391814_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391817_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391863_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391817_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391857_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391859_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391857_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391863_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391911_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391992_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391911_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391966_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391923_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391924_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391923_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391993_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391924_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392101_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391927_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391968_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391927_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391964_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391966_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391964_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391968_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391984_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391992_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391984_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392064_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391992_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391993_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391996_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392068_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1391996_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392062_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392064_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392062_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392068_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392089_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392101_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392089_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392146_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392101_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392102_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392105_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392150_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392105_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392144_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392146_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392144_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392150_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392238_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392239_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392238_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392587_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392239_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392320_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392287_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392320_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392287_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392355_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392320_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392321_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392347_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392355_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392347_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392365_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392357_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392961_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392357_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392843_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392365_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392747_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392587_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392603_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392595_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444728_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392595_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392611_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392603_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1444729_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392605_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392611_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392605_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392654_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392613_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392656_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392613_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392654_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392656_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392660_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392717_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392660_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392711_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392713_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392711_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392717_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392736_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393088_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392736_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392759_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393115_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392746_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392747_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392746_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393049_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392750_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392761_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392750_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392809_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392759_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392761_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392765_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392813_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392765_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392807_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392809_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392807_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392813_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392831_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392845_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392831_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392874_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392843_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392845_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392849_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392878_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392849_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392872_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392874_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392872_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392878_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392953_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392961_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392953_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393018_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392961_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392962_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392962_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393114_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392965_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393022_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1392965_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393016_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393018_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393016_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393022_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393038_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393098_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393038_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393060_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393049_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393098_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393052_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393060_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393074_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393062_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393088_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393062_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393074_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393106_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393114_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393106_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393124_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393114_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393115_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393118_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393124_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393118_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393134_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393126_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393126_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393145_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393134_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393234_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393136_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393145_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393136_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393202_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393147_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393206_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393147_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393200_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393202_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393200_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393206_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393223_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393233_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393223_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393270_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393233_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393234_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393237_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393274_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393237_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393268_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393270_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393268_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393274_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393299_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395524_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393299_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395083_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393345_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393361_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393345_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393397_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393362_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393361_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395063_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393389_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393397_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393389_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393405_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393405_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394947_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393904_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394221_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393904_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394052_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393922_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394052_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1393922_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394068_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394056_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394068_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394056_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394082_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394070_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394082_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394070_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394104_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394084_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394106_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394084_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394116_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394104_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394106_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394110_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394116_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394110_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394171_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394118_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394175_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394118_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394169_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394171_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394169_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394175_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394213_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394221_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394213_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394231_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394221_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394222_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394222_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394317_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394225_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394231_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394225_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394241_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394233_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394241_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394233_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394249_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394243_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394249_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394243_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394289_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394251_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394293_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394251_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394287_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394289_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394287_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394293_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394309_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394317_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394309_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394354_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394317_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394318_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394318_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394321_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394358_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394321_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394352_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394354_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394358_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394374_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394382_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394374_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394392_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394382_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394383_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394383_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394458_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394386_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394392_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394386_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394430_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394394_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394434_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394394_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394428_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394430_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394428_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394434_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394450_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394458_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394450_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394504_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394458_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394459_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394459_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394532_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394462_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394508_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394462_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394502_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394504_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394502_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394508_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394524_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394532_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394524_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394542_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394532_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394533_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394533_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394605_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394536_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394542_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394575_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394544_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394579_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394544_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394573_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394575_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394573_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394579_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394597_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394605_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394597_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394646_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394605_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394606_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394674_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394609_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394650_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394609_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394644_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394646_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394644_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394650_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394666_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394674_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394666_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394715_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394674_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394675_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394675_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394779_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394678_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394719_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394678_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394713_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394715_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394713_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394719_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394771_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394779_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394771_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394818_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394779_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394780_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394780_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394869_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394783_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394822_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394783_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394816_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394818_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394816_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394822_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394861_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394869_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394861_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394879_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394869_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394870_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394870_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394946_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394873_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394879_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394873_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394918_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394881_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394922_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394881_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394916_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394918_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394916_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394922_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394938_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394946_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394938_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394956_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394946_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394947_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394950_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394956_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394950_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395029_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394958_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395033_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1394958_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395027_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395029_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395027_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395033_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395062_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395063_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395062_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395525_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395071_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395081_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395071_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395093_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395081_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395083_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395087_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395360_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395087_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395103_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395093_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395361_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395095_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395105_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395095_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395164_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395103_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395105_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395109_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395168_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395109_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395162_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395164_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395162_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395168_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395352_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395360_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395352_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395370_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395360_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395361_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395364_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395370_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395364_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395380_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395372_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395380_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395372_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395429_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395382_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395433_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395382_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395427_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395429_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395427_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395433_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395516_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395524_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395516_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395534_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395524_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395525_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395528_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395615_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395528_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395544_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395534_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395616_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395536_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395544_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395536_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395588_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395546_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395592_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395546_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395586_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395588_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395586_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395592_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395607_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395615_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395607_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395653_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395615_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1395616_1 | SOURCEANDSINK | vanduo šaltas - V1 2
