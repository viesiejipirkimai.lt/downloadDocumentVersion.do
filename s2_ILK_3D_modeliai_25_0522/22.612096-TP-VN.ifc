Properties of the parts of a building model (IFC2X3), part 25 of 57

# IfcDistributionPort (38115)
Name | FlowDirection | Group
Port_1425467_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425468_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425468_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425491_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425483_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425491_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425483_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425491_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425492_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425492_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425515_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425507_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425515_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425507_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425525_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425515_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425516_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425519_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425525_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425519_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425541_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425557_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425541_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425569_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425557_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425558_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425561_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425569_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425561_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425584_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425596_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425584_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425606_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425596_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425597_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425600_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425606_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425600_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425637_0 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1425655_2 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1425637_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1425657_1 | SOURCEANDSINK | vanduo šaltas - V1 1
Port_1425694_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425708_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425694_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425720_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425708_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425709_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425712_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425720_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425712_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425737_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425745_3 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425737_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425757_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425745_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425746_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425749_0 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425757_2 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425749_1 | SOURCEANDSINK | vanduo šaltas - V1 2
Port_1425775_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425775_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425790_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425784_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425790_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425784_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425936_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425866_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425936_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425866_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425880_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425874_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426770_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425874_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425890_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425880_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426771_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425890_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1425936_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426026_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426026_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426042_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426034_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426042_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426034_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426065_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426065_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446575_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426302_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439287_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426302_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426384_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426376_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426384_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426376_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426505_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426505_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426552_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426552_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451189_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426560_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1457108_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426560_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451423_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426652_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426879_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426652_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432499_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426660_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439288_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426660_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426661_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426660_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427882_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426661_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1449477_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426704_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1435139_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426704_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426722_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426713_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441259_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426713_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426743_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426716_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1448918_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426716_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426717_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426716_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1445010_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426717_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1446574_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426722_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434427_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426722_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426723_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426723_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1441805_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426735_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426743_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426735_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426751_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426745_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426751_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426778_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426755_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426774_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426755_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426778_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426768_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426770_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426768_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426770_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426771_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426879_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1451589_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426879_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439166_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426913_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1439132_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426913_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427136_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1426996_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427077_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1426996_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427031_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427004_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427004_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427077_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427023_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427031_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427023_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427039_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427039_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427041_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427041_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 2
Port_1427129_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427135_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427129_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427166_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427135_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427135_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427136_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427166_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427718_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427718_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427734_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427728_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427734_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427728_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427746_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427746_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428640_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427760_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427760_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431383_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427762_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427772_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427762_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427810_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427772_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431554_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427802_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427810_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427802_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427839_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427839_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427862_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427862_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427889_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427870_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427885_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427870_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427889_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427879_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427881_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427879_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427885_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427881_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1453401_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427881_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427882_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427896_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428066_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427896_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427995_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427980_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431191_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1427987_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427995_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427987_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428034_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427997_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428038_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1427997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428032_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428034_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428032_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428038_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428054_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428066_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428054_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428148_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428066_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428067_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428639_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428067_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428070_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428152_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428070_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428146_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428148_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428146_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428152_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 3
Port_1428207_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428639_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428207_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428502_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428488_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428502_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428488_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428502_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428700_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428639_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428640_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428689_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428699_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428689_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428769_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428699_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428808_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428699_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428700_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428707_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428773_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428707_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428767_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428769_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428767_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428773_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428791_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428807_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428791_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428823_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428807_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428956_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428807_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428808_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428815_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428823_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428906_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428825_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428910_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428825_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428904_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428906_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428904_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428910_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428937_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428955_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428937_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428974_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428955_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429253_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428955_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428956_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428963_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428974_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428963_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429050_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428976_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429054_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1428976_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429048_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429050_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429048_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429054_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429236_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429362_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429268_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429252_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429480_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429252_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429253_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429252_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429363_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429260_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429268_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429260_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429334_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429270_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429338_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429270_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429332_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429334_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429332_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429338_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429354_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429362_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429354_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429444_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429362_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429363_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429366_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429448_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429366_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429442_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429444_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429442_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429448_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429471_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429479_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429471_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429557_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429479_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429654_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429479_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429480_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429487_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429561_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429487_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429555_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429557_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429555_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429561_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429591_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429653_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429591_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429667_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429653_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429738_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429653_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429654_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429669_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429669_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429701_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429679_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429701_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429679_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429713_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429703_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429713_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429703_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429727_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429737_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429727_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429811_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429737_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429850_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429737_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429738_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429745_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429815_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429745_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429809_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429811_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429809_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429815_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429833_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429849_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429833_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429865_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429849_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429981_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429849_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429850_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429857_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429865_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429857_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429942_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429867_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429946_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429867_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429940_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429942_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429940_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429946_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429968_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429980_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429968_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430071_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429980_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430114_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429980_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429981_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429988_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430075_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1429988_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430069_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430071_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430069_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430075_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430091_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430582_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430129_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430113_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430691_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430113_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430114_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430113_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430583_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430121_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430491_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430121_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430137_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430129_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430492_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430131_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430137_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430131_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430236_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430223_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430240_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430223_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430234_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430236_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430234_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430240_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430479_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430491_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430479_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430491_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430492_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430574_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430582_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430574_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430592_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430582_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430583_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430586_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430592_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430586_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430644_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430594_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430648_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430594_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430642_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430644_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430642_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430648_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430672_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430690_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430672_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430706_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430690_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431132_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430690_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430691_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430698_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430997_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430698_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430717_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430706_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430998_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430708_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430717_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430708_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430770_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430719_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430774_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430719_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430768_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430770_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430768_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430774_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430991_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430997_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430991_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431087_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430997_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1430998_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431001_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431091_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431001_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431085_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431087_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431085_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431091_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431115_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431131_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431115_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431143_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431131_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431192_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431131_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431132_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431135_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431143_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431135_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431151_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431145_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431151_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431145_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431171_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431191_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431171_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431243_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431191_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431192_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431235_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431243_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431235_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431354_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431245_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431358_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431245_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431352_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431354_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431352_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431358_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431374_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431382_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431374_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431396_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431382_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431648_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431382_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431383_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431390_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431396_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431390_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431467_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431398_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431469_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431398_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431465_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431467_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431465_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431469_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431554_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431647_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431647_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431648_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431647_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1431668_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431676_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431668_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431731_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431676_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431678_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431735_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431678_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431729_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431731_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431729_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431735_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 4
Port_1431959_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1431959_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432043_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432029_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432043_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432029_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432171_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432045_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432171_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432045_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432071_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432065_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432274_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432065_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432087_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432071_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432275_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432087_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432171_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432199_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432199_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432274_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432275_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432274_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432373_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432373_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432403_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432381_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432403_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432381_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432415_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432407_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432415_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432407_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432435_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432435_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467004_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432499_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1437997_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432499_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438956_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432510_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1438955_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432510_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432530_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432522_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432530_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432542_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432532_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432542_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432532_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432925_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432630_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432682_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432630_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432646_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432638_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432646_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432638_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432654_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432648_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432654_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432648_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433006_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432672_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452933_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432672_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432794_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432682_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432683_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432682_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432866_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432683_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1438855_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432718_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1445047_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432718_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432736_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432727_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448277_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432727_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432730_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1465484_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432730_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432731_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432730_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1436352_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432731_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1467003_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432736_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1448278_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432736_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432737_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432737_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449821_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432794_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1449822_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432794_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434004_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432805_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434003_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432805_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432835_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432825_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432835_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432825_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434045_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432849_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432865_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432849_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433119_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432865_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1452934_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432865_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432866_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1432907_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1492088_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432907_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432923_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432925_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1432923_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1461815_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
InPort_1432967_0 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1492119_2 | SOURCE | vanduo karštas apytakinis - T4 1
InPort_1492100_2 | SINK | vanduo karštas apytakinis - T4 1
OutPort_1432967_1 | SOURCE | vanduo karštas apytakinis - T4 1
Port_1433004_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433006_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433004_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1464666_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433068_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433119_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433068_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433194_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433176_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433742_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433176_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433677_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433192_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433194_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433192_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433675_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433332_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433342_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433332_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433579_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433342_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433677_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433571_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433579_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433571_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433626_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433618_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433626_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433618_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433634_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433628_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433634_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433628_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433675_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433743_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433717_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433742_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433717_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433776_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433742_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433743_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433746_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433776_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433746_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433790_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433778_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433790_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433778_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433798_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433792_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433798_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433792_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433810_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433810_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433812_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433812_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433826_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433820_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433826_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433820_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433840_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433828_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433840_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433828_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434011_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433889_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434011_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1433889_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434015_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434001_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434003_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434001_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434015_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434003_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434004_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434045_2 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434121_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434121_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451291_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434146_0 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1451291_3 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434146_1 | SOURCEANDSINK | vanduo karštas apytakinis - T4 1
Port_1434189_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434343_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434189_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434237_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434225_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1463533_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434225_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434226_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434225_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434943_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434226_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434426_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434231_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434237_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434231_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434312_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434297_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434316_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434297_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434310_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434312_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434310_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434316_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434335_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434343_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434335_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434391_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434343_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434344_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434344_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434942_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434347_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434395_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434347_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434389_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434391_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434389_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434395_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434416_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434521_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434416_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434438_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434426_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434427_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434426_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434836_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434432_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434438_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434432_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434448_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434440_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434448_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434440_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434491_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434450_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434495_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434450_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434489_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434491_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434489_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434495_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434511_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434521_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434511_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434579_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434521_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434522_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434522_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434609_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434525_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434583_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434525_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434577_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434579_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434577_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434583_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434601_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434609_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434601_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434669_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434609_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434610_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434610_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434722_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434613_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434673_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434613_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434667_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434669_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434667_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434673_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434714_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434722_3 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434714_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434734_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434722_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434723_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434723_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434835_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434726_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434734_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434726_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434795_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434736_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434799_2 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434736_1 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
Port_1434793_0 | SOURCEANDSINK | vanduo karštas tiekiamasis - T3 1
