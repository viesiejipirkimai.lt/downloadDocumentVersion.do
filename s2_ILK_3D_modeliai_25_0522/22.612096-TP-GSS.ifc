Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcDistributionControlElement: GSS_IO_modulis:IO modulis 4/4 (124)
Name (GSS_IO_modulis:IO modulis 4/4:...) | In
2021113 | 4 aukštas
2021229 | 4 aukštas
2021264 | 4 aukštas
2021325 | 4 aukštas
2021422 | 4 aukštas
2021530 | 4 aukštas
2021573 | 4 aukštas
2021635 | 4 aukštas
2021660 | 4 aukštas
2021705 | 4 aukštas
2021971 | 3 aukštas
2022030 | 3 aukštas
2022079 | 4 aukštas
2022119 | 4 aukštas
2022159 | 4 aukštas
2022199 | 4 aukštas
2022257 | 4 aukštas
2022302 | 4 aukštas
2022350 | 4 aukštas
2022393 | 4 aukštas
2022451 | 4 aukštas
2022512 | 4 aukštas
2022555 | 4 aukštas
2022598 | 4 aukštas
2022641 | 4 aukštas
2022702 | 4 aukštas
2022781 | 4 aukštas
2022842 | 4 aukštas
2022885 | 4 aukštas
2022928 | 4 aukštas
2022963 | 4 aukštas
2023016 | 4 aukštas
2023059 | 4 aukštas
2023102 | 4 aukštas
2023163 | 4 aukštas
2023215 | 4 aukštas
2023243 | 4 aukštas
2023295 | 4 aukštas
2023347 | 4 aukštas
2023399 | 4 aukštas
2023483 | 5 aukštas
2025080 | Rūsys
2025210 | Rūsys
2025264 | Rūsys
2025361 | Rūsys
2025408 | Rūsys
2029790 | 5 aukštas
2029798 | 5 aukštas

# IfcDistributionControlElement: GSS_Irenginiai:10_Maitinimo šaltinis (3)
Type - Material: White
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: 10_Maitinimo šaltinis
Name (GSS_Irenginiai:10_Maitinimo šaltinis:...) | In
1470388 | Rūsys
1476778 | 1 aukštas
1482783 | 1 aukštas

# IfcDistributionControlElement: GSS_Irenginiai:Konvekcinių detektorių kontrolės modulis (3)
Type - Material: White
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: Konvekcinių detektorių kontrolės modulis
Name (GSS_Irenginiai:Konvekcinių detektorių kontrolės modulis:...) | In
1470542 | Rūsys
1476779 | 1 aukštas
1482784 | 1 aukštas

# IfcDistributionControlElement: GSS_Irenginiai:Linijinių detektorių valdiklis (3)
Type - Material: White
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: Linijinių detektorių valdiklis
Name (GSS_Irenginiai:Linijinių detektorių valdiklis:...) | In
1470643 | Rūsys
1476780 | 1 aukštas
1482785 | 1 aukštas

# IfcDistributionControlElement: GSS_Sirena:Lauko sirena, GSS_Sirena:Lauko sirena:1490574
In: 2 aukštas
Type - Material: Red
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: Lauko sirena

# IfcDistributionControlElement: GSS_Sirena:Vidinė sirena (83)
Type - Material: Red
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: Vidinė sirena
Name (GSS_Sirena:Vidinė sirena:...) | In
1324711 | Rūsys
1324993 | Rūsys
1325016 | Rūsys
1325070 | Rūsys
1325268 | Rūsys
1325449 | Rūsys
1325528 | Rūsys
1325618 | Rūsys
1325707 | 1 aukštas
1326119 | 1 aukštas
1326171 | 1 aukštas
1326207 | 1 aukštas
1326281 | 1 aukštas
1326358 | 1 aukštas
1326502 | 1 aukštas
1326545 | 1 aukštas
1326658 | 1 aukštas
1326955 | 2 aukštas
1327519 | 2 aukštas
1327701 | 2 aukštas
1327711 | 2 aukštas
1327769 | 2 aukštas
1327844 | 2 aukštas
1327894 | 2 aukštas
1327908 | 2 aukštas
1327991 | 2 aukštas
1328040 | 2 aukštas
1328124 | 2 aukštas
1328217 | 2 aukštas
1328251 | 2 aukštas
1328263 | 2 aukštas
1328281 | 2 aukštas
1328295 | 2 aukštas
1328347 | 2 aukštas
1328391 | 2 aukštas
1328471 | 3 aukštas
1328775 | 3 aukštas
1328842 | 3 aukštas
1328886 | 3 aukštas
1328937 | 3 aukštas
1329010 | 3 aukštas
1329020 | 3 aukštas
1329090 | 3 aukštas
1329108 | 3 aukštas
1329178 | 4 aukštas
1329368 | 4 aukštas
1329393 | 4 aukštas
1329445 | 4 aukštas
1329540 | 4 aukštas
1329548 | 4 aukštas
1329629 | 4 aukštas
1329641 | 4 aukštas
1329651 | 4 aukštas
1329765 | 4 aukštas
1329773 | 4 aukštas
1329781 | 4 aukštas
1329799 | 4 aukštas
1329852 | 4 aukštas
1329896 | 4 aukštas
1329943 | 4 aukštas
1329951 | 4 aukštas
1329961 | 4 aukštas
1329969 | 4 aukštas
1330070 | 4 aukštas
1330088 | 4 aukštas
1330098 | 4 aukštas
1330110 | 4 aukštas
1330120 | 4 aukštas
1330162 | 4 aukštas
1330174 | 4 aukštas
1330206 | 4 aukštas
1330220 | 4 aukštas
1330230 | 4 aukštas
1331858 | 5 aukštas
1332223 | 5 aukštas
1332258 | 5 aukštas
1332363 | 5 aukštas
1332426 | 5 aukštas
1552182 | 1 aukštas
1552288 | 4 aukštas
1552352 | 4 aukštas
1552413 | 4 aukštas
1552847 | 5 aukštas

# IfcDistributionPort (2119)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_1299920
Port_1300149
Port_1300661
Port_1300662
Port_1300748
Port_1300749
Port_1300757
Port_1300758
Port_1300850
Port_1300851
Port_1300860
Port_1300861
Port_1300904
Port_1300905
Port_1301049
Port_1301050
Port_1301077
Port_1301078
Port_1301104
Port_1301105
Port_1301131
Port_1301132
Port_1301156
Port_1301157
Port_1301213
Port_1301214
Port_1301247
Port_1301248
Port_1301300
Port_1301301
Port_1301326
Port_1301327
Port_1301364
Port_1301365
Port_1301405
Port_1301406
Port_1301434
Port_1301435
Port_1301456
Port_1301457
Port_1301485
Port_1301486
Port_1301526
Port_1301527
Port_1301563
Port_1301564
Port_1301574
Port_1301575
Port_1301619
Port_1301620
Port_1301646
Port_1301647
Port_1301684
Port_1301685
Port_1301707
Port_1301708
Port_1301748
Port_1301749
Port_1301784
Port_1301785
Port_1302373
Port_1302374
Port_1302386
Port_1302387
Port_1302408
Port_1302409
Port_1302429
Port_1302430
Port_1302440
Port_1302441
Port_1302586
Port_1302587
Port_1302603
Port_1302604
Port_1302612
Port_1302613
Port_1302623
Port_1302624
Port_1302632
Port_1302633
Port_1302643
Port_1302644
Port_1302654
Port_1302655
Port_1302708
Port_1302709
Port_1302719
Port_1302720
Port_1302730
Port_1302731
Port_1302743
Port_1302744
Port_1302754
Port_1302755
Port_1302826
Port_1302827
Port_1303585
Port_1304086
Port_1304244
Port_1304314
Port_1304523
Port_1304623
Port_1304738
Port_1304812
Port_1304876
Port_1304927
Port_1304937
Port_1304945
Port_1304953
Port_1304961
Port_1304969
Port_1304979
Port_1304987
Port_1304995
Port_1305003
Port_1305096
Port_1305106
Port_1305122
Port_1305130
Port_1305172
Port_1305180
Port_1305230
Port_1305238
Port_1305334
Port_1305649
Port_1305657
Port_1305665
Port_1305721
Port_1305801
Port_1305809
Port_1305907
Port_1305943
Port_1306067
Port_1306799
Port_1307418
Port_1307419
Port_1307441
Port_1307442
Port_1307450
Port_1307451
Port_1307461
Port_1307462
Port_1307610
Port_1307611
Port_1307621
Port_1307622
Port_1307636
Port_1307637
Port_1307676
Port_1307677
Port_1307687
Port_1307688
Port_1307696
Port_1307697
Port_1307705
Port_1307706
Port_1307714
Port_1307715
Port_1307725
Port_1307726
Port_1307734
Port_1307735
Port_1307749
Port_1307750
Port_1307775
Port_1307776
Port_1307904
Port_1307905
Port_1307937
Port_1307938
Port_1308060
Port_1308061
Port_1308285
Port_1308286
Port_1308391
Port_1308640
Port_1308641
Port_1308671
Port_1308672
Port_1308701
Port_1308702
Port_1308712
Port_1308713
Port_1308721
Port_1308722
Port_1308736
Port_1308737
Port_1308758
Port_1308759
Port_1308767
Port_1308768
Port_1308778
Port_1308779
Port_1308791
Port_1308792
Port_1308812
Port_1308813
Port_1308823
Port_1308824
Port_1308868
Port_1308869
Port_1308883
Port_1308884
Port_1308892
Port_1308893
Port_1308955
Port_1308956
Port_1308984
Port_1308985
Port_1309017
Port_1309018
Port_1309026
Port_1309027
Port_1309035
Port_1309036
Port_1309080
Port_1309081
Port_1309089
Port_1309090
Port_1309098
Port_1309099
Port_1309107
Port_1309108
Port_1309116
Port_1309117
Port_1309125
Port_1309126
Port_1309134
Port_1309135
Port_1309143
Port_1309144
Port_1309156
Port_1309157
Port_1309165
Port_1309166
Port_1309174
Port_1309175
Port_1309187
Port_1309188
Port_1309198
Port_1309199
Port_1309209
Port_1309210
Port_1309218
Port_1309219
Port_1309229
Port_1309230
Port_1309238
Port_1309239
Port_1309247
Port_1309248
Port_1309256
Port_1309257
Port_1309265
Port_1309266
Port_1309276
Port_1309277
Port_1309285
Port_1309286
Port_1309294
Port_1309295
Port_1309303
Port_1309304
Port_1309312
Port_1309313
Port_1309323
Port_1309324
Port_1309332
Port_1309333
Port_1309341
Port_1309342
Port_1309350
Port_1309351
Port_1309399
Port_1309400
Port_1309410
Port_1309411
Port_1309419
Port_1309420
Port_1309475
Port_1309476
Port_1309517
Port_1309518
Port_1309526
Port_1309527
Port_1309541
Port_1309542
Port_1309550
Port_1309551
Port_1309559
Port_1309560
Port_1309568
Port_1309569
Port_1309577
Port_1309578
Port_1309586
Port_1309587
Port_1309595
Port_1309596
Port_1309606
Port_1309607
Port_1309615
Port_1309616
Port_1309630
Port_1309631
Port_1309639
Port_1309640
Port_1309650
Port_1309651
Port_1309661
Port_1309662
Port_1309672
Port_1309673
Port_1309681
Port_1309682
Port_1309694
Port_1309695
Port_1309703
Port_1309704
Port_1309722
Port_1309723
Port_1309748
Port_1309749
Port_1309771
Port_1309772
Port_1309786
Port_1309787
Port_1309812
Port_1309813
Port_1309860
Port_1309861
Port_1309869
Port_1309870
Port_1309880
Port_1309881
Port_1309889
Port_1309890
Port_1309900
Port_1309901
Port_1309907
Port_1309908
Port_1309920
Port_1309921
Port_1309929
Port_1309930
Port_1309938
Port_1309939
Port_1309947
Port_1309948
Port_1309956
Port_1309957
Port_1309969
Port_1309970
Port_1309978
Port_1309979
Port_1309989
Port_1309990
Port_1309998
Port_1309999
Port_1310046
Port_1310047
Port_1310055
Port_1310056
Port_1310064
Port_1310065
Port_1310075
Port_1310076
Port_1310117
Port_1310118
Port_1310126
Port_1310127
Port_1310139
Port_1310140
Port_1310150
Port_1310151
Port_1310159
Port_1310160
Port_1310174
Port_1310175
Port_1310183
Port_1310184
Port_1310194
Port_1310195
Port_1310209
Port_1310210
Port_1310218
Port_1310219
Port_1310251
Port_1310252
Port_1310272
Port_1310273
Port_1310291
Port_1310292
Port_1310300
Port_1310301
Port_1310334
Port_1310335
Port_1310343
Port_1310344
Port_1310352
Port_1310353
Port_1310363
Port_1310364
Port_1310372
Port_1310373
Port_1310389
Port_1310390
Port_1310400
Port_1310401
Port_1310427
Port_1310428
Port_1310469
Port_1310470
Port_1310480
Port_1310481
Port_1310489
Port_1310490
Port_1310504
Port_1310505
Port_1310530
Port_1310531
Port_1310539
Port_1310540
Port_1310550
Port_1310551
Port_1310586
Port_1310587
Port_1310611
Port_1310612
Port_1310634
Port_1310635
Port_1310645
Port_1310646
Port_1310656
Port_1310657
Port_1310665
Port_1310666
Port_1310688
Port_1310689
Port_1310699
Port_1310700
Port_1310708
Port_1310709
Port_1310729
Port_1310730
Port_1310744
Port_1310745
Port_1310753
Port_1310754
Port_1310762
Port_1310763
Port_1310771
Port_1310772
Port_1310780
Port_1310781
Port_1310789
Port_1310790
Port_1310819
Port_1310820
Port_1310856
Port_1310857
Port_1310875
Port_1310876
Port_1310886
Port_1310901
Port_1310902
Port_1310916
Port_1310917
Port_1310929
Port_1310930
Port_1310950
Port_1310951
Port_1310961
Port_1310962
Port_1310972
Port_1310973
Port_1310981
Port_1310982
Port_1310994
Port_1310995
Port_1311988
Port_1312160
Port_1312447
Port_1312448
Port_1312458
Port_1312459
Port_1312487
Port_1312488
Port_1312513
Port_1312514
Port_1312554
Port_1312603
Port_1312604
Port_1312616
Port_1312617
Port_1312631
Port_1312632
Port_1312640
Port_1312641
Port_1312675
Port_1312676
Port_1312684
Port_1312685
Port_1312695
Port_1312696
Port_1312714
Port_1312715
Port_1314348
Port_1314349
Port_1314359
Port_1314360
Port_1314370
Port_1314371
Port_1314383
Port_1314384
Port_1314398
Port_1314399
Port_1314440
Port_1314441
Port_1314466
Port_1314467
Port_1314475
Port_1314476
Port_1314488
Port_1314489
Port_1314499
Port_1314500
Port_1314526
Port_1314527
Port_1314616
Port_1314626
Port_1314627
Port_1314637
Port_1314638
Port_1314648
Port_1314649
Port_1314663
Port_1314664
Port_1314672
Port_1314673
Port_1314724
Port_1314725
Port_1314757
Port_1314758
Port_1314852
Port_1314853
Port_1314899
Port_1314900
Port_1314952
Port_1314953
Port_1314995
Port_1314996
Port_1315004
Port_1315005
Port_1315021
Port_1315022
Port_1315032
Port_1315033
Port_1315043
Port_1315044
Port_1315065
Port_1315066
Port_1315074
Port_1315075
Port_1315091
Port_1315092
Port_1315104
Port_1315105
Port_1315153
Port_1315154
Port_1315166
Port_1315167
Port_1315177
Port_1315178
Port_1315190
Port_1315191
Port_1315201
Port_1315202
Port_1315210
Port_1315211
Port_1315225
Port_1315226
Port_1315288
Port_1315289
Port_1315352
Port_1315353
Port_1315377
Port_1315378
Port_1315388
Port_1315389
Port_1315408
Port_1315409
Port_1315419
Port_1315420
Port_1315593
Port_1315594
Port_1315608
Port_1315609
Port_1315617
Port_1315618
Port_1315630
Port_1315631
Port_1315746
Port_1315747
Port_1315755
Port_1315756
Port_1315764
Port_1315765
Port_1315773
Port_1315774
Port_1315784
Port_1315785
Port_1315793
Port_1315794
Port_1315802
Port_1315803
Port_1315811
Port_1315812
Port_1315820
Port_1315821
Port_1315829
Port_1315830
Port_1315842
Port_1315843
Port_1315855
Port_1315856
Port_1315868
Port_1315869
Port_1315881
Port_1315882
Port_1315890
Port_1315891
Port_1315899
Port_1315900
Port_1315940
Port_1315941
Port_1316020
Port_1316021
Port_1316031
Port_1316032
Port_1316040
Port_1316041
Port_1316068
Port_1316069
Port_1316094
Port_1316095
Port_1316107
Port_1316108
Port_1316143
Port_1316144
Port_1316152
Port_1316153
Port_1316161
Port_1316162
Port_1316172
Port_1316173
Port_1316261
Port_1316262
Port_1316289
Port_1316290
Port_1316326
Port_1316327
Port_1316606
Port_1316614
Port_1316775
Port_1316897
Port_1317192
Port_1317193
Port_1317227
Port_1317228
Port_1317248
Port_1317249
Port_1319220
Port_1319221
Port_1319233
Port_1319234
Port_1319280
Port_1319281
Port_1319282
Port_1319283
Port_1319344
Port_1319345
Port_1319373
Port_1319374
Port_1319384
Port_1319385
Port_1319518
Port_1319519
Port_1319654
Port_1319729
Port_1319730
Port_1319768
Port_1319769
Port_1319779
Port_1319780
Port_1319790
Port_1319791
Port_1319801
Port_1319802
Port_1319812
Port_1319813
Port_1319821
Port_1319822
Port_1319832
Port_1319833
Port_1319845
Port_1319846
Port_1319894
Port_1319895
Port_1319909
Port_1319910
Port_1319940
Port_1319941
Port_1319949
Port_1319950
Port_1319958
Port_1319959
Port_1319969
Port_1319970
Port_1319978
Port_1319979
Port_1320027
Port_1320028
Port_1320036
Port_1320037
Port_1320045
Port_1320046
Port_1320056
Port_1320057
Port_1320065
Port_1320066
Port_1320113
Port_1320114
Port_1320180
Port_1320181
Port_1320230
Port_1320231
Port_1320243
Port_1320244
Port_1320252
Port_1320253
Port_1320261
Port_1320262
Port_1320270
Port_1320271
Port_1320281
Port_1320282
Port_1320290
Port_1320291
Port_1320301
Port_1320302
Port_1320310
Port_1320311
Port_1320319
Port_1320320
Port_1320328
Port_1320329
Port_1320549
Port_1320550
Port_1320564
Port_1320565
Port_1320588
Port_1320589
Port_1320619
Port_1320620
Port_1320678
Port_1320679
Port_1320687
Port_1320688
Port_1320696
Port_1320697
Port_1320705
Port_1320706
Port_1320714
Port_1320715
Port_1320723
Port_1320724
Port_1320734
Port_1320735
Port_1320743
Port_1320744
Port_1320752
Port_1320753
Port_1320763
Port_1320764
Port_1320774
Port_1320775
Port_1320783
Port_1320784
Port_1320794
Port_1320795
Port_1320803
Port_1320804
Port_1320814
Port_1320815
Port_1320825
Port_1320826
Port_1320834
Port_1320835
Port_1320865
Port_1320866
Port_1320874
Port_1320875
Port_1320885
Port_1320886
Port_1320896
Port_1320897
Port_1320911
Port_1320912
Port_1320924
Port_1320925
Port_1320933
Port_1320934
Port_1320944
Port_1320945
Port_1320957
Port_1320958
Port_1320974
Port_1320975
Port_1320985
Port_1320986
Port_1321028
Port_1321029
Port_1321043
Port_1321044
Port_1321072
Port_1321073
Port_1321081
Port_1321082
Port_1321116
Port_1321117
Port_1321125
Port_1321126
Port_1321138
Port_1321139
Port_1321166
Port_1321167
Port_1321225
Port_1321226
Port_1321276
Port_1321277
Port_1321309
Port_1321310
Port_1321322
Port_1321323
Port_1321365
Port_1321366
Port_1321380
Port_1321381
Port_1321389
Port_1321390
Port_1321400
Port_1321409
Port_1321410
Port_1321426
Port_1321427
Port_1321435
Port_1321436
Port_1321455
Port_1321456
Port_1321464
Port_1321465
Port_1321473
Port_1321474
Port_1321506
Port_1321507
Port_1321517
Port_1321518
Port_1321528
Port_1321529
Port_1321565
Port_1321566
Port_1321576
Port_1321577
Port_1321589
Port_1321590
Port_1321613
Port_1321614
Port_1321624
Port_1321625
Port_1321635
Port_1321636
Port_1321648
Port_1321649
Port_1321663
Port_1321664
Port_1321674
Port_1321675
Port_1321687
Port_1321688
Port_1321700
Port_1321701
Port_1321711
Port_1321712
Port_1321722
Port_1321723
Port_1321739
Port_1321740
Port_1321748
Port_1321749
Port_1321757
Port_1321758
Port_1321766
Port_1321767
Port_1322036
Port_1322347
Port_1322348
Port_1322367
Port_1322368
Port_1322421
Port_1322422
Port_1322430
Port_1322431
Port_1322462
Port_1322463
Port_1322471
Port_1322472
Port_1322480
Port_1322481
Port_1322491
Port_1322492
Port_1322500
Port_1322501
Port_1322509
Port_1322510
Port_1322518
Port_1322519
Port_1322527
Port_1322528
Port_1322536
Port_1322537
Port_1322553
Port_1322554
Port_1322562
Port_1322563
Port_1322571
Port_1322572
Port_1322580
Port_1322581
Port_1322589
Port_1322590
Port_1322598
Port_1322599
Port_1322609
Port_1322610
Port_1322622
Port_1322623
Port_1322633
Port_1322634
Port_1322642
Port_1322643
Port_1322651
Port_1322652
Port_1322660
Port_1322661
Port_1322679
Port_1322680
Port_1322688
Port_1322689
Port_1322697
Port_1322698
Port_1322706
Port_1322707
Port_1322715
Port_1322716
Port_1322724
Port_1322725
Port_1322735
Port_1322736
Port_1322744
Port_1322745
Port_1322757
Port_1322758
Port_1322770
Port_1322771
Port_1322780
Port_1322793
Port_1322803
Port_1322804
Port_1322812
Port_1322813
Port_1322821
Port_1322822
Port_1322830
Port_1322831
Port_1322839
Port_1322840
Port_1322848
Port_1322849
Port_1322857
Port_1322858
Port_1322870
Port_1322871
Port_1322881
Port_1322882
Port_1322890
Port_1322891
Port_1322901
Port_1322902
Port_1322910
Port_1322911
Port_1322919
Port_1322920
Port_1322930
Port_1322931
Port_1322941
Port_1322942
Port_1324550
Port_1324551
Port_1324609
Port_1324610
Port_1324711
Port_1324993
Port_1325016
Port_1325070
Port_1325268
Port_1325449
Port_1325528
Port_1325618
Port_1325707
Port_1326119
Port_1326171
Port_1326207
Port_1326281
Port_1326358
Port_1326502
Port_1326545
Port_1326658
Port_1326955
Port_1327519
Port_1327701
Port_1327711
Port_1327769
Port_1327844
Port_1327894
Port_1327908
Port_1327991
Port_1328040
Port_1328124
Port_1328217
Port_1328251
Port_1328263
Port_1328281
Port_1328295
Port_1328347
Port_1328391
Port_1328471
Port_1328775
Port_1328842
Port_1328886
Port_1328937
Port_1329010
Port_1329020
Port_1329090
Port_1329108
Port_1329178
Port_1329368
Port_1329393
Port_1329445
Port_1329540
Port_1329548
Port_1329629
Port_1329641
Port_1329651
Port_1329765
Port_1329773
Port_1329781
Port_1329799
Port_1329852
Port_1329896
Port_1329943
Port_1329951
Port_1329961
Port_1329969
Port_1330070
Port_1330088
Port_1330098
Port_1330110
Port_1330120
Port_1330162
Port_1330174
Port_1330206
Port_1330220
Port_1330230
Port_1331858
Port_1332223
Port_1332258
Port_1332363
Port_1332426
Port_1332540
Port_1332847
Port_1332915
Port_1333205
Port_1333273
Port_1333524
Port_1333609
Port_1333640
Port_1333701
Port_1333757
Port_1333875
Port_1338246
Port_1338448
Port_1338541
Port_1338615
Port_1338699
Port_1338801
Port_1338919
Port_1339308
Port_1339518
Port_1339585
Port_1339651
Port_1339755
Port_1339861
Port_1339915
Port_1339974
Port_1339990
Port_1340115
Port_1340171
Port_1340257
Port_1340324
Port_1340360
Port_1340771
Port_1340840
Port_1340926
Port_1341037
Port_1341126
Port_1341179
Port_1341483
Port_1341546
Port_1341726
Port_1341843
Port_1341883
Port_1342008
Port_1342047
Port_1342134
Port_1342393
Port_1342493
Port_1342546
Port_1342669
Port_1342759
Port_1342790
Port_1343124
Port_1344427
Port_1344428
Port_1418198
Port_1418700
Port_1418755
Port_1418756
Port_1418835
Port_1418836
Port_1418922
Port_1418923
Port_1419340
Port_1419416
Port_1419433
Port_1422650
Port_1422891
Port_1422908
Port_1422911
Port_1422914
Port_1422917
Port_1422920
Port_1426723
Port_1426856
Port_1426864
Port_1426964
Port_1426972
Port_1426980
Port_1426988
Port_1427076
Port_1427214
Port_1427222
Port_1427321
Port_1427322
Port_1427331
Port_1427383
Port_1427391
Port_1427399
Port_1427525
Port_1427533
Port_1427635
Port_1427643
Port_1427696
Port_1427772
Port_1427804
Port_1427812
Port_1427820
Port_1427828
Port_1427836
Port_1427844
Port_1427982
Port_1428693
Port_1428942
Port_1428987
Port_1428997
Port_1429007
Port_1429015
Port_1429069
Port_1429081
Port_1429120
Port_1429179
Port_1429187
Port_1429219
Port_1429309
Port_1429375
Port_1429412
Port_1429413
Port_1429424
Port_1429425
Port_1429428
Port_1429429
Port_1429433
Port_1429479
Port_1429511
Port_1429561
Port_1429594
Port_1429620
Port_1429658
Port_1429772
Port_1429921
Port_1429929
Port_1429937
Port_1429995
Port_1430023
Port_1430024
Port_1430032
Port_1430033
Port_1430041
Port_1430042
Port_1430065
Port_1430106
Port_1430114
Port_1430122
Port_1430174
Port_1430182
Port_1430190
Port_1430198
Port_1430234
Port_1430267
Port_1430275
Port_1430359
Port_1430446
Port_1430452
Port_1430482
Port_1430490
Port_1430568
Port_1430634
Port_1430645
Port_1430648
Port_1430651
Port_1430673
Port_1430683
Port_1430761
Port_1430773
Port_1430827
Port_1430839
Port_1430884
Port_1430894
Port_1430924
Port_1430975
Port_1430983
Port_1431015
Port_1431023
Port_1431095
Port_1431103
Port_1431175
Port_1431302
Port_1431472
Port_1431484
Port_1431492
Port_1431502
Port_1431510
Port_1431550
Port_1431723
Port_1431734
Port_1431737
Port_1431740
Port_1431762
Port_1431816
Port_1431829
Port_1431832
Port_1431835
Port_1431838
Port_1431841
Port_1431884
Port_1431903
Port_1431916
Port_1431975
Port_1431983
Port_1431991
Port_1432154
Port_1432162
Port_1432197
Port_1432231
Port_1432239
Port_1432247
Port_1432255
Port_1432327
Port_1432340
Port_1432343
Port_1432346
Port_1432380
Port_1432399
Port_1432412
Port_1432457
Port_1432505
Port_1432513
Port_1432583
Port_1432591
Port_1432648
Port_1432686
Port_1432798
Port_1432893
Port_1432899
Port_1432975
Port_1433010
Port_1433057
Port_1433065
Port_1433073
Port_1433188
Port_1433201
Port_1433204
Port_1433251
Port_1433353
Port_1433395
Port_1433463
Port_1433492
Port_1433493
Port_1433504
Port_1433505
Port_1433508
Port_1433509
Port_1433548
Port_1433549
Port_1433585
Port_1433586
Port_1433597
Port_1433598
Port_1433601
Port_1433602
Port_1433605
Port_1433606
Port_1433640
Port_1433711
Port_1433768
Port_1433776
Port_1433823
Port_1433850
Port_1433885
Port_1433899
Port_1433999
Port_1434031
Port_1434037
Port_1434045
Port_1434053
Port_1434063
Port_1434071
Port_1434119
Port_1434178
Port_1434222
Port_1434283
Port_1434293
Port_1434356
Port_1434408
Port_1434498
Port_1434508
Port_1434587
Port_1434595
Port_1434635
Port_1434645
Port_1434731
Port_1434739
Port_1434749
Port_1434759
Port_1434822
Port_1434974
Port_1434982
Port_1435026
Port_1435061
Port_1435099
Port_1435140
Port_1435181
Port_1435189
Port_1435197
Port_1435205
Port_1435215
Port_1435225
Port_1435233
Port_1435243
Port_1435251
Port_1435306
Port_1435314
Port_1435322
Port_1435330
Port_1435362
Port_1435370
Port_1435412
Port_1435447
Port_1435479
Port_1435487
Port_1435591
Port_1435641
Port_1435684
Port_1435734
Port_1435769
Port_1435777
Port_1435811
Port_1435856
Port_1435864
Port_1435996
Port_1436028
Port_1436069
Port_1436112
Port_1436120
Port_1436128
Port_1436136
Port_1436170
Port_1436273
Port_1436281
Port_1436303
Port_1436311
Port_1436319
Port_1436327
Port_1436335
Port_1436343
Port_1436351
Port_1436359
Port_1436405
Port_1436413
Port_1436421
Port_1436429
Port_1436437
Port_1436445
Port_1436512
Port_1436520
Port_1436576
Port_1436586
Port_1436594
Port_1436602
Port_1436666
Port_1440434
Port_1440435
Port_1441231
Port_1441668
Port_1441679
Port_1441682
Port_1441685
Port_1441703
Port_1441735
Port_1441795
Port_1441834
Port_1441847
Port_1441850
Port_1441853
Port_1441856
Port_1441892
Port_1441928
Port_1441993
Port_1442025
Port_1442036
Port_1442039
Port_1442042
Port_1442108
Port_1442120
Port_1442170
Port_1442213
Port_1442284
Port_1442295
Port_1442298
Port_1442301
Port_1442304
Port_1442383
Port_1442393
Port_1442403
Port_1442500
Port_1442506
Port_1442514
Port_1442522
Port_1442554
Port_1442600
Port_1442608
Port_1442680
Port_1442690
Port_1442773
Port_1442811
Port_1442878
Port_1443003
Port_1443035
Port_1443041
Port_1443084
Port_1443122
Port_1443210
Port_1443218
Port_1443251
Port_1443257
Port_1443265
Port_1443273
Port_1443281
Port_1443291
Port_1443299
Port_1443369
Port_1443377
Port_1443432
Port_1443440
Port_1443448
Port_1443456
Port_1443464
Port_1443538
Port_1443574
Port_1443582
Port_1443590
Port_1443598
Port_1443659
Port_1443660
Port_1443690
Port_1443691
Port_1443731
Port_1443768
Port_1443813
Port_1443821
Port_1443829
Port_1443837
Port_1443845
Port_1443853
Port_1443861
Port_1443917
Port_1443953
Port_1443961
Port_1443971
Port_1443979
Port_1444035
Port_1444076
Port_1444144
Port_1444260
Port_1444325
Port_1444347
Port_1444383
Port_1444408
Port_1444482
Port_1444531
Port_1444568
Port_1444588
Port_1444644
Port_1444723
Port_1444762
Port_1444803
Port_1444818
Port_1444821
Port_1444845
Port_1444904
Port_1444938
Port_1444951
Port_1444954
Port_1444957
Port_1444960
Port_1445054
Port_1445103
Port_1445150
Port_1445193
Port_1445204
Port_1445207
Port_1445210
Port_1445213
Port_1445290
Port_1445322
Port_1445333
Port_1445399
Port_1445431
Port_1445480
Port_1445503
Port_1445504
Port_1445539
Port_1445582
Port_1445593
Port_1445596
Port_1445659
Port_1445708
Port_1445720
Port_1445726
Port_1445736
Port_1445744
Port_1445756
Port_1445768
Port_1445776
Port_1445784
Port_1445790
Port_1445796
Port_1445804
Port_1445812
Port_1445863
Port_1445922
Port_1445983
Port_1445991
Port_1446034
Port_1446044
Port_1446052
Port_1446062
Port_1446072
Port_1446080
Port_1446231
Port_1446239
Port_1446247
Port_1446255
Port_1446263
Port_1446273
Port_1446285
Port_1446293
Port_1446301
Port_1446309
Port_1446317
Port_1446325
Port_1446333
Port_1446341
Port_1446349
Port_1446357
Port_1446365
Port_1446375
Port_1446383
Port_1446391
Port_1446437
Port_1446439
Port_1446440
Port_1446476
Port_1446486
Port_1446494
Port_1446502
Port_1446510
Port_1446518
Port_1446526
Port_1446534
Port_1446544
Port_1446554
Port_1446562
Port_1446570
Port_1446578
Port_1446586
Port_1446594
Port_1446638
Port_1446646
Port_1446680
Port_1446688
Port_1446732
Port_1446762
Port_1446772
Port_1446782
Port_1446792
Port_1446800
Port_1446808
Port_1446837
Port_1446838
Port_1446855
Port_1446863
Port_1446970
Port_1446978
Port_1446986
Port_1447035
Port_1447043
Port_1447051
Port_1447083
Port_1447345
Port_1447356
Port_1447384
Port_1447412
Port_1447460
Port_1447557
Port_1447558
Port_1447559
Port_1447598
Port_1447647
Port_1447719
Port_1447738
Port_1447741
Port_1447744
Port_1447747
Port_1447750
Port_1447753
Port_1447825
Port_1447861
Port_1447874
Port_1447877
Port_1447935
Port_1448021
Port_1448034
Port_1448074
Port_1448130
Port_1448175
Port_1448183
Port_1448193
Port_1448201
Port_1448209
Port_1448217
Port_1448225
Port_1448235
Port_1448253
Port_1448261
Port_1448277
Port_1448285
Port_1448295
Port_1448383
Port_1448435
Port_1448443
Port_1448451
Port_1448459
Port_1448469
Port_1448477
Port_1448485
Port_1448523
Port_1448531
Port_1448539
Port_1448547
Port_1448557
Port_1448606
Port_1448614
Port_1448622
Port_1448630
Port_1448678
Port_1448713
Port_1448721
Port_1448727
Port_1448759
Port_1448767
Port_1448777
Port_1448785
Port_1448795
Port_1448803
Port_1448811
Port_1451898
Port_1452245
Port_1456345
Port_1456559
Port_1456865
Port_1459100
Port_1462413
Port_1462414
Port_1462415
Port_1462416
Port_1462417
Port_1462418
Port_1462419
Port_1462420
Port_1462421
Port_1462422
Port_1462423
Port_1462424
Port_1462425
Port_1462426
Port_1462427
Port_1462428
Port_1462429
Port_1462430
Port_1462431
Port_1462432
Port_1462433
Port_1462434
Port_1462556
Port_1462557
Port_1462673
Port_1462674
Port_1462831
Port_1462832
Port_1462866
Port_1462867
Port_1462997
Port_1463005
Port_1463013
Port_1463021
Port_1463170
Port_1463242
Port_1463431
Port_1463481
Port_1463689
Port_1463690
Port_1463969
Port_1464358
Port_1464471
Port_1464532
Port_1464566
Port_1464604
Port_1464677
Port_1464756
Port_1464764
Port_1465528
Port_1465576
Port_1465593
Port_1466060
Port_1466203
Port_1466292
Port_1466362
Port_1466425
Port_1466978
Port_1470388
Port_1470542
Port_1470643
Port_1476778
Port_1476779
Port_1476780
Port_1482783
Port_1482784
Port_1482785
Port_1490574
Port_1493375
Port_1543621
Port_1543622
Port_1543623
Port_1543624
Port_1549770
Port_1549771
Port_1552053
Port_1552182
Port_1552243
Port_1552244
Port_1552288
Port_1552352
Port_1552413
Port_1552443
Port_1552444
Port_1552462
Port_1552463
Port_1552471
Port_1552472
Port_1552480
Port_1552481
Port_1552489
Port_1552490
Port_1552498
Port_1552499
Port_1552630
Port_1552631
Port_1552723
Port_1552724
Port_1552734
Port_1552735
Port_1552745
Port_1552746
Port_1552754
Port_1552755
Port_1552763
Port_1552764
Port_1552847
Port_1552900
Port_1552901
Port_1552957
Port_1552958
Port_1568723
Port_1568971
Port_1569062
Port_1569159
Port_1569627
Port_1570123
Port_1570154
Port_1570338
Port_1570571
Port_1570669
Port_1570685
Port_1570747
Port_1570757
Port_1570769
Port_1570777
Port_1570892
Port_1570900
Port_1570954
Port_1570970
Port_1571164
Port_1571304
Port_1571406
Port_1571523
Port_1571535
Port_1571543
Port_1571551
Port_1571780
Port_1571904
Port_1571983
Port_1572727
Port_1572755
Port_1572840
Port_1572883
Port_1572927
Port_1573023
Port_1573091
Port_1573220
Port_1573350
Port_1573358
Port_1573504
Port_1573516
Port_1573547
Port_1573647
Port_1573685
Port_1574203
Port_1574257
Port_1574265
Port_1574273
Port_1574281
Port_1574289
Port_1574303
Port_1574311
Port_1574319
Port_1574327
Port_1574335
Port_1574349
Port_1574357
Port_1574379
Port_1574421
Port_1574526
Port_1574642
Port_1574755
Port_1574763
Port_1574795
Port_1574807
Port_1574843
Port_1574875
Port_1574893
Port_1574937
Port_1575220
Port_1575303
Port_1575311
Port_1575626
Port_1575656
Port_1575701
Port_1575761
Port_1575930
Port_1575999
Port_1576199
Port_1576298
Port_1576306
Port_1576325
Port_1576428
Port_1576438
Port_1576500
Port_1576548
Port_1576600
Port_1576666
Port_1576747
Port_1576769
Port_1576807
Port_1576841
Port_1576849
Port_1747521
Port_2005278
Port_2005496
Port_2005743
Port_2005939
Port_2006035
Port_2006113
Port_2006203
Port_2006264
Port_2006298
Port_2006972
Port_2007015
Port_2007156
Port_2007278
Port_2007339
Port_2007391
Port_2007479
Port_2007505
Port_2007579
Port_2007614
Port_2007825
Port_2008063
Port_2008230
Port_2008540
Port_2008583
Port_2008662
Port_2019145
Port_2019619
Port_2019686
Port_2019712
Port_2019734
Port_2019874
Port_2019952
Port_2019979
Port_2020008
Port_2020051
Port_2020094
Port_2020129
Port_2020254
Port_2020256
Port_2020293
Port_2020363
Port_2020401
Port_2020462
Port_2020523
Port_2020585
Port_2020709
Port_2020757
Port_2020800
Port_2020825
Port_2020883
Port_2020935
Port_2020985
Port_2021043
Port_2021078
Port_2021113
Port_2021229
Port_2021264
Port_2021325
Port_2021422
Port_2021530
Port_2021573
Port_2021635
Port_2021660
Port_2021705
Port_2021971
Port_2022030
Port_2022079
Port_2022119
Port_2022159
Port_2022199
Port_2022257
Port_2022302
Port_2022350
Port_2022393
Port_2022451
Port_2022512
Port_2022555
Port_2022598
Port_2022641
Port_2022702
Port_2022781
Port_2022842
Port_2022885
Port_2022928
Port_2022963
Port_2023016
Port_2023059
Port_2023102
Port_2023163
Port_2023215
Port_2023243
Port_2023295
Port_2023347
Port_2023399
Port_2023483
Port_2025080
Port_2025210
Port_2025264
Port_2025361
Port_2025408
Port_2029790
Port_2029798
Port_2041344
Port_2041426
Port_2041493
Port_2041494
Port_2043438
Port_2043439
Port_2044012
Port_2044013
Port_2044237
Port_2044238
Port_2044268
Port_2044269
Port_2177170
Port_2192674
Port_2192675
Port_2200117
Port_2201391
Port_2203000
Port_2207515
Port_2235496
Port_2236285
Port_2244303
Port_2244882
Port_2245793
Port_2246132
Port_2246228
Port_2246368
Port_2247031
Port_2247176
Port_2248167
Port_2248354
Port_2248587
Port_2248773
Port_2249208
Port_2249418
Port_2249737
Port_2250778
Port_2252084
Port_2252191
Port_2252420
Port_2252842
Port_2261276
Port_2261336
Port_2261429
Port_2261430
Port_2262740
Port_2262775
Port_2263024
Port_2263093
Port_2263171
Port_2263172
Port_2263264
Port_2263571
Port_2263716
Port_2263818
Port_2263887
Port_2263997
Port_2264108
Port_2272877
Port_2273332
Port_2280887
Port_2280971
Port_2281118
Port_2281176
Port_2281209
Port_2281280
Port_2281331
Port_2281388
Port_2281471
Port_2281603
Port_2281604
Port_2281627
Port_2281675
Port_2282188
Port_2282320
Port_2282511
Port_2282637
Port_2282929
Port_2282979
Port_2283093

# IfcFlowController: GSS_Rankinis_mygtukas:Rankinis pavojaus mygtulas (55)
Type - Material: White, Red
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_DistributionFlowElementCommon - Reference: Rankinis pavojaus mygtulas; sets with these values: 2
Name (GSS_Rankinis_mygtukas:Rankinis pavojaus mygtulas:...) | In
1332540 | Rūsys
1332847 | Rūsys
1332915 | Rūsys
1333205 | Rūsys
1333273 | Rūsys
1333524 | Rūsys
1333609 | Rūsys
1333640 | Rūsys
1333701 | Rūsys
1333757 | Rūsys
1333875 | Rūsys
1338246 | 1 aukštas
1338448 | 1 aukštas
1338541 | 1 aukštas
1338615 | 1 aukštas
1338699 | 1 aukštas
1338801 | 1 aukštas
1338919 | 2 aukštas
1339308 | 2 aukštas
1339518 | 2 aukštas
1339585 | 2 aukštas
1339651 | 2 aukštas
1339755 | 2 aukštas
1339861 | 2 aukštas
1339915 | 2 aukštas
1339974 | 2 aukštas
1339990 | 2 aukštas
1340115 | 2 aukštas
1340171 | 2 aukštas
1340257 | 2 aukštas
1340324 | 2 aukštas
1340360 | 3 aukštas
1340771 | 3 aukštas
1340840 | 3 aukštas
1340926 | 3 aukštas
1341037 | 3 aukštas
1341126 | 3 aukštas
1341179 | 4 aukštas
1341483 | 4 aukštas
1341546 | 4 aukštas
1341726 | 4 aukštas
1341843 | 4 aukštas
1341883 | 4 aukštas
1342008 | 4 aukštas
1342047 | 4 aukštas
1342134 | 5 aukštas
1342393 | 5 aukštas
1342493 | 5 aukštas
1342546 | 5 aukštas
1342669 | 5 aukštas
1342759 | 5 aukštas
1342790 | 5 aukštas
1343124 | 5 aukštas
1552053 | 1 aukštas
2207515 | Rūsys

# IfcFlowTerminal: IS_Korpusinis_garsiakalbis_sieninis:03_IS_Korpusinis sieninis garsiakalbis 6W (16)
Type - Material: Metal - Silver, Plastic - White
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_DistributionFlowElementCommon - Reference: 03_IS_Korpusinis sieninis garsiakalbis 6W; sets with these values: 2
Name (IS_Korpusinis_garsiakalbis_sieninis:03_IS_Korpusinis sieninis garsiakalbis 6W:...) | In
1429658 | 1 aukštas
1431175 | 1 aukštas
1433823 | 2 aukštas
1436666 | 2 aukštas
1440434 | 2 aukštas
1440435 | 2 aukštas
1443084 | 3 aukštas
1443731 | 3 aukštas
1444076 | 3 aukštas
1444144 | 3 aukštas
1446437 | 4 aukštas
1446440 | 4 aukštas
1446837 | 4 aukštas
1446838 | 4 aukštas
1447557 | 5 aukštas
1447559 | 5 aukštas

# IfcFlowTerminal: IS_Lubinis_garsiakalbis:01_IS_Lubinis_įleidžiamas_garsiakalbis 3W (183)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_DistributionFlowElementCommon - Reference: 01_IS_Lubinis_įleidžiamas_garsiakalbis 3W; sets with these values: 2
Name (IS_Lubinis_garsiakalbis:01_IS_Lubinis_įleidžiamas_garsiakalbis 3W:...) | In | Material
1428942 | 1 aukštas
1429015 | 1 aukštas | Plastic - White
1429179 | 1 aukštas | Plastic - White
1429187 | 1 aukštas | Plastic - White
1429511 | 1 aukštas | Plastic - White
1431015 | 1 aukštas | Plastic - White
1431023 | 1 aukštas | Plastic - White
1433711 | 2 aukštas | Plastic - White
1433899 | 2 aukštas | Plastic - White
1433999 | 2 aukštas | Plastic - White
1434031 | 2 aukštas | Plastic - White
1434037 | 2 aukštas | Plastic - White
1434045 | 2 aukštas | Plastic - White
1434053 | 2 aukštas | Plastic - White
1434063 | 2 aukštas | Plastic - White
1434071 | 2 aukštas | Plastic - White
1434356 | 2 aukštas | Plastic - White
1434635 | 2 aukštas | Plastic - White
1434645 | 2 aukštas | Plastic - White
1434731 | 2 aukštas | Plastic - White
1434739 | 2 aukštas | Plastic - White
1434749 | 2 aukštas | Plastic - White
1434759 | 2 aukštas | Plastic - White
1434974 | 2 aukštas | Plastic - White
1434982 | 2 aukštas | Plastic - White
1435026 | 2 aukštas | Plastic - White
1435061 | 2 aukštas | Plastic - White
1435140 | 2 aukštas | Plastic - White
1435181 | 2 aukštas | Plastic - White
1435189 | 2 aukštas | Plastic - White
1435197 | 2 aukštas | Plastic - White
1435205 | 2 aukštas | Plastic - White
1435215 | 2 aukštas | Plastic - White
1435225 | 2 aukštas | Plastic - White
1435233 | 2 aukštas | Plastic - White
1435243 | 2 aukštas | Plastic - White
1435251 | 2 aukštas | Plastic - White
1435306 | 2 aukštas | Plastic - White
1435314 | 2 aukštas | Plastic - White
1435322 | 2 aukštas | Plastic - White
1435330 | 2 aukštas | Plastic - White
1435591 | 2 aukštas | Plastic - White
1435684 | 2 aukštas | Plastic - White
1436069 | 2 aukštas | Plastic - White
1436112 | 2 aukštas | Plastic - White
1436120 | 2 aukštas | Plastic - White
1436128 | 2 aukštas | Plastic - White
1436136 | 2 aukštas | Plastic - White
1436273 | 2 aukštas | Plastic - White
1436281 | 2 aukštas | Plastic - White
1436303 | 2 aukštas | Plastic - White
1436311 | 2 aukštas | Plastic - White
1436319 | 2 aukštas | Plastic - White
1436327 | 2 aukštas | Plastic - White
1436335 | 2 aukštas | Plastic - White
1436343 | 2 aukštas | Plastic - White
1436351 | 2 aukštas | Plastic - White
1436359 | 2 aukštas | Plastic - White
1436405 | 2 aukštas | Plastic - White
1436413 | 2 aukštas | Plastic - White
1436421 | 2 aukštas | Plastic - White
1436429 | 2 aukštas | Plastic - White
1436437 | 2 aukštas | Plastic - White
1436445 | 2 aukštas | Plastic - White
1436512 | 2 aukštas | Plastic - White
1436520 | 2 aukštas | Plastic - White
1436576 | 2 aukštas | Plastic - White
1436586 | 2 aukštas | Plastic - White
1436594 | 2 aukštas | Plastic - White
1436602 | 2 aukštas | Plastic - White
1442383 | 3 aukštas | Plastic - White
1442393 | 3 aukštas | Plastic - White
1442403 | 3 aukštas | Plastic - White
1442500 | 3 aukštas | Plastic - White
1442506 | 3 aukštas | Plastic - White
1442514 | 3 aukštas | Plastic - White
1442522 | 3 aukštas | Plastic - White
1442600 | 3 aukštas | Plastic - White
1442608 | 3 aukštas | Plastic - White
1442680 | 3 aukštas | Plastic - White
1442690 | 3 aukštas | Plastic - White
1443003 | 3 aukštas | Plastic - White
1443251 | 3 aukštas | Plastic - White
1443257 | 3 aukštas | Plastic - White
1443265 | 3 aukštas | Plastic - White
1443273 | 3 aukštas | Plastic - White
1443281 | 3 aukštas | Plastic - White
1443291 | 3 aukštas | Plastic - White
1443432 | 3 aukštas | Plastic - White
1443440 | 3 aukštas | Plastic - White
1443448 | 3 aukštas | Plastic - White
1443456 | 3 aukštas | Plastic - White
1443538 | 3 aukštas | Plastic - White
1443813 | 3 aukštas | Plastic - White
1443821 | 3 aukštas | Plastic - White
1443829 | 3 aukštas | Plastic - White
1443837 | 3 aukštas | Plastic - White
1443845 | 3 aukštas | Plastic - White
1443853 | 3 aukštas | Plastic - White
1443861 | 3 aukštas | Plastic - White
1443953 | 3 aukštas | Plastic - White
1443961 | 3 aukštas | Plastic - White
1443971 | 3 aukštas | Plastic - White
1443979 | 3 aukštas | Plastic - White
1445659 | 4 aukštas | Plastic - White
1445708 | 4 aukštas | Plastic - White
1445720 | 4 aukštas | Plastic - White
1445726 | 4 aukštas | Plastic - White
1445736 | 4 aukštas | Plastic - White
1445744 | 4 aukštas | Plastic - White
1445756 | 4 aukštas | Plastic - White
1445768 | 4 aukštas | Plastic - White
1445776 | 4 aukštas | Plastic - White
1445784 | 4 aukštas | Plastic - White
1445790 | 4 aukštas | Plastic - White
1445796 | 4 aukštas | Plastic - White
1445804 | 4 aukštas | Plastic - White
1445812 | 4 aukštas | Plastic - White
1445983 | 4 aukštas | Plastic - White
1445991 | 4 aukštas | Plastic - White
1446034 | 4 aukštas | Plastic - White
1446044 | 4 aukštas | Plastic - White
1446052 | 4 aukštas | Plastic - White
1446062 | 4 aukštas | Plastic - White
1446072 | 4 aukštas | Plastic - White
1446476 | 4 aukštas | Plastic - White
1446486 | 4 aukštas | Plastic - White
1446494 | 4 aukštas | Plastic - White
1446502 | 4 aukštas | Plastic - White
1446510 | 4 aukštas | Plastic - White
1446518 | 4 aukštas | Plastic - White
1446526 | 4 aukštas | Plastic - White
1446534 | 4 aukštas | Plastic - White
1446544 | 4 aukštas | Plastic - White
1446554 | 4 aukštas | Plastic - White
1446562 | 4 aukštas | Plastic - White
1446570 | 4 aukštas | Plastic - White
1446578 | 4 aukštas | Plastic - White
1446586 | 4 aukštas | Plastic - White
1446646 | 4 aukštas | Plastic - White
1446680 | 4 aukštas | Plastic - White
1446688 | 4 aukštas | Plastic - White
1446762 | 4 aukštas | Plastic - White
1446772 | 4 aukštas | Plastic - White
1446782 | 4 aukštas | Plastic - White
1446792 | 4 aukštas | Plastic - White
1446800 | 4 aukštas | Plastic - White
1446808 | 4 aukštas | Plastic - White
1446863 | 4 aukštas | Plastic - White
1446970 | 4 aukštas | Plastic - White
1446978 | 4 aukštas | Plastic - White
1446986 | 4 aukštas | Plastic - White
1447035 | 4 aukštas | Plastic - White
1447043 | 4 aukštas | Plastic - White
1447051 | 4 aukštas | Plastic - White
1447460 | 4 aukštas | Plastic - White
1448074 | 5 aukštas | Plastic - White
1448130 | 5 aukštas | Plastic - White
1448175 | 5 aukštas | Plastic - White
1448183 | 5 aukštas | Plastic - White
1448193 | 5 aukštas | Plastic - White
1448201 | 5 aukštas | Plastic - White
1448209 | 5 aukštas | Plastic - White
1448217 | 5 aukštas | Plastic - White
1448225 | 5 aukštas | Plastic - White
1448235 | 5 aukštas | Plastic - White
1448253 | 5 aukštas | Plastic - White
1448277 | 5 aukštas | Plastic - White
1448285 | 5 aukštas | Plastic - White
1448383 | 5 aukštas | Plastic - White
1448435 | 5 aukštas | Plastic - White
1448443 | 5 aukštas | Plastic - White
1448459 | 5 aukštas | Plastic - White
1448523 | 5 aukštas | Plastic - White
1448531 | 5 aukštas | Plastic - White
1448539 | 5 aukštas | Plastic - White
1448547 | 5 aukštas | Plastic - White
1448557 | 5 aukštas | Plastic - White
1448606 | 5 aukštas | Plastic - White
1448614 | 5 aukštas | Plastic - White
1448622 | 5 aukštas | Plastic - White
2177170 | 5 aukštas | Plastic - White
2203000 | 2 aukštas | Plastic - White

# IfcFlowTerminal: IS_Lubinis_garsiakalbis:01_IS_Lubinis_įleidžiamas_garsiakalbis 6W (244)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_DistributionFlowElementCommon - Reference: 01_IS_Lubinis_įleidžiamas_garsiakalbis 6W; sets with these values: 2
Name (IS_Lubinis_garsiakalbis:01_IS_Lubinis_įleidžiamas_garsiakalbis 6W:...) | In | Material
1428693 | 1 aukštas
1428987 | 1 aukštas | Plastic - White
1428997 | 1 aukštas | Plastic - White
1429007 | 1 aukštas | Plastic - White
1429120 | 1 aukštas | Plastic - White
1429219 | 1 aukštas | Plastic - White
1429309 | 1 aukštas | Plastic - White
1429375 | 1 aukštas | Plastic - White
1429412 | 1 aukštas | Plastic - White
1429413 | 1 aukštas | Plastic - White
1429424 | 1 aukštas | Plastic - White
1429425 | 1 aukštas | Plastic - White
1429428 | 1 aukštas | Plastic - White
1429429 | 1 aukštas | Plastic - White
1429433 | 1 aukštas | Plastic - White
1429479 | 1 aukštas | Plastic - White
1429561 | 1 aukštas | Plastic - White
1429620 | 1 aukštas | Plastic - White
1429772 | 1 aukštas | Plastic - White
1429921 | 1 aukštas | Plastic - White
1429929 | 1 aukštas | Plastic - White
1429937 | 1 aukštas | Plastic - White
1429995 | 1 aukštas | Plastic - White
1430023 | 1 aukštas | Plastic - White
1430024 | 1 aukštas | Plastic - White
1430032 | 1 aukštas | Plastic - White
1430033 | 1 aukštas | Plastic - White
1430041 | 1 aukštas | Plastic - White
1430042 | 1 aukštas | Plastic - White
1430267 | 1 aukštas | Plastic - White
1430275 | 1 aukštas | Plastic - White
1430359 | 1 aukštas | Plastic - White
1430446 | 1 aukštas | Plastic - White
1430452 | 1 aukštas | Plastic - White
1430568 | 1 aukštas | Plastic - White
1430634 | 1 aukštas | Plastic - White
1430645 | 1 aukštas | Plastic - White
1430648 | 1 aukštas | Plastic - White
1430651 | 1 aukštas | Plastic - White
1430673 | 1 aukštas | Plastic - White
1430683 | 1 aukštas | Plastic - White
1430761 | 1 aukštas | Plastic - White
1430773 | 1 aukštas | Plastic - White
1430827 | 1 aukštas | Plastic - White
1430839 | 1 aukštas | Plastic - White
1430884 | 1 aukštas | Plastic - White
1430894 | 1 aukštas | Plastic - White
1431095 | 1 aukštas | Plastic - White
1431103 | 1 aukštas | Plastic - White
1431550 | 2 aukštas | Plastic - White
1431723 | 2 aukštas | Plastic - White
1431734 | 2 aukštas | Plastic - White
1431737 | 2 aukštas | Plastic - White
1431740 | 2 aukštas | Plastic - White
1431762 | 2 aukštas | Plastic - White
1431816 | 2 aukštas | Plastic - White
1431829 | 2 aukštas | Plastic - White
1431832 | 2 aukštas | Plastic - White
1431835 | 2 aukštas | Plastic - White
1431838 | 2 aukštas | Plastic - White
1431841 | 2 aukštas | Plastic - White
1431884 | 2 aukštas | Plastic - White
1431903 | 2 aukštas | Plastic - White
1431916 | 2 aukštas | Plastic - White
1431975 | 2 aukštas | Plastic - White
1431983 | 2 aukštas | Plastic - White
1431991 | 2 aukštas | Plastic - White
1432154 | 2 aukštas | Plastic - White
1432162 | 2 aukštas | Plastic - White
1432197 | 2 aukštas | Plastic - White
1432231 | 2 aukštas | Plastic - White
1432239 | 2 aukštas | Plastic - White
1432247 | 2 aukštas | Plastic - White
1432255 | 2 aukštas | Plastic - White
1432327 | 2 aukštas | Plastic - White
1432340 | 2 aukštas | Plastic - White
1432343 | 2 aukštas | Plastic - White
1432346 | 2 aukštas | Plastic - White
1432380 | 2 aukštas | Plastic - White
1432399 | 2 aukštas | Plastic - White
1432412 | 2 aukštas | Plastic - White
1432457 | 2 aukštas | Plastic - White
1432505 | 2 aukštas | Plastic - White
1432513 | 2 aukštas | Plastic - White
1432583 | 2 aukštas | Plastic - White
1432591 | 2 aukštas | Plastic - White
1432648 | 2 aukštas | Plastic - White
1432686 | 2 aukštas | Plastic - White
1432798 | 2 aukštas | Plastic - White
1432893 | 2 aukštas | Plastic - White
1432899 | 2 aukštas | Plastic - White
1432975 | 2 aukštas | Plastic - White
1433010 | 2 aukštas | Plastic - White
1433057 | 2 aukštas | Plastic - White
1433065 | 2 aukštas | Plastic - White
1433073 | 2 aukštas | Plastic - White
1433188 | 2 aukštas | Plastic - White
1433201 | 2 aukštas | Plastic - White
1433204 | 2 aukštas | Plastic - White
1433251 | 2 aukštas | Plastic - White
1433353 | 2 aukštas | Plastic - White
1433395 | 2 aukštas | Plastic - White
1433463 | 2 aukštas | Plastic - White
1433492 | 2 aukštas | Plastic - White
1433493 | 2 aukštas | Plastic - White
1433504 | 2 aukštas | Plastic - White
1433505 | 2 aukštas | Plastic - White
1433508 | 2 aukštas | Plastic - White
1433509 | 2 aukštas | Plastic - White
1433548 | 2 aukštas | Plastic - White
1433549 | 2 aukštas | Plastic - White
1433585 | 2 aukštas | Plastic - White
1433586 | 2 aukštas | Plastic - White
1433597 | 2 aukštas | Plastic - White
1433598 | 2 aukštas | Plastic - White
1433601 | 2 aukštas | Plastic - White
1433602 | 2 aukštas | Plastic - White
1433605 | 2 aukštas | Plastic - White
1433606 | 2 aukštas | Plastic - White
1433768 | 2 aukštas | Plastic - White
1433776 | 2 aukštas | Plastic - White
1433850 | 2 aukštas | Plastic - White
1433885 | 2 aukštas | Plastic - White
1434119 | 2 aukštas | Plastic - White
1434222 | 2 aukštas | Plastic - White
1434283 | 2 aukštas | Plastic - White
1434293 | 2 aukštas | Plastic - White
1434498 | 2 aukštas | Plastic - White
1434508 | 2 aukštas | Plastic - White
1434587 | 2 aukštas | Plastic - White
1434595 | 2 aukštas | Plastic - White
1434822 | 2 aukštas | Plastic - White
1435362 | 2 aukštas | Plastic - White
1435370 | 2 aukštas | Plastic - White
1435412 | 2 aukštas | Plastic - White
1435447 | 2 aukštas | Plastic - White
1435479 | 2 aukštas | Plastic - White
1435487 | 2 aukštas | Plastic - White
1435641 | 2 aukštas | Plastic - White
1435769 | 2 aukštas | Plastic - White
1435777 | 2 aukštas | Plastic - White
1435811 | 2 aukštas | Plastic - White
1435856 | 2 aukštas | Plastic - White
1435864 | 2 aukštas | Plastic - White
1435996 | 2 aukštas | Plastic - White
1436028 | 2 aukštas | Plastic - White
1441231 | 3 aukštas | Plastic - White
1441668 | 3 aukštas | Plastic - White
1441679 | 3 aukštas | Plastic - White
1441682 | 3 aukštas | Plastic - White
1441685 | 3 aukštas | Plastic - White
1441703 | 3 aukštas | Plastic - White
1441735 | 3 aukštas | Plastic - White
1441795 | 3 aukštas | Plastic - White
1441834 | 3 aukštas | Plastic - White
1441847 | 3 aukštas | Plastic - White
1441850 | 3 aukštas | Plastic - White
1441853 | 3 aukštas | Plastic - White
1441856 | 3 aukštas | Plastic - White
1441892 | 3 aukštas | Plastic - White
1441928 | 3 aukštas | Plastic - White
1441993 | 3 aukštas | Plastic - White
1442025 | 3 aukštas | Plastic - White
1442036 | 3 aukštas | Plastic - White
1442039 | 3 aukštas | Plastic - White
1442042 | 3 aukštas | Plastic - White
1442108 | 3 aukštas | Plastic - White
1442120 | 3 aukštas | Plastic - White
1442170 | 3 aukštas | Plastic - White
1442213 | 3 aukštas | Plastic - White
1442284 | 3 aukštas | Plastic - White
1442295 | 3 aukštas | Plastic - White
1442298 | 3 aukštas | Plastic - White
1442301 | 3 aukštas | Plastic - White
1442304 | 3 aukštas | Plastic - White
1442773 | 3 aukštas | Plastic - White
1442811 | 3 aukštas | Plastic - White
1442878 | 3 aukštas | Plastic - White
1443299 | 3 aukštas | Plastic - White
1443369 | 3 aukštas | Plastic - White
1443377 | 3 aukštas | Plastic - White
1443464 | 3 aukštas | Plastic - White
1443574 | 3 aukštas | Plastic - White
1443582 | 3 aukštas | Plastic - White
1443590 | 3 aukštas | Plastic - White
1443598 | 3 aukštas | Plastic - White
1443917 | 3 aukštas | Plastic - White
1444035 | 3 aukštas | Plastic - White
1444644 | 4 aukštas | Plastic - White
1444723 | 4 aukštas | Plastic - White
1444762 | 4 aukštas | Plastic - White
1444803 | 4 aukštas | Plastic - White
1444818 | 4 aukštas | Plastic - White
1444821 | 4 aukštas | Plastic - White
1444845 | 4 aukštas | Plastic - White
1444904 | 4 aukštas | Plastic - White
1444938 | 4 aukštas | Plastic - White
1444951 | 4 aukštas | Plastic - White
1444954 | 4 aukštas | Plastic - White
1444957 | 4 aukštas | Plastic - White
1444960 | 4 aukštas | Plastic - White
1445054 | 4 aukštas | Plastic - White
1445103 | 4 aukštas | Plastic - White
1445150 | 4 aukštas | Plastic - White
1445193 | 4 aukštas | Plastic - White
1445204 | 4 aukštas | Plastic - White
1445207 | 4 aukštas | Plastic - White
1445210 | 4 aukštas | Plastic - White
1445213 | 4 aukštas | Plastic - White
1445290 | 4 aukštas | Plastic - White
1445322 | 4 aukštas | Plastic - White
1445333 | 4 aukštas | Plastic - White
1445399 | 4 aukštas | Plastic - White
1445431 | 4 aukštas | Plastic - White
1445480 | 4 aukštas | Plastic - White
1445503 | 4 aukštas | Plastic - White
1445504 | 4 aukštas | Plastic - White
1445539 | 4 aukštas | Plastic - White
1445582 | 4 aukštas | Plastic - White
1445593 | 4 aukštas | Plastic - White
1445596 | 4 aukštas | Plastic - White
1445922 | 4 aukštas | Plastic - White
1446594 | 4 aukštas | Plastic - White
1446638 | 4 aukštas | Plastic - White
1446855 | 4 aukštas | Plastic - White
1447647 | 5 aukštas | Plastic - White
1447719 | 5 aukštas | Plastic - White
1447738 | 5 aukštas | Plastic - White
1447741 | 5 aukštas | Plastic - White
1447744 | 5 aukštas | Plastic - White
1447747 | 5 aukštas | Plastic - White
1447750 | 5 aukštas | Plastic - White
1447753 | 5 aukštas | Plastic - White
1447825 | 5 aukštas | Plastic - White
1447861 | 5 aukštas | Plastic - White
1447874 | 5 aukštas | Plastic - White
1447877 | 5 aukštas | Plastic - White
1447935 | 5 aukštas | Plastic - White
1448021 | 5 aukštas | Plastic - White
1448034 | 5 aukštas | Plastic - White
1448678 | 5 aukštas | Plastic - White
1448713 | 5 aukštas | Plastic - White
1448721 | 5 aukštas | Plastic - White
1448727 | 5 aukštas | Plastic - White
