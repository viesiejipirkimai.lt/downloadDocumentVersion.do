Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 22.612096
Time: 2023-07-27T13:57:10
Author: UAB "Projectum", mindaugas@projectum.lt
Written by: ODA IFC SDK 22.8
Made in: 22.1.40.58 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcProject, 22.612096
LongName: Gydymo paskirties pastato Santariškių g. 2, Vilniuje, statybos projektas; Phase: TP

# IfcSite, Santariškių g. 2, Vilnius
RefLatitude: 54, 45, 7, 339197; RefLongitude: 25, 16, 31, 313663; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 6
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (6)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Rūsys | Rūsys | 149080
1 aukštas | 1 aukštas | 152840
2 aukštas | 2 aukštas | 157340
3 aukštas | 3 aukštas | 162140
4 aukštas | 4 aukštas | 166640
5 aukštas | 5 aukštas | 171140

# IfcBuildingElementProxy: GSS_Centrale:Gaisrinė centralė (2)
In: 1 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Gaisrinė centralė; sets with these values: 2
Pset_ProvisionForVoid - Width: 450 mm; Height: 185 mm; Depth: 960 mm
Name (GSS_Centrale:...)
GC-1:1493375
GC-2:1747521

# IfcBuildingElementProxy: GSS_Centrale:Gaisrinės centralės kartotuvas, GSS_Centrale:Gaisrinės centralės kartotuvas:1466978
In: 2 aukštas
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Gaisrinės centralės kartotuvas; sets with these values: 2
Pset_ProvisionForVoid - Width: 450 mm; Height: 185 mm; Depth: 960 mm

# IfcBuildingElementProxy: IS_Korpusinis_garsiakalbis:03_IS_Korpusinis lubinis garsiakalbis 1,5W (4)
In: Rūsys
Type - Material: Plastic - White, Plastic - Grey
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: 03_IS_Korpusinis lubinis garsiakalbis 1,5W; sets with these values: 2
Pset_ProvisionForVoid - Width: 234 mm; Height: 146 mm; Depth: 5 mm
Name (IS_Korpusinis_garsiakalbis:03_IS_Korpusinis lubinis garsiakalbis 1,5W:...)
1426964
1426972
1426980
1426988

# IfcBuildingElementProxy: IS_Korpusinis_garsiakalbis:03_IS_Korpusinis lubinis garsiakalbis 3W (2)
In: Rūsys
Type - Material: Plastic - White, Plastic - Grey
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: 03_IS_Korpusinis lubinis garsiakalbis 3W; sets with these values: 2
Pset_ProvisionForVoid - Width: 234 mm; Height: 146 mm; Depth: 5 mm
Name (IS_Korpusinis_garsiakalbis:03_IS_Korpusinis lubinis garsiakalbis 3W:...)
1427391
1427399

# IfcBuildingElementProxy: IS_Korpusinis_garsiakalbis:03_IS_Korpusinis lubinis garsiakalbis 6W (50)
Type - Material: Plastic - White, Plastic - Grey
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: 03_IS_Korpusinis lubinis garsiakalbis 6W; sets with these values: 2
Pset_ProvisionForVoid - Width: 234 mm; Height: 146 mm; Depth: 5 mm
Name (IS_Korpusinis_garsiakalbis:03_IS_Korpusinis lubinis garsiakalbis 6W:...) | In
1422650 | Rūsys
1422891 | Rūsys
1422908 | Rūsys
1422911 | Rūsys
1422914 | Rūsys
1422917 | Rūsys
1422920 | Rūsys
1426723 | Rūsys
1426856 | Rūsys
1426864 | Rūsys
1427076 | Rūsys
1427214 | Rūsys
1427222 | Rūsys
1427321 | Rūsys
1427322 | Rūsys
1427331 | Rūsys
1427383 | Rūsys
1427525 | Rūsys
1427533 | Rūsys
1427635 | Rūsys
1427643 | Rūsys
1427696 | Rūsys
1427772 | Rūsys
1427804 | Rūsys
1427812 | Rūsys
1427820 | Rūsys
1427828 | Rūsys
1427836 | Rūsys
1427844 | Rūsys
1430482 | 1 aukštas
1430490 | 1 aukštas
1430924 | 1 aukštas
1433640 | 2 aukštas
1435734 | 2 aukštas
1443122 | 3 aukštas
1443210 | 3 aukštas
1443218 | 3 aukštas
1443768 | 3 aukštas
1445863 | 4 aukštas
1446439 | 4 aukštas
1446732 | 4 aukštas
1447558 | 5 aukštas
1447598 | 5 aukštas
1448759 | 5 aukštas
1448767 | 5 aukštas
1448777 | 5 aukštas
1448785 | 5 aukštas
1448795 | 5 aukštas
1448803 | 5 aukštas
1448811 | 5 aukštas

# IfcBuildingElementProxy: IS_Lubinis_garsiakalbis:01_IS_Lubinis_įleidžiamas_garsiakalbis 1,5W (17)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: 01_IS_Lubinis_įleidžiamas_garsiakalbis 1,5W; sets with these values: 2
Pset_ProvisionForVoid - Depth: 10 mm
Name (IS_Lubinis_garsiakalbis:01_IS_Lubinis_įleidžiamas_garsiakalbis 1,5W:...) | In | Material
1434178 | 2 aukštas
1435099 | 2 aukštas | Plastic - White
1436170 | 2 aukštas | Plastic - White
1443035 | 3 aukštas | Plastic - White
1443041 | 3 aukštas | Plastic - White
1443659 | 3 aukštas | Plastic - White
1443660 | 3 aukštas | Plastic - White
1443690 | 3 aukštas | Plastic - White
1443691 | 3 aukštas | Plastic - White
1447083 | 4 aukštas | Plastic - White
1448261 | 5 aukštas | Plastic - White
1448295 | 5 aukštas | Plastic - White
1448451 | 5 aukštas | Plastic - White
1448469 | 5 aukštas | Plastic - White
1448477 | 5 aukštas | Plastic - White
1448485 | 5 aukštas | Plastic - White
1459100 | 5 aukštas | Plastic - White

# IfcBuildingElementProxy: IS_Lubinis_garsiakalbis:02_IS_Lubinis_įleidžiamas_garsiakalbis_hermetinis 3W (43)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: 02_IS_Lubinis_įleidžiamas_garsiakalbis_hermetinis 3W; sets with these values: 2
Pset_ProvisionForVoid - Depth: 10 mm
Name (IS_Lubinis_garsiakalbis:02_IS_Lubinis_įleidžiamas_garsiakalbis_hermetinis 3W:...) | In | Material
1429069 | 1 aukštas
1429081 | 1 aukštas | Plastic - White
1430065 | 1 aukštas | Plastic - White
1430106 | 1 aukštas | Plastic - White
1430114 | 1 aukštas | Plastic - White
1430122 | 1 aukštas | Plastic - White
1430174 | 1 aukštas | Plastic - White
1430182 | 1 aukštas | Plastic - White
1430190 | 1 aukštas | Plastic - White
1430198 | 1 aukštas | Plastic - White
1430234 | 1 aukštas | Plastic - White
1430975 | 1 aukštas | Plastic - White
1430983 | 1 aukštas | Plastic - White
1431302 | 2 aukštas | Plastic - White
1431472 | 2 aukštas | Plastic - White
1431484 | 2 aukštas | Plastic - White
1431492 | 2 aukštas | Plastic - White
1431502 | 2 aukštas | Plastic - White
1431510 | 2 aukštas | Plastic - White
1434408 | 2 aukštas | Plastic - White
1442554 | 3 aukštas | Plastic - White
1446080 | 4 aukštas | Plastic - White
1446231 | 4 aukštas | Plastic - White
1446239 | 4 aukštas | Plastic - White
1446247 | 4 aukštas | Plastic - White
1446255 | 4 aukštas | Plastic - White
1446263 | 4 aukštas | Plastic - White
1446273 | 4 aukštas | Plastic - White
1446285 | 4 aukštas | Plastic - White
1446293 | 4 aukštas | Plastic - White
1446301 | 4 aukštas | Plastic - White
1446309 | 4 aukštas | Plastic - White
1446317 | 4 aukštas | Plastic - White
1446325 | 4 aukštas | Plastic - White
1446333 | 4 aukštas | Plastic - White
1446341 | 4 aukštas | Plastic - White
1446349 | 4 aukštas | Plastic - White
1446357 | 4 aukštas | Plastic - White
1446365 | 4 aukštas | Plastic - White
1446375 | 4 aukštas | Plastic - White
1446383 | 4 aukštas | Plastic - White
1446391 | 4 aukštas | Plastic - White
1448630 | 5 aukštas | Plastic - White

# IfcBuildingElementProxy: IS_Panele su mikrofonu:Panele su mikrofonu (3)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: Panele su mikrofonu; sets with these values: 2
Name (IS_Panele su mikrofonu:Panele su mikrofonu:...) | In | Material
1456345 | 1 aukštas
1456559 | 1 aukštas | <Unnamed>
1456865 | 2 aukštas | <Unnamed>

# IfcBuildingElementProxy: IS_Ruporinis_garsiakalbis_apvalus:06_IS_Ruporinis garsiakalbis_apvalus_lubinis 10W (26)
Type - Material: Metal - Gray (7)
Type - Pset_ProductRequirements - Category: Communication Devices
Pset_BuildingElementProxyCommon - Reference: 06_IS_Ruporinis garsiakalbis_apvalus_lubinis 10W; sets with these values: 2
Name (IS_Ruporinis_garsiakalbis_apvalus:06_IS_Ruporinis garsiakalbis_apvalus_lubinis 10W:...) | In | Material
1418198 | Rūsys
1418700 | Rūsys | Metal - Gray
1418755 | Rūsys | Metal - Gray
1418756 | Rūsys | Metal - Gray
1418835 | Rūsys | Metal - Gray
1418836 | Rūsys | Metal - Gray
1418922 | Rūsys | Metal - Gray
1418923 | Rūsys | Metal - Gray
1419340 | 1 aukštas | Metal - Gray
1419416 | 1 aukštas | Metal - Gray
1419433 | 1 aukštas | Metal - Gray
1427982 | Rūsys | Metal - Gray
1429594 | 1 aukštas | Metal - Gray
1444260 | 3 aukštas | Metal - Gray
1444325 | 3 aukštas | Metal - Gray
1444347 | 3 aukštas | Metal - Gray
1444383 | 3 aukštas | Metal - Gray
1444408 | 3 aukštas | Metal - Gray
1444482 | 2 aukštas | Metal - Gray
1444531 | 2 aukštas | Metal - Gray
1444568 | 2 aukštas | Metal - Gray
1444588 | 2 aukštas | Metal - Gray
1447345 | 4 aukštas | Metal - Gray
1447356 | 4 aukštas | Metal - Gray
1447384 | 4 aukštas | Metal - Gray
1447412 | 4 aukštas | Metal - Gray

# IfcBuildingElementProxy: SS_Komutacine_spinta_Comm:Komutacine spinta_42U 600x800 mm (2)
In: Rūsys
Type - Material: Black
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Komutacine spinta_42U 600x800 mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 600 mm; Height: 800 mm; Depth: 2000 mm
Name (SS_Komutacine_spinta_Comm:...)
ĮS-EVAC:1451898
ĮS-EVAC.B:1452245

# IfcDistributionControlElement: GSS_Detektorius:01_Optinis dūmų detektorius (585)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: 01_Optinis dūmų detektorius
Name (GSS_Detektorius:01_Optinis dūmų detektorius:...) | In | Material
1299920 | 1 aukštas
1300661 | 1 aukštas | Plastic - White
1300748 | 1 aukštas | Plastic - White
1300757 | 1 aukštas | Plastic - White
1300850 | 1 aukštas | Plastic - White
1300860 | 1 aukštas | Plastic - White
1300904 | 1 aukštas | Plastic - White
1301049 | 1 aukštas | Plastic - White
1301077 | 1 aukštas | Plastic - White
1301104 | 1 aukštas | Plastic - White
1301131 | 1 aukštas | Plastic - White
1301156 | 1 aukštas | Plastic - White
1301213 | 1 aukštas | Plastic - White
1301247 | 1 aukštas | Plastic - White
1301300 | 1 aukštas | Plastic - White
1301326 | 1 aukštas | Plastic - White
1301364 | 1 aukštas | Plastic - White
1301405 | 1 aukštas | Plastic - White
1301434 | 1 aukštas | Plastic - White
1301456 | 1 aukštas | Plastic - White
1301485 | 1 aukštas | Plastic - White
1301526 | 1 aukštas | Plastic - White
1301563 | 1 aukštas | Plastic - White
1301574 | 1 aukštas | Plastic - White
1301619 | 1 aukštas | Plastic - White
1301646 | 1 aukštas | Plastic - White
1301684 | 1 aukštas | Plastic - White
1301707 | 1 aukštas | Plastic - White
1301748 | 1 aukštas | Plastic - White
1301784 | 1 aukštas | Plastic - White
1302373 | 1 aukštas | Plastic - White
1302386 | 1 aukštas | Plastic - White
1302408 | 1 aukštas | Plastic - White
1302429 | 1 aukštas | Plastic - White
1302440 | 1 aukštas | Plastic - White
1302586 | 1 aukštas | Plastic - White
1302603 | 1 aukštas | Plastic - White
1302612 | 1 aukštas | Plastic - White
1302623 | 1 aukštas | Plastic - White
1302632 | 1 aukštas | Plastic - White
1302643 | 1 aukštas | Plastic - White
1302654 | 1 aukštas | Plastic - White
1302708 | 1 aukštas | Plastic - White
1302719 | 1 aukštas | Plastic - White
1302730 | 1 aukštas | Plastic - White
1302743 | 1 aukštas | Plastic - White
1302754 | 1 aukštas | Plastic - White
1302826 | 1 aukštas | Plastic - White
1303585 | Rūsys | Plastic - White
1304086 | Rūsys | Plastic - White
1304244 | Rūsys | Plastic - White
1304314 | Rūsys | Plastic - White
1304523 | Rūsys | Plastic - White
1304623 | Rūsys | Plastic - White
1304738 | Rūsys | Plastic - White
1304812 | Rūsys | Plastic - White
1304876 | Rūsys | Plastic - White
1304927 | Rūsys | Plastic - White
1304937 | Rūsys | Plastic - White
1304945 | Rūsys | Plastic - White
1304953 | Rūsys | Plastic - White
1304961 | Rūsys | Plastic - White
1304969 | Rūsys | Plastic - White
1304979 | Rūsys | Plastic - White
1304987 | Rūsys | Plastic - White
1304995 | Rūsys | Plastic - White
1305003 | Rūsys | Plastic - White
1305096 | Rūsys | Plastic - White
1305106 | Rūsys | Plastic - White
1305122 | Rūsys | Plastic - White
1305130 | Rūsys | Plastic - White
1305172 | Rūsys | Plastic - White
1305180 | Rūsys | Plastic - White
1305230 | Rūsys | Plastic - White
1305238 | Rūsys | Plastic - White
1305334 | Rūsys | Plastic - White
1305649 | Rūsys | Plastic - White
1305657 | Rūsys | Plastic - White
1305665 | Rūsys | Plastic - White
1305721 | Rūsys | Plastic - White
1305801 | Rūsys | Plastic - White
1305809 | Rūsys | Plastic - White
1305907 | Rūsys | Plastic - White
1305943 | Rūsys | Plastic - White
1306067 | Rūsys | Plastic - White
1306799 | 2 aukštas | Plastic - White
1307418 | 2 aukštas | Plastic - White
1307441 | 2 aukštas | Plastic - White
1307450 | 2 aukštas | Plastic - White
1307461 | 2 aukštas | Plastic - White
1307610 | 2 aukštas | Plastic - White
1307621 | 2 aukštas | Plastic - White
1307636 | 2 aukštas | Plastic - White
1307676 | 2 aukštas | Plastic - White
1307687 | 2 aukštas | Plastic - White
1307696 | 2 aukštas | Plastic - White
1307705 | 2 aukštas | Plastic - White
1307714 | 2 aukštas | Plastic - White
1307725 | 2 aukštas | Plastic - White
1307734 | 2 aukštas | Plastic - White
1307749 | 2 aukštas | Plastic - White
1307775 | 2 aukštas | Plastic - White
1307904 | 2 aukštas | Plastic - White
1307937 | 2 aukštas | Plastic - White
1308060 | 2 aukštas | Plastic - White
1308285 | 2 aukštas | Plastic - White
1308391 | 2 aukštas | Plastic - White
1308640 | 2 aukštas | Plastic - White
1308671 | 2 aukštas | Plastic - White
1308701 | 2 aukštas | Plastic - White
1308712 | 2 aukštas | Plastic - White
1308721 | 2 aukštas | Plastic - White
1308736 | 2 aukštas | Plastic - White
1308758 | 2 aukštas | Plastic - White
1308767 | 2 aukštas | Plastic - White
1308778 | 2 aukštas | Plastic - White
1308791 | 2 aukštas | Plastic - White
1308812 | 2 aukštas | Plastic - White
1308823 | 2 aukštas | Plastic - White
1308868 | 2 aukštas | Plastic - White
1308883 | 2 aukštas | Plastic - White
1308892 | 2 aukštas | Plastic - White
1308955 | 2 aukštas | Plastic - White
1308984 | 2 aukštas | Plastic - White
1309017 | 2 aukštas | Plastic - White
1309026 | 2 aukštas | Plastic - White
1309035 | 2 aukštas | Plastic - White
1309080 | 2 aukštas | Plastic - White
1309089 | 2 aukštas | Plastic - White
1309098 | 2 aukštas | Plastic - White
1309107 | 2 aukštas | Plastic - White
1309116 | 2 aukštas | Plastic - White
1309125 | 2 aukštas | Plastic - White
1309134 | 2 aukštas | Plastic - White
1309143 | 2 aukštas | Plastic - White
1309156 | 2 aukštas | Plastic - White
1309165 | 2 aukštas | Plastic - White
1309174 | 2 aukštas | Plastic - White
1309187 | 2 aukštas | Plastic - White
1309198 | 2 aukštas | Plastic - White
1309209 | 2 aukštas | Plastic - White
1309218 | 2 aukštas | Plastic - White
1309229 | 2 aukštas | Plastic - White
1309238 | 2 aukštas | Plastic - White
1309247 | 2 aukštas | Plastic - White
1309256 | 2 aukštas | Plastic - White
1309265 | 2 aukštas | Plastic - White
1309276 | 2 aukštas | Plastic - White
1309285 | 2 aukštas | Plastic - White
1309294 | 2 aukštas | Plastic - White
1309303 | 2 aukštas | Plastic - White
1309312 | 2 aukštas | Plastic - White
1309323 | 2 aukštas | Plastic - White
1309332 | 2 aukštas | Plastic - White
1309341 | 2 aukštas | Plastic - White
1309350 | 2 aukštas | Plastic - White
1309399 | 2 aukštas | Plastic - White
1309410 | 2 aukštas | Plastic - White
1309419 | 2 aukštas | Plastic - White
1309475 | 2 aukštas | Plastic - White
1309517 | 2 aukštas | Plastic - White
1309526 | 2 aukštas | Plastic - White
1309541 | 2 aukštas | Plastic - White
1309550 | 2 aukštas | Plastic - White
1309559 | 2 aukštas | Plastic - White
1309568 | 2 aukštas | Plastic - White
1309577 | 2 aukštas | Plastic - White
1309586 | 2 aukštas | Plastic - White
1309595 | 2 aukštas | Plastic - White
1309606 | 2 aukštas | Plastic - White
1309615 | 2 aukštas | Plastic - White
1309630 | 2 aukštas | Plastic - White
1309639 | 2 aukštas | Plastic - White
1309650 | 2 aukštas | Plastic - White
1309661 | 2 aukštas | Plastic - White
1309672 | 2 aukštas | Plastic - White
1309681 | 2 aukštas | Plastic - White
1309694 | 2 aukštas | Plastic - White
1309703 | 2 aukštas | Plastic - White
1309722 | 2 aukštas | Plastic - White
1309748 | 2 aukštas | Plastic - White
1309771 | 2 aukštas | Plastic - White
1309786 | 2 aukštas | Plastic - White
1309812 | 2 aukštas | Plastic - White
1309860 | 2 aukštas | Plastic - White
1309869 | 2 aukštas | Plastic - White
1309880 | 2 aukštas | Plastic - White
1309889 | 2 aukštas | Plastic - White
1309900 | 2 aukštas | Plastic - White
1309907 | 2 aukštas | Plastic - White
1309920 | 2 aukštas | Plastic - White
1309929 | 2 aukštas | Plastic - White
1309938 | 2 aukštas | Plastic - White
1309947 | 2 aukštas | Plastic - White
1309956 | 2 aukštas | Plastic - White
1309969 | 2 aukštas | Plastic - White
1309978 | 2 aukštas | Plastic - White
1309989 | 2 aukštas | Plastic - White
1309998 | 2 aukštas | Plastic - White
1310046 | 2 aukštas | Plastic - White
1310055 | 2 aukštas | Plastic - White
1310064 | 2 aukštas | Plastic - White
1310075 | 2 aukštas | Plastic - White
1310117 | 2 aukštas | Plastic - White
1310126 | 2 aukštas | Plastic - White
1310139 | 2 aukštas | Plastic - White
1310150 | 2 aukštas | Plastic - White
1310159 | 2 aukštas | Plastic - White
1310174 | 2 aukštas | Plastic - White
1310183 | 2 aukštas | Plastic - White
1310194 | 2 aukštas | Plastic - White
1310209 | 2 aukštas | Plastic - White
1310218 | 2 aukštas | Plastic - White
1310251 | 2 aukštas | Plastic - White
1310272 | 2 aukštas | Plastic - White
1310291 | 2 aukštas | Plastic - White
1310300 | 2 aukštas | Plastic - White
1310334 | 2 aukštas | Plastic - White
1310343 | 2 aukštas | Plastic - White
1310352 | 2 aukštas | Plastic - White
1310363 | 2 aukštas | Plastic - White
1310372 | 2 aukštas | Plastic - White
1310389 | 2 aukštas | Plastic - White
1310400 | 2 aukštas | Plastic - White
1310427 | 2 aukštas | Plastic - White
1310469 | 2 aukštas | Plastic - White
1310480 | 2 aukštas | Plastic - White
1310489 | 2 aukštas | Plastic - White
1310504 | 2 aukštas | Plastic - White
1310530 | 2 aukštas | Plastic - White
1310539 | 2 aukštas | Plastic - White
1310550 | 2 aukštas | Plastic - White
1310586 | 2 aukštas | Plastic - White
1310611 | 2 aukštas | Plastic - White
1310634 | 2 aukštas | Plastic - White
1310645 | 2 aukštas | Plastic - White
1310656 | 2 aukštas | Plastic - White
1310665 | 2 aukštas | Plastic - White
1310688 | 2 aukštas | Plastic - White
1310699 | 2 aukštas | Plastic - White
1310708 | 2 aukštas | Plastic - White
1310729 | 2 aukštas | Plastic - White
1310744 | 2 aukštas | Plastic - White
1310753 | 2 aukštas | Plastic - White
1310762 | 2 aukštas | Plastic - White
1310771 | 2 aukštas | Plastic - White
1310780 | 2 aukštas | Plastic - White
1310789 | 2 aukštas | Plastic - White
1310819 | 2 aukštas | Plastic - White
1310856 | 2 aukštas | Plastic - White
1310875 | 2 aukštas | Plastic - White
1310886 | 2 aukštas | Plastic - White
1310901 | 2 aukštas | Plastic - White
1310916 | 2 aukštas | Plastic - White
1310929 | 2 aukštas | Plastic - White
1310950 | 2 aukštas | Plastic - White
1310961 | 2 aukštas | Plastic - White
1310972 | 2 aukštas | Plastic - White
1310981 | 2 aukštas | Plastic - White
1310994 | 2 aukštas | Plastic - White
1312160 | 3 aukštas | Plastic - White
1312448 | 3 aukštas | Plastic - White
1312459 | 3 aukštas | Plastic - White
1312488 | 3 aukštas | Plastic - White
1312514 | 3 aukštas | Plastic - White
1312554 | 3 aukštas | Plastic - White
1312604 | 3 aukštas | Plastic - White
1312617 | 3 aukštas | Plastic - White
1312632 | 3 aukštas | Plastic - White
1312641 | 3 aukštas | Plastic - White
1312676 | 3 aukštas | Plastic - White
1312685 | 3 aukštas | Plastic - White
1312696 | 3 aukštas | Plastic - White
1312715 | 3 aukštas | Plastic - White
1314349 | 3 aukštas | Plastic - White
1314360 | 3 aukštas | Plastic - White
1314371 | 3 aukštas | Plastic - White
1314384 | 3 aukštas | Plastic - White
1314399 | 3 aukštas | Plastic - White
1314441 | 3 aukštas | Plastic - White
1314467 | 3 aukštas | Plastic - White
1314476 | 3 aukštas | Plastic - White
1314489 | 3 aukštas | Plastic - White
1314500 | 3 aukštas | Plastic - White
1314527 | 3 aukštas | Plastic - White
1314616 | 3 aukštas | Plastic - White
1314627 | 3 aukštas | Plastic - White
1314638 | 3 aukštas | Plastic - White
1314649 | 3 aukštas | Plastic - White
1314664 | 3 aukštas | Plastic - White
1314673 | 3 aukštas | Plastic - White
1314725 | 3 aukštas | Plastic - White
1314758 | 3 aukštas | Plastic - White
1314853 | 3 aukštas | Plastic - White
1314900 | 3 aukštas | Plastic - White
1314953 | 3 aukštas | Plastic - White
1314996 | 3 aukštas | Plastic - White
1315005 | 3 aukštas | Plastic - White
1315022 | 3 aukštas | Plastic - White
1315033 | 3 aukštas | Plastic - White
1315044 | 3 aukštas | Plastic - White
1315066 | 3 aukštas | Plastic - White
1315075 | 3 aukštas | Plastic - White
1315092 | 3 aukštas | Plastic - White
1315105 | 3 aukštas | Plastic - White
1315154 | 3 aukštas | Plastic - White
1315167 | 3 aukštas | Plastic - White
1315178 | 3 aukštas | Plastic - White
1315191 | 3 aukštas | Plastic - White
1315202 | 3 aukštas | Plastic - White
1315211 | 3 aukštas | Plastic - White
1315226 | 3 aukštas | Plastic - White
1315289 | 3 aukštas | Plastic - White
1315353 | 3 aukštas | Plastic - White
1315378 | 3 aukštas | Plastic - White
1315389 | 3 aukštas | Plastic - White
1315409 | 3 aukštas | Plastic - White
1315420 | 3 aukštas | Plastic - White
1315594 | 3 aukštas | Plastic - White
1315609 | 3 aukštas | Plastic - White
1315618 | 3 aukštas | Plastic - White
1315631 | 3 aukštas | Plastic - White
1315747 | 3 aukštas | Plastic - White
1315756 | 3 aukštas | Plastic - White
1315765 | 3 aukštas | Plastic - White
1315774 | 3 aukštas | Plastic - White
1315785 | 3 aukštas | Plastic - White
1315794 | 3 aukštas | Plastic - White
1315803 | 3 aukštas | Plastic - White
1315812 | 3 aukštas | Plastic - White
1315821 | 3 aukštas | Plastic - White
1315830 | 3 aukštas | Plastic - White
1315843 | 3 aukštas | Plastic - White
1315856 | 3 aukštas | Plastic - White
1315869 | 3 aukštas | Plastic - White
1315882 | 3 aukštas | Plastic - White
1315891 | 3 aukštas | Plastic - White
1315900 | 3 aukštas | Plastic - White
1315941 | 3 aukštas | Plastic - White
1316021 | 3 aukštas | Plastic - White
1316032 | 3 aukštas | Plastic - White
1316041 | 3 aukštas | Plastic - White
1316069 | 3 aukštas | Plastic - White
1316095 | 3 aukštas | Plastic - White
1316108 | 3 aukštas | Plastic - White
1316144 | 3 aukštas | Plastic - White
1316153 | 3 aukštas | Plastic - White
1316162 | 3 aukštas | Plastic - White
1316173 | 3 aukštas | Plastic - White
1316262 | 3 aukštas | Plastic - White
1316290 | 3 aukštas | Plastic - White
1316327 | 3 aukštas | Plastic - White
1316606 | 3 aukštas | Plastic - White
1316614 | 3 aukštas | Plastic - White
1316775 | 4 aukštas | Plastic - White
1317192 | 4 aukštas | Plastic - White
1317227 | 4 aukštas | Plastic - White
1317248 | 4 aukštas | Plastic - White
1319220 | 4 aukštas | Plastic - White
1319233 | 4 aukštas | Plastic - White
1319280 | 4 aukštas | Plastic - White
1319282 | 4 aukštas | Plastic - White
1319344 | 4 aukštas | Plastic - White
1319373 | 4 aukštas | Plastic - White
1319384 | 4 aukštas | Plastic - White
1319518 | 4 aukštas | Plastic - White
1319654 | 4 aukštas | Plastic - White
1319729 | 4 aukštas | Plastic - White
1319768 | 4 aukštas | Plastic - White
1319779 | 4 aukštas | Plastic - White
1319790 | 4 aukštas | Plastic - White
1319801 | 4 aukštas | Plastic - White
1319812 | 4 aukštas | Plastic - White
1319821 | 4 aukštas | Plastic - White
1319832 | 4 aukštas | Plastic - White
1319845 | 4 aukštas | Plastic - White
1319894 | 4 aukštas | Plastic - White
1319909 | 4 aukštas | Plastic - White
1319940 | 4 aukštas | Plastic - White
1319949 | 4 aukštas | Plastic - White
1319958 | 4 aukštas | Plastic - White
1319969 | 4 aukštas | Plastic - White
1319978 | 4 aukštas | Plastic - White
1320027 | 4 aukštas | Plastic - White
1320036 | 4 aukštas | Plastic - White
1320045 | 4 aukštas | Plastic - White
1320056 | 4 aukštas | Plastic - White
1320065 | 4 aukštas | Plastic - White
1320113 | 4 aukštas | Plastic - White
1320180 | 4 aukštas | Plastic - White
1320230 | 4 aukštas | Plastic - White
1320243 | 4 aukštas | Plastic - White
1320252 | 4 aukštas | Plastic - White
1320261 | 4 aukštas | Plastic - White
1320270 | 4 aukštas | Plastic - White
1320281 | 4 aukštas | Plastic - White
1320290 | 4 aukštas | Plastic - White
1320301 | 4 aukštas | Plastic - White
1320310 | 4 aukštas | Plastic - White
1320319 | 4 aukštas | Plastic - White
1320328 | 4 aukštas | Plastic - White
1320549 | 4 aukštas | Plastic - White
1320564 | 4 aukštas | Plastic - White
1320588 | 4 aukštas | Plastic - White
1320619 | 4 aukštas | Plastic - White
1320678 | 4 aukštas | Plastic - White
1320687 | 4 aukštas | Plastic - White
1320696 | 4 aukštas | Plastic - White
1320705 | 4 aukštas | Plastic - White
1320714 | 4 aukštas | Plastic - White
1320723 | 4 aukštas | Plastic - White
1320734 | 4 aukštas | Plastic - White
1320743 | 4 aukštas | Plastic - White
1320752 | 4 aukštas | Plastic - White
1320763 | 4 aukštas | Plastic - White
1320774 | 4 aukštas | Plastic - White
1320783 | 4 aukštas | Plastic - White
1320794 | 4 aukštas | Plastic - White
1320803 | 4 aukštas | Plastic - White
1320814 | 4 aukštas | Plastic - White
1320825 | 4 aukštas | Plastic - White
1320834 | 4 aukštas | Plastic - White
1320865 | 4 aukštas | Plastic - White
1320874 | 4 aukštas | Plastic - White
1320885 | 4 aukštas | Plastic - White
1320896 | 4 aukštas | Plastic - White
1320911 | 4 aukštas | Plastic - White
1320924 | 4 aukštas | Plastic - White
1320933 | 4 aukštas | Plastic - White
1320944 | 4 aukštas | Plastic - White
1320957 | 4 aukštas | Plastic - White
1320974 | 4 aukštas | Plastic - White
1320985 | 4 aukštas | Plastic - White
1321028 | 4 aukštas | Plastic - White
1321043 | 4 aukštas | Plastic - White
1321072 | 4 aukštas | Plastic - White
1321081 | 4 aukštas | Plastic - White
1321116 | 4 aukštas | Plastic - White
1321125 | 4 aukštas | Plastic - White
1321138 | 4 aukštas | Plastic - White
1321166 | 4 aukštas | Plastic - White
1321225 | 4 aukštas | Plastic - White
1321276 | 4 aukštas | Plastic - White
1321309 | 4 aukštas | Plastic - White
1321322 | 4 aukštas | Plastic - White
1321365 | 4 aukštas | Plastic - White
1321380 | 4 aukštas | Plastic - White
1321389 | 4 aukštas | Plastic - White
1321400 | 4 aukštas | Plastic - White
1321409 | 4 aukštas | Plastic - White
1321426 | 4 aukštas | Plastic - White
1321435 | 4 aukštas | Plastic - White
1321455 | 4 aukštas | Plastic - White
1321464 | 4 aukštas | Plastic - White
1321473 | 4 aukštas | Plastic - White
1321506 | 4 aukštas | Plastic - White
1321517 | 4 aukštas | Plastic - White
1321528 | 4 aukštas | Plastic - White
1321565 | 4 aukštas | Plastic - White
1321576 | 4 aukštas | Plastic - White
1321589 | 4 aukštas | Plastic - White
1321613 | 4 aukštas | Plastic - White
1321624 | 4 aukštas | Plastic - White
1321635 | 4 aukštas | Plastic - White
1321648 | 4 aukštas | Plastic - White
1321663 | 4 aukštas | Plastic - White
1321674 | 4 aukštas | Plastic - White
1321687 | 4 aukštas | Plastic - White
1321700 | 4 aukštas | Plastic - White
1321711 | 4 aukštas | Plastic - White
1321722 | 4 aukštas | Plastic - White
1321739 | 4 aukštas | Plastic - White
1321748 | 4 aukštas | Plastic - White
1321757 | 4 aukštas | Plastic - White
1321766 | 4 aukštas | Plastic - White
1322036 | 5 aukštas | Plastic - White
1322348 | 5 aukštas | Plastic - White
1322368 | 5 aukštas | Plastic - White
1322422 | 5 aukštas | Plastic - White
1322431 | 5 aukštas | Plastic - White
1322463 | 5 aukštas | Plastic - White
1322472 | 5 aukštas | Plastic - White
1322481 | 5 aukštas | Plastic - White
1322492 | 5 aukštas | Plastic - White
1322501 | 5 aukštas | Plastic - White
1322510 | 5 aukštas | Plastic - White
1322519 | 5 aukštas | Plastic - White
1322528 | 5 aukštas | Plastic - White
1322537 | 5 aukštas | Plastic - White
1322554 | 5 aukštas | Plastic - White
1322563 | 5 aukštas | Plastic - White
1322572 | 5 aukštas | Plastic - White
1322581 | 5 aukštas | Plastic - White
1322590 | 5 aukštas | Plastic - White
1322599 | 5 aukštas | Plastic - White
1322610 | 5 aukštas | Plastic - White
1322623 | 5 aukštas | Plastic - White
1322634 | 5 aukštas | Plastic - White
1322643 | 5 aukštas | Plastic - White
1322652 | 5 aukštas | Plastic - White
1322661 | 5 aukštas | Plastic - White
1322680 | 5 aukštas | Plastic - White
1322689 | 5 aukštas | Plastic - White
1322698 | 5 aukštas | Plastic - White
1322707 | 5 aukštas | Plastic - White
1322716 | 5 aukštas | Plastic - White
1322725 | 5 aukštas | Plastic - White
1322736 | 5 aukštas | Plastic - White
1322745 | 5 aukštas | Plastic - White
1322758 | 5 aukštas | Plastic - White
1322771 | 5 aukštas | Plastic - White
1322780 | 5 aukštas | Plastic - White
1322793 | 5 aukštas | Plastic - White
1322804 | 5 aukštas | Plastic - White
1322813 | 5 aukštas | Plastic - White
1322822 | 5 aukštas | Plastic - White
1322831 | 5 aukštas | Plastic - White
1322840 | 5 aukštas | Plastic - White
1322849 | 5 aukštas | Plastic - White
1322858 | 5 aukštas | Plastic - White
1322871 | 5 aukštas | Plastic - White
1322882 | 5 aukštas | Plastic - White
1322891 | 5 aukštas | Plastic - White
1322902 | 5 aukštas | Plastic - White
1322911 | 5 aukštas | Plastic - White
1322920 | 5 aukštas | Plastic - White
1322931 | 5 aukštas | Plastic - White
1322942 | 5 aukštas | Plastic - White
1324551 | 5 aukštas | Plastic - White
1324609 | 4 aukštas | Plastic - White
1344427 | 4 aukštas | Plastic - White
1462413 | Rūsys | Plastic - White
1462414 | Rūsys | Plastic - White
1462415 | Rūsys | Plastic - White
1462416 | Rūsys | Plastic - White
1462417 | Rūsys | Plastic - White
1462418 | 1 aukštas | Plastic - White
1462419 | 1 aukštas | Plastic - White
1462421 | 1 aukštas | Plastic - White
1462423 | 1 aukštas | Plastic - White
1462425 | 1 aukštas | Plastic - White
1462427 | 1 aukštas | Plastic - White
1462429 | 1 aukštas | Plastic - White
1462431 | 1 aukštas | Plastic - White
1462433 | 1 aukštas | Plastic - White
1462556 | 2 aukštas | Plastic - White
1462673 | 2 aukštas | Plastic - White
1462832 | 3 aukštas | Plastic - White
1462867 | 3 aukštas | Plastic - White
1462997 | 3 aukštas | Plastic - White
1463005 | 3 aukštas | Plastic - White
1463013 | 3 aukštas | Plastic - White
1463021 | 3 aukštas | Plastic - White
1463170 | 4 aukštas | Plastic - White
1463242 | 4 aukštas | Plastic - White
1463689 | 4 aukštas | Plastic - White
1549770 | 1 aukštas | Plastic - White
1552243 | 2 aukštas | Plastic - White
1552443 | 4 aukštas | Plastic - White
1552462 | 4 aukštas | Plastic - White
1552471 | 4 aukštas | Plastic - White
1552480 | 4 aukštas | Plastic - White
1552489 | 4 aukštas | Plastic - White
1552498 | 4 aukštas | Plastic - White
1552631 | 5 aukštas | Plastic - White
1552724 | 5 aukštas | Plastic - White
1552735 | 5 aukštas | Plastic - White
1552746 | 5 aukštas | Plastic - White
1552755 | 5 aukštas | Plastic - White
1552764 | 5 aukštas | Plastic - White
1552901 | 5 aukštas | Plastic - White
1552958 | 5 aukštas | Plastic - White
1569062 | Rūsys | Plastic - White
2041344 | Rūsys | Plastic - White
2041426 | Rūsys | Plastic - White
2041493 | 1 aukštas | Plastic - White
2043438 | 1 aukštas | Plastic - White
2044013 | 5 aukštas | Plastic - White
2044238 | 5 aukštas | Plastic - White
2044269 | 5 aukštas | Plastic - White
2192674 | 2 aukštas | Plastic - White
2200117 | Rūsys | Plastic - White
2201391 | Rūsys | Plastic - White
2235496 | Rūsys | Plastic - White
2281604 | 5 aukštas | Plastic - White

# IfcDistributionControlElement: GSS_Detektorius:01_Optinis dūmų detektorius po ortakiu (3)
In: Rūsys
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: 01_Optinis dūmų detektorius po ortakiu
Name (GSS_Detektorius:01_Optinis dūmų detektorius po ortakiu:...) | Material
1568723
1568971 | Plastic - White
2236285 | Plastic - White

# IfcDistributionControlElement: GSS_Detektorius:03_Optinis dūmų detektorius su indikatorium (605)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: 03_Optinis dūmų detektorius su indikatorium
Name (GSS_Detektorius:03_Optinis dūmų detektorius su indikatorium:...) | In | Material
1300149 | 1 aukštas
1300662 | 1 aukštas | Plastic - White
1300749 | 1 aukštas | Plastic - White
1300758 | 1 aukštas | Plastic - White
1300851 | 1 aukštas | Plastic - White
1300861 | 1 aukštas | Plastic - White
1300905 | 1 aukštas | Plastic - White
1301050 | 1 aukštas | Plastic - White
1301078 | 1 aukštas | Plastic - White
1301105 | 1 aukštas | Plastic - White
1301132 | 1 aukštas | Plastic - White
1301157 | 1 aukštas | Plastic - White
1301214 | 1 aukštas | Plastic - White
1301248 | 1 aukštas | Plastic - White
1301301 | 1 aukštas | Plastic - White
1301327 | 1 aukštas
1301365 | 1 aukštas | Plastic - White
1301406 | 1 aukštas | Plastic - White
1301435 | 1 aukštas | Plastic - White
1301457 | 1 aukštas | Plastic - White
1301486 | 1 aukštas | Plastic - White
1301527 | 1 aukštas | Plastic - White
1301564 | 1 aukštas | Plastic - White
1301575 | 1 aukštas | Plastic - White
1301620 | 1 aukštas | Plastic - White
1301647 | 1 aukštas | Plastic - White
1301685 | 1 aukštas | Plastic - White
1301708 | 1 aukštas | Plastic - White
1301749 | 1 aukštas | Plastic - White
1301785 | 1 aukštas | Plastic - White
1302374 | 1 aukštas | Plastic - White
1302387 | 1 aukštas | Plastic - White
1302409 | 1 aukštas | Plastic - White
1302430 | 1 aukštas | Plastic - White
1302441 | 1 aukštas | Plastic - White
1302587 | 1 aukštas | Plastic - White
1302604 | 1 aukštas | Plastic - White
1302613 | 1 aukštas | Plastic - White
1302624 | 1 aukštas | Plastic - White
1302633 | 1 aukštas | Plastic - White
1302644 | 1 aukštas | Plastic - White
1302655 | 1 aukštas | Plastic - White
1302709 | 1 aukštas | Plastic - White
1302720 | 1 aukštas | Plastic - White
1302731 | 1 aukštas | Plastic - White
1302744 | 1 aukštas | Plastic - White
1302755 | 1 aukštas | Plastic - White
1302827 | 1 aukštas | Plastic - White
1307419 | 2 aukštas | Plastic - White
1307442 | 2 aukštas | Plastic - White
1307451 | 2 aukštas | Plastic - White
1307462 | 2 aukštas | Plastic - White
1307611 | 2 aukštas | Plastic - White
1307622 | 2 aukštas | Plastic - White
1307637 | 2 aukštas | Plastic - White
1307677 | 2 aukštas | Plastic - White
1307688 | 2 aukštas | Plastic - White
1307697 | 2 aukštas | Plastic - White
1307706 | 2 aukštas | Plastic - White
1307715 | 2 aukštas | Plastic - White
1307726 | 2 aukštas | Plastic - White
1307735 | 2 aukštas | Plastic - White
1307750 | 2 aukštas | Plastic - White
1307776 | 2 aukštas | Plastic - White
1307905 | 2 aukštas | Plastic - White
1307938 | 2 aukštas | Plastic - White
1308061 | 2 aukštas | Plastic - White
1308286 | 2 aukštas | Plastic - White
1308641 | 2 aukštas | Plastic - White
1308672 | 2 aukštas | Plastic - White
1308702 | 2 aukštas | Plastic - White
1308713 | 2 aukštas | Plastic - White
1308722 | 2 aukštas | Plastic - White
1308737 | 2 aukštas | Plastic - White
1308759 | 2 aukštas | Plastic - White
1308768 | 2 aukštas | Plastic - White
1308779 | 2 aukštas | Plastic - White
1308792 | 2 aukštas | Plastic - White
1308813 | 2 aukštas | Plastic - White
1308824 | 2 aukštas | Plastic - White
1308869 | 2 aukštas | Plastic - White
1308884 | 2 aukštas | Plastic - White
1308893 | 2 aukštas | Plastic - White
1308956 | 2 aukštas | Plastic - White
1308985 | 2 aukštas | Plastic - White
1309018 | 2 aukštas | Plastic - White
1309027 | 2 aukštas | Plastic - White
1309036 | 2 aukštas | Plastic - White
1309081 | 2 aukštas | Plastic - White
1309090 | 2 aukštas | Plastic - White
1309099 | 2 aukštas | Plastic - White
1309108 | 2 aukštas | Plastic - White
1309117 | 2 aukštas | Plastic - White
1309126 | 2 aukštas | Plastic - White
1309135 | 2 aukštas | Plastic - White
1309144 | 2 aukštas | Plastic - White
1309157 | 2 aukštas | Plastic - White
1309166 | 2 aukštas | Plastic - White
1309175 | 2 aukštas | Plastic - White
1309188 | 2 aukštas | Plastic - White
1309199 | 2 aukštas | Plastic - White
1309210 | 2 aukštas | Plastic - White
1309219 | 2 aukštas | Plastic - White
1309230 | 2 aukštas | Plastic - White
1309239 | 2 aukštas | Plastic - White
1309248 | 2 aukštas | Plastic - White
1309257 | 2 aukštas | Plastic - White
1309266 | 2 aukštas | Plastic - White
1309277 | 2 aukštas | Plastic - White
1309286 | 2 aukštas | Plastic - White
1309295 | 2 aukštas | Plastic - White
1309304 | 2 aukštas | Plastic - White
1309313 | 2 aukštas | Plastic - White
1309324 | 2 aukštas | Plastic - White
1309333 | 2 aukštas | Plastic - White
1309342 | 2 aukštas | Plastic - White
1309351 | 2 aukštas | Plastic - White
1309400 | 2 aukštas | Plastic - White
1309411 | 2 aukštas | Plastic - White
1309420 | 2 aukštas | Plastic - White
1309476 | 2 aukštas | Plastic - White
1309518 | 2 aukštas | Plastic - White
1309527 | 2 aukštas | Plastic - White
1309542 | 2 aukštas | Plastic - White
1309551 | 2 aukštas | Plastic - White
1309560 | 2 aukštas | Plastic - White
1309569 | 2 aukštas | Plastic - White
1309578 | 2 aukštas | Plastic - White
1309587 | 2 aukštas | Plastic - White
1309596 | 2 aukštas | Plastic - White
1309607 | 2 aukštas | Plastic - White
1309616 | 2 aukštas | Plastic - White
1309631 | 2 aukštas | Plastic - White
1309640 | 2 aukštas | Plastic - White
1309651 | 2 aukštas | Plastic - White
1309662 | 2 aukštas | Plastic - White
1309673 | 2 aukštas | Plastic - White
1309682 | 2 aukštas | Plastic - White
1309695 | 2 aukštas | Plastic - White
1309704 | 2 aukštas | Plastic - White
1309723 | 2 aukštas | Plastic - White
1309749 | 2 aukštas | Plastic - White
1309772 | 2 aukštas | Plastic - White
1309787 | 2 aukštas | Plastic - White
1309813 | 2 aukštas | Plastic - White
1309861 | 2 aukštas | Plastic - White
1309870 | 2 aukštas | Plastic - White
1309881 | 2 aukštas | Plastic - White
1309890 | 2 aukštas | Plastic - White
1309901 | 2 aukštas | Plastic - White
1309908 | 2 aukštas | Plastic - White
1309921 | 2 aukštas | Plastic - White
1309930 | 2 aukštas | Plastic - White
1309939 | 2 aukštas | Plastic - White
1309948 | 2 aukštas | Plastic - White
1309957 | 2 aukštas | Plastic - White
1309970 | 2 aukštas | Plastic - White
1309979 | 2 aukštas | Plastic - White
1309990 | 2 aukštas | Plastic - White
1309999 | 2 aukštas | Plastic - White
1310047 | 2 aukštas | Plastic - White
1310056 | 2 aukštas | Plastic - White
1310065 | 2 aukštas | Plastic - White
1310076 | 2 aukštas | Plastic - White
1310118 | 2 aukštas | Plastic - White
1310127 | 2 aukštas | Plastic - White
1310140 | 2 aukštas | Plastic - White
1310151 | 2 aukštas | Plastic - White
1310160 | 2 aukštas | Plastic - White
1310175 | 2 aukštas | Plastic - White
1310184 | 2 aukštas | Plastic - White
1310195 | 2 aukštas | Plastic - White
1310210 | 2 aukštas | Plastic - White
1310219 | 2 aukštas | Plastic - White
1310252 | 2 aukštas | Plastic - White
1310273 | 2 aukštas | Plastic - White
1310292 | 2 aukštas | Plastic - White
1310301 | 2 aukštas | Plastic - White
1310335 | 2 aukštas | Plastic - White
1310344 | 2 aukštas | Plastic - White
1310353 | 2 aukštas | Plastic - White
1310364 | 2 aukštas | Plastic - White
1310373 | 2 aukštas | Plastic - White
1310390 | 2 aukštas | Plastic - White
1310401 | 2 aukštas | Plastic - White
1310428 | 2 aukštas | Plastic - White
1310470 | 2 aukštas | Plastic - White
1310481 | 2 aukštas | Plastic - White
1310490 | 2 aukštas | Plastic - White
1310505 | 2 aukštas | Plastic - White
1310531 | 2 aukštas | Plastic - White
1310540 | 2 aukštas | Plastic - White
1310551 | 2 aukštas | Plastic - White
1310587 | 2 aukštas | Plastic - White
1310612 | 2 aukštas | Plastic - White
1310635 | 2 aukštas | Plastic - White
1310646 | 2 aukštas | Plastic - White
1310657 | 2 aukštas | Plastic - White
1310666 | 2 aukštas | Plastic - White
1310689 | 2 aukštas | Plastic - White
1310700 | 2 aukštas | Plastic - White
1310709 | 2 aukštas | Plastic - White
1310730 | 2 aukštas | Plastic - White
1310745 | 2 aukštas | Plastic - White
1310754 | 2 aukštas | Plastic - White
1310763 | 2 aukštas | Plastic - White
1310772 | 2 aukštas | Plastic - White
1310781 | 2 aukštas | Plastic - White
1310790 | 2 aukštas | Plastic - White
1310820 | 2 aukštas | Plastic - White
1310857 | 2 aukštas | Plastic - White
1310876 | 2 aukštas | Plastic - White
1310902 | 2 aukštas | Plastic - White
1310917 | 2 aukštas | Plastic - White
1310930 | 2 aukštas | Plastic - White
1310951 | 2 aukštas | Plastic - White
1310962 | 2 aukštas | Plastic - White
1310973 | 2 aukštas | Plastic - White
1310982 | 2 aukštas | Plastic - White
1310995 | 2 aukštas | Plastic - White
1311988 | 3 aukštas | Plastic - White
1312447 | 3 aukštas | Plastic - White
1312458 | 3 aukštas | Plastic - White
1312487 | 3 aukštas | Plastic - White
1312513 | 3 aukštas | Plastic - White
1312603 | 3 aukštas | Plastic - White
1312616 | 3 aukštas | Plastic - White
1312631 | 3 aukštas | Plastic - White
1312640 | 3 aukštas | Plastic - White
1312675 | 3 aukštas | Plastic - White
1312684 | 3 aukštas | Plastic - White
1312695 | 3 aukštas | Plastic - White
1312714 | 3 aukštas | Plastic - White
1314348 | 3 aukštas | Plastic - White
1314359 | 3 aukštas | Plastic - White
1314370 | 3 aukštas | Plastic - White
1314383 | 3 aukštas | Plastic - White
1314398 | 3 aukštas | Plastic - White
1314440 | 3 aukštas | Plastic - White
1314466 | 3 aukštas | Plastic - White
1314475 | 3 aukštas | Plastic - White
1314488 | 3 aukštas | Plastic - White
1314499 | 3 aukštas | Plastic - White
1314526 | 3 aukštas | Plastic - White
1314626 | 3 aukštas | Plastic - White
1314637 | 3 aukštas | Plastic - White
1314648 | 3 aukštas | Plastic - White
1314663 | 3 aukštas | Plastic - White
1314672 | 3 aukštas | Plastic - White
1314724 | 3 aukštas | Plastic - White
1314757 | 3 aukštas | Plastic - White
1314852 | 3 aukštas | Plastic - White
1314899 | 3 aukštas | Plastic - White
1314952 | 3 aukštas | Plastic - White
1314995 | 3 aukštas | Plastic - White
1315004 | 3 aukštas | Plastic - White
1315021 | 3 aukštas | Plastic - White
1315032 | 3 aukštas | Plastic - White
1315043 | 3 aukštas | Plastic - White
1315065 | 3 aukštas | Plastic - White
1315074 | 3 aukštas | Plastic - White
1315091 | 3 aukštas | Plastic - White
1315104 | 3 aukštas | Plastic - White
1315153 | 3 aukštas | Plastic - White
1315166 | 3 aukštas | Plastic - White
1315177 | 3 aukštas | Plastic - White
1315190 | 3 aukštas | Plastic - White
1315201 | 3 aukštas | Plastic - White
1315210 | 3 aukštas | Plastic - White
1315225 | 3 aukštas | Plastic - White
1315288 | 3 aukštas | Plastic - White
1315352 | 3 aukštas | Plastic - White
1315377 | 3 aukštas | Plastic - White
1315388 | 3 aukštas | Plastic - White
1315408 | 3 aukštas | Plastic - White
1315419 | 3 aukštas | Plastic - White
1315593 | 3 aukštas | Plastic - White
1315608 | 3 aukštas | Plastic - White
1315617 | 3 aukštas | Plastic - White
1315630 | 3 aukštas | Plastic - White
1315746 | 3 aukštas | Plastic - White
1315755 | 3 aukštas | Plastic - White
1315764 | 3 aukštas | Plastic - White
1315773 | 3 aukštas | Plastic - White
1315784 | 3 aukštas | Plastic - White
1315793 | 3 aukštas | Plastic - White
1315802 | 3 aukštas | Plastic - White
1315811 | 3 aukštas | Plastic - White
1315820 | 3 aukštas | Plastic - White
1315829 | 3 aukštas | Plastic - White
1315842 | 3 aukštas | Plastic - White
1315855 | 3 aukštas | Plastic - White
1315868 | 3 aukštas | Plastic - White
1315881 | 3 aukštas | Plastic - White
1315890 | 3 aukštas | Plastic - White
1315899 | 3 aukštas | Plastic - White
1315940 | 3 aukštas | Plastic - White
1316020 | 3 aukštas | Plastic - White
1316031 | 3 aukštas | Plastic - White
1316040 | 3 aukštas | Plastic - White
1316068 | 3 aukštas | Plastic - White
1316094 | 3 aukštas | Plastic - White
1316107 | 3 aukštas | Plastic - White
1316143 | 3 aukštas | Plastic - White
1316152 | 3 aukštas | Plastic - White
1316161 | 3 aukštas | Plastic - White
1316172 | 3 aukštas | Plastic - White
1316261 | 3 aukštas | Plastic - White
1316289 | 3 aukštas | Plastic - White
1316326 | 3 aukštas | Plastic - White
1316897 | 4 aukštas | Plastic - White
1317193 | 4 aukštas | Plastic - White
1317228 | 4 aukštas | Plastic - White
1317249 | 4 aukštas | Plastic - White
1319221 | 4 aukštas | Plastic - White
1319234 | 4 aukštas | Plastic - White
1319281 | 4 aukštas | Plastic - White
1319283 | 4 aukštas | Plastic - White
1319345 | 4 aukštas | Plastic - White
1319374 | 4 aukštas | Plastic - White
1319385 | 4 aukštas | Plastic - White
1319519 | 4 aukštas | Plastic - White
1319730 | 4 aukštas | Plastic - White
1319769 | 4 aukštas | Plastic - White
1319780 | 4 aukštas | Plastic - White
1319791 | 4 aukštas | Plastic - White
1319802 | 4 aukštas | Plastic - White
1319813 | 4 aukštas | Plastic - White
1319822 | 4 aukštas | Plastic - White
1319833 | 4 aukštas | Plastic - White
1319846 | 4 aukštas | Plastic - White
1319895 | 4 aukštas | Plastic - White
1319910 | 4 aukštas | Plastic - White
1319941 | 4 aukštas | Plastic - White
1319950 | 4 aukštas | Plastic - White
1319959 | 4 aukštas | Plastic - White
1319970 | 4 aukštas | Plastic - White
1319979 | 4 aukštas | Plastic - White
1320028 | 4 aukštas | Plastic - White
1320037 | 4 aukštas | Plastic - White
1320046 | 4 aukštas | Plastic - White
1320057 | 4 aukštas | Plastic - White
1320066 | 4 aukštas | Plastic - White
1320114 | 4 aukštas | Plastic - White
1320181 | 4 aukštas | Plastic - White
1320231 | 4 aukštas | Plastic - White
1320244 | 4 aukštas | Plastic - White
1320253 | 4 aukštas | Plastic - White
1320262 | 4 aukštas | Plastic - White
1320271 | 4 aukštas | Plastic - White
1320282 | 4 aukštas | Plastic - White
1320291 | 4 aukštas | Plastic - White
1320302 | 4 aukštas | Plastic - White
1320311 | 4 aukštas | Plastic - White
1320320 | 4 aukštas | Plastic - White
1320329 | 4 aukštas | Plastic - White
1320550 | 4 aukštas | Plastic - White
1320565 | 4 aukštas | Plastic - White
1320589 | 4 aukštas | Plastic - White
1320620 | 4 aukštas | Plastic - White
1320679 | 4 aukštas | Plastic - White
1320688 | 4 aukštas | Plastic - White
1320697 | 4 aukštas | Plastic - White
1320706 | 4 aukštas | Plastic - White
1320715 | 4 aukštas | Plastic - White
1320724 | 4 aukštas | Plastic - White
1320735 | 4 aukštas | Plastic - White
1320744 | 4 aukštas | Plastic - White
1320753 | 4 aukštas | Plastic - White
1320764 | 4 aukštas | Plastic - White
1320775 | 4 aukštas | Plastic - White
1320784 | 4 aukštas | Plastic - White
1320795 | 4 aukštas | Plastic - White
1320804 | 4 aukštas | Plastic - White
1320815 | 4 aukštas | Plastic - White
1320826 | 4 aukštas | Plastic - White
1320835 | 4 aukštas | Plastic - White
1320866 | 4 aukštas | Plastic - White
1320875 | 4 aukštas | Plastic - White
1320886 | 4 aukštas | Plastic - White
1320897 | 4 aukštas | Plastic - White
1320912 | 4 aukštas | Plastic - White
1320925 | 4 aukštas | Plastic - White
1320934 | 4 aukštas | Plastic - White
1320945 | 4 aukštas | Plastic - White
1320958 | 4 aukštas | Plastic - White
1320975 | 4 aukštas | Plastic - White
1320986 | 4 aukštas | Plastic - White
1321029 | 4 aukštas | Plastic - White
1321044 | 4 aukštas | Plastic - White
1321073 | 4 aukštas | Plastic - White
1321082 | 4 aukštas | Plastic - White
1321117 | 4 aukštas | Plastic - White
1321126 | 4 aukštas | Plastic - White
1321139 | 4 aukštas | Plastic - White
1321167 | 4 aukštas | Plastic - White
1321226 | 4 aukštas | Plastic - White
1321277 | 4 aukštas | Plastic - White
1321310 | 4 aukštas | Plastic - White
1321323 | 4 aukštas | Plastic - White
1321366 | 4 aukštas | Plastic - White
1321381 | 4 aukštas | Plastic - White
1321390 | 4 aukštas | Plastic - White
1321410 | 4 aukštas | Plastic - White
1321427 | 4 aukštas | Plastic - White
1321436 | 4 aukštas | Plastic - White
1321456 | 4 aukštas | Plastic - White
1321465 | 4 aukštas | Plastic - White
1321474 | 4 aukštas | Plastic - White
1321507 | 4 aukštas | Plastic - White
1321518 | 4 aukštas | Plastic - White
1321529 | 4 aukštas | Plastic - White
1321566 | 4 aukštas | Plastic - White
1321577 | 4 aukštas | Plastic - White
1321590 | 4 aukštas | Plastic - White
1321614 | 4 aukštas | Plastic - White
1321625 | 4 aukštas | Plastic - White
1321636 | 4 aukštas | Plastic - White
1321649 | 4 aukštas | Plastic - White
1321664 | 4 aukštas | Plastic - White
1321675 | 4 aukštas | Plastic - White
1321688 | 4 aukštas | Plastic - White
1321701 | 4 aukštas | Plastic - White
1321712 | 4 aukštas | Plastic - White
1321723 | 4 aukštas | Plastic - White
1321740 | 4 aukštas | Plastic - White
1321749 | 4 aukštas | Plastic - White
1321758 | 4 aukštas | Plastic - White
1321767 | 4 aukštas | Plastic - White
1322347 | 5 aukštas | Plastic - White
1322367 | 5 aukštas | Plastic - White
1322421 | 5 aukštas | Plastic - White
1322430 | 5 aukštas | Plastic - White
1322462 | 5 aukštas | Plastic - White
1322471 | 5 aukštas | Plastic - White
1322480 | 5 aukštas | Plastic - White
1322491 | 5 aukštas | Plastic - White
1322500 | 5 aukštas | Plastic - White
1322509 | 5 aukštas | Plastic - White
1322518 | 5 aukštas | Plastic - White
1322527 | 5 aukštas | Plastic - White
1322536 | 5 aukštas | Plastic - White
1322553 | 5 aukštas | Plastic - White
1322562 | 5 aukštas | Plastic - White
1322571 | 5 aukštas | Plastic - White
1322580 | 5 aukštas | Plastic - White
1322589 | 5 aukštas | Plastic - White
1322598 | 5 aukštas | Plastic - White
1322609 | 5 aukštas | Plastic - White
1322622 | 5 aukštas | Plastic - White
1322633 | 5 aukštas | Plastic - White
1322642 | 5 aukštas | Plastic - White
1322651 | 5 aukštas | Plastic - White
1322660 | 5 aukštas | Plastic - White
1322679 | 5 aukštas | Plastic - White
1322688 | 5 aukštas | Plastic - White
1322697 | 5 aukštas | Plastic - White
1322706 | 5 aukštas | Plastic - White
1322715 | 5 aukštas | Plastic - White
1322724 | 5 aukštas | Plastic - White
1322735 | 5 aukštas | Plastic - White
1322744 | 5 aukštas | Plastic - White
1322757 | 5 aukštas | Plastic - White
1322770 | 5 aukštas | Plastic - White
1322803 | 5 aukštas | Plastic - White
1322812 | 5 aukštas | Plastic - White
1322821 | 5 aukštas | Plastic - White
1322830 | 5 aukštas | Plastic - White
1322839 | 5 aukštas | Plastic - White
1322848 | 5 aukštas | Plastic - White
1322857 | 5 aukštas | Plastic - White
1322870 | 5 aukštas | Plastic - White
1322881 | 5 aukštas | Plastic - White
1322890 | 5 aukštas | Plastic - White
1322901 | 5 aukštas | Plastic - White
1322910 | 5 aukštas | Plastic - White
1322919 | 5 aukštas | Plastic - White
1322930 | 5 aukštas | Plastic - White
1322941 | 5 aukštas | Plastic - White
1324550 | 5 aukštas | Plastic - White
1324610 | 4 aukštas | Plastic - White
1344428 | 4 aukštas | Plastic - White
1462420 | 1 aukštas | Plastic - White
1462422 | 1 aukštas | Plastic - White
1462424 | 1 aukštas | Plastic - White
1462426 | 1 aukštas | Plastic - White
1462428 | 1 aukštas | Plastic - White
1462430 | 1 aukštas | Plastic - White
1462432 | 1 aukštas | Plastic - White
1462434 | 1 aukštas | Plastic - White
1462557 | 2 aukštas | Plastic - White
1462674 | 2 aukštas | Plastic - White
1462831 | 3 aukštas | Plastic - White
1462866 | 3 aukštas | Plastic - White
1463431 | 4 aukštas | Plastic - White
1463481 | 4 aukštas | Plastic - White
1463690 | 4 aukštas | Plastic - White
1549771 | 1 aukštas | Plastic - White
1552244 | 2 aukštas | Plastic - White
1552444 | 4 aukštas | Plastic - White
1552463 | 4 aukštas | Plastic - White
1552472 | 4 aukštas | Plastic - White
1552481 | 4 aukštas | Plastic - White
1552490 | 4 aukštas | Plastic - White
1552499 | 4 aukštas | Plastic - White
1552630 | 5 aukštas | Plastic - White
1552723 | 5 aukštas | Plastic - White
1552734 | 5 aukštas | Plastic - White
1552745 | 5 aukštas | Plastic - White
1552754 | 5 aukštas | Plastic - White
1552763 | 5 aukštas | Plastic - White
1552900 | 5 aukštas | Plastic - White
1552957 | 5 aukštas | Plastic - White
1570338 | 1 aukštas | Plastic - White
1570571 | 1 aukštas | Plastic - White
1570669 | 1 aukštas | Plastic - White
1570685 | 1 aukštas | Plastic - White
1570747 | 1 aukštas | Plastic - White
1570757 | 1 aukštas | Plastic - White
1570769 | 1 aukštas | Plastic - White
1570777 | 1 aukštas | Plastic - White
1570892 | 2 aukštas | Plastic - White
1570900 | 2 aukštas | Plastic - White
1570954 | 2 aukštas | Plastic - White
1570970 | 2 aukštas | Plastic - White
1571164 | 2 aukštas | Plastic - White
1571304 | 2 aukštas | Plastic - White
1571406 | 2 aukštas | Plastic - White
1571523 | 2 aukštas | Plastic - White
1571535 | 2 aukštas | Plastic - White
1571543 | 2 aukštas | Plastic - White
1571551 | 2 aukštas | Plastic - White
1571780 | 2 aukštas | Plastic - White
1571904 | 2 aukštas | Plastic - White
1571983 | 2 aukštas | Plastic - White
1572727 | 2 aukštas | Plastic - White
1572755 | 2 aukštas | Plastic - White
1572840 | 2 aukštas | Plastic - White
1572883 | 2 aukštas | Plastic - White
1573091 | 2 aukštas | Plastic - White
1573220 | 3 aukštas | Plastic - White
1573350 | 3 aukštas | Plastic - White
1573358 | 3 aukštas | Plastic - White
1573504 | 3 aukštas | Plastic - White
1573516 | 3 aukštas | Plastic - White
1574421 | 3 aukštas | Plastic - White
1574642 | 3 aukštas | Plastic - White
1574755 | 3 aukštas | Plastic - White
1574763 | 3 aukštas | Plastic - White
1574795 | 3 aukštas | Plastic - White
1574807 | 3 aukštas | Plastic - White
1574843 | 3 aukštas | Plastic - White
1574875 | 3 aukštas | Plastic - White
1574893 | 3 aukštas | Plastic - White
1574937 | 3 aukštas | Plastic - White
1575626 | 4 aukštas | Plastic - White
1575656 | 4 aukštas | Plastic - White
1575701 | 4 aukštas | Plastic - White
1575761 | 4 aukštas | Plastic - White
1575930 | 4 aukštas | Plastic - White
1575999 | 4 aukštas | Plastic - White
1576199 | 4 aukštas | Plastic - White
1576298 | 4 aukštas | Plastic - White
1576306 | 4 aukštas | Plastic - White
1576548 | 4 aukštas | Plastic - White
1576600 | 4 aukštas | Plastic - White
1576666 | 4 aukštas | Plastic - White
1576747 | 4 aukštas | Plastic - White
1576769 | 4 aukštas | Plastic - White
2041494 | 1 aukštas | Plastic - White
2043439 | 1 aukštas | Plastic - White
2044012 | 5 aukštas | Plastic - White
2044237 | 5 aukštas | Plastic - White
2044268 | 5 aukštas | Plastic - White
2192675 | 2 aukštas | Plastic - White
2244303 | 2 aukštas | Plastic - White
2244882 | 2 aukštas | Plastic - White
2245793 | 2 aukštas | Plastic - White
2246132 | 2 aukštas | Plastic - White
2246228 | 2 aukštas | Plastic - White
2246368 | 2 aukštas | Plastic - White
2252084 | 2 aukštas | Plastic - White
2252191 | 2 aukštas | Plastic - White
2252420 | 2 aukštas | Plastic - White
2252842 | 2 aukštas | Plastic - White
2262740 | 3 aukštas | Plastic - White
2262775 | 3 aukštas | Plastic - White
2263571 | 3 aukštas | Plastic - White
2263716 | 3 aukštas | Plastic - White
2263818 | 3 aukštas | Plastic - White
2263887 | 3 aukštas | Plastic - White
2263997 | 3 aukštas | Plastic - White
2264108 | 3 aukštas | Plastic - White
2272877 | 4 aukštas | Plastic - White
2281118 | 5 aukštas | Plastic - White
2281176 | 5 aukštas | Plastic - White
2281209 | 5 aukštas | Plastic - White
2281388 | 5 aukštas | Plastic - White
2281471 | 5 aukštas | Plastic - White
2281603 | 5 aukštas | Plastic - White
2281627 | 5 aukštas | Plastic - White
2281675 | 5 aukštas | Plastic - White
2282188 | 5 aukštas | Plastic - White
2282320 | 5 aukštas | Plastic - White
2282511 | 5 aukštas | Plastic - White

# IfcDistributionControlElement: GSS_Detektorius:03_Optinis dūmų detektorius su indikatorium po ortakiu (61)
Type - Material: Plastic - White (2)
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: 03_Optinis dūmų detektorius su indikatorium po ortakiu
Name (GSS_Detektorius:03_Optinis dūmų detektorius su indikatorium po ortakiu:...) | In | Material
1569627 | 1 aukštas
1570123 | 1 aukštas | Plastic - White
1570154 | 1 aukštas | Plastic - White
1572927 | 2 aukštas | Plastic - White
1573023 | 2 aukštas | Plastic - White
1573547 | 3 aukštas | Plastic - White
1573647 | 3 aukštas | Plastic - White
1573685 | 3 aukštas | Plastic - White
1574203 | 3 aukštas | Plastic - White
1574257 | 3 aukštas | Plastic - White
1574265 | 3 aukštas | Plastic - White
1574273 | 3 aukštas | Plastic - White
1574281 | 3 aukštas | Plastic - White
1574289 | 3 aukštas | Plastic - White
1574303 | 3 aukštas | Plastic - White
1574311 | 3 aukštas | Plastic - White
1574319 | 3 aukštas | Plastic - White
1574327 | 3 aukštas | Plastic - White
1574335 | 3 aukštas | Plastic - White
1574349 | 3 aukštas | Plastic - White
1574357 | 3 aukštas | Plastic - White
1574379 | 3 aukštas | Plastic - White
1574526 | 3 aukštas | Plastic - White
1575220 | 3 aukštas | Plastic - White
1575303 | 3 aukštas | Plastic - White
1575311 | 3 aukštas | Plastic - White
1576325 | 4 aukštas | Plastic - White
1576428 | 4 aukštas | Plastic - White
1576438 | 4 aukštas | Plastic - White
1576500 | 4 aukštas | Plastic - White
1576807 | 4 aukštas | Plastic - White
1576841 | 4 aukštas | Plastic - White
1576849 | 4 aukštas | Plastic - White
2247031 | 2 aukštas | Plastic - White
2247176 | 2 aukštas | Plastic - White
2248167 | 2 aukštas | Plastic - White
2248354 | 2 aukštas | Plastic - White
2248587 | 2 aukštas | Plastic - White
2248773 | 2 aukštas | Plastic - White
2249208 | 2 aukštas | Plastic - White
2249418 | 2 aukštas | Plastic - White
2249737 | 2 aukštas | Plastic - White
2250778 | 2 aukštas
2261276 | 3 aukštas | Plastic - White
2261336 | 3 aukštas | Plastic - White
2261429 | 3 aukštas | Plastic - White
2261430 | 3 aukštas | Plastic - White
2263024 | 3 aukštas | Plastic - White
2263093 | 3 aukštas | Plastic - White
2263171 | 3 aukštas | Plastic - White
2263172 | 3 aukštas | Plastic - White
2263264 | 3 aukštas | Plastic - White
2273332 | 4 aukštas | Plastic - White
2280887 | 5 aukštas | Plastic - White
2280971 | 5 aukštas | Plastic - White
2281280 | 5 aukštas | Plastic - White
2281331 | 5 aukštas | Plastic - White
2282637 | 5 aukštas | Plastic - White
2282929 | 5 aukštas | Plastic - White
2282979 | 5 aukštas | Plastic - White
2283093 | 5 aukštas | Plastic - White

# IfcDistributionControlElement: GSS_IO_modulis:IO modulis 4/4 (124)
Type - Material: White
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Pset_QuantityTakeOff - Reference: IO modulis 4/4
Name (GSS_IO_modulis:IO modulis 4/4:...) | In
1463969 | Rūsys
1464358 | Rūsys
1464471 | Rūsys
1464532 | Rūsys
1464566 | Rūsys
1464604 | Rūsys
1464677 | Rūsys
1464756 | Rūsys
1464764 | Rūsys
1465528 | 1 aukštas
1465576 | 1 aukštas
1465593 | 2 aukštas
1466060 | 5 aukštas
1466203 | 5 aukštas
1466292 | 5 aukštas
1466362 | 1 aukštas
1466425 | 1 aukštas
1543621 | Rūsys
1543622 | Rūsys
1543623 | Rūsys
1543624 | Rūsys
1569159 | 5 aukštas
2005278 | 1 aukštas
2005496 | 1 aukštas
2005743 | 2 aukštas
2005939 | 2 aukštas
2006035 | 3 aukštas
2006113 | 3 aukštas
2006203 | 4 aukštas
2006264 | 4 aukštas
2006298 | 5 aukštas
2006972 | Rūsys
2007015 | Rūsys
2007156 | 1 aukštas
2007278 | 2 aukštas
2007339 | 2 aukštas
2007391 | 2 aukštas
2007479 | 2 aukštas
2007505 | 2 aukštas
2007579 | 2 aukštas
2007614 | 2 aukštas
2007825 | 2 aukštas
2008063 | 2 aukštas
2008230 | 2 aukštas
2008540 | 2 aukštas
2008583 | 2 aukštas
2008662 | 3 aukštas
2019145 | 1 aukštas
2019619 | 2 aukštas
2019686 | 2 aukštas
2019712 | 2 aukštas
2019734 | 2 aukštas
2019874 | 2 aukštas
2019952 | 2 aukštas
2019979 | 2 aukštas
2020008 | 2 aukštas
2020051 | 2 aukštas
2020094 | 2 aukštas
2020129 | 2 aukštas
2020254 | 3 aukštas
2020256 | 3 aukštas
2020293 | 3 aukštas
2020363 | 3 aukštas
2020401 | 3 aukštas
2020462 | 3 aukštas
2020523 | 3 aukštas
2020585 | 3 aukštas
2020709 | 3 aukštas
2020757 | 3 aukštas
2020800 | 3 aukštas
2020825 | 4 aukštas
2020883 | 4 aukštas
2020935 | 4 aukštas
2020985 | 4 aukštas
2021043 | 4 aukštas
2021078 | 4 aukštas
