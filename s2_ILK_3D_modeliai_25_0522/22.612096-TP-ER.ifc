Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 22.612096
Time: 2023-07-27T13:56:51
Author: UAB "Projectum", mindaugas@projectum.lt
Written by: ODA IFC SDK 22.8
Made in: 22.1.40.58 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcProject, 22.612096
LongName: Gydymo paskirties pastato Santariškių g. 2, Vilniuje, statybos projektas; Phase: TP

# IfcSite, Santariškių g. 2, Vilnius
RefLatitude: 54, 45, 7, 339197; RefLongitude: 25, 16, 31, 313663; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 6
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (6)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Rūsys | Rūsys | 149080
1 aukštas | 1 aukštas | 152840
2 aukštas | 2 aukštas | 157340
3 aukštas | 3 aukštas | 162140
4 aukštas | 4 aukštas | 166640
5 aukštas | 5 aukštas | 171140

# IfcBuildingElementProxy: SS_Komutacine_spinta_Data:Komutacine spinta_42U 800x1000 mm (16)
In: 5 aukštas
Type - Material: Black
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Komutacine spinta_42U 800x1000 mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 800 mm; Height: 1000 mm; Depth: 2000 mm
Name (SS_Komutacine_spinta_Data:...)
SS1:1978037
SS2:1978230
SS3:1978238
SS4:1978246
SS5:1978254
SS6:1978262
SS7:1978270
SS8:1978278
SS16:1978311
SS15:1978312
SS14:1978313
SS13:1978314
SS12:1978315
SS11:1978316
SS10:1978317
SS9:1978318

# IfcBuildingElementProxy: SS_Komutacine_spinta_Data:Komutacine spinta_42U 800x800 mm (23)
Type - Material: Black
Type - Pset_ProductRequirements - Category: Electrical Equipment
Pset_BuildingElementProxyCommon - Reference: Komutacine spinta_42U 800x800 mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 800 mm; Height: 800 mm; Depth: 2000 mm
Name (SS_Komutacine_spinta_Data:...) | In
KS1/2.2:1355218 | 1 aukštas
KS1/2.1:1355472 | 1 aukštas
KS1/1.2:1355798 | 1 aukštas
KS1/1.1:1355799 | 1 aukštas
KS2/2.2:1356057 | 2 aukštas
KS2/2.1:1356058 | 2 aukštas
KS2/1.2:1356059 | 2 aukštas
KS2/1.1:1356060 | 2 aukštas
KS3/2.2:1356111 | 3 aukštas
KS3/2.1:1356112 | 3 aukštas
KS3/1.2:1356113 | 3 aukštas
KS3/1.1:1356114 | 3 aukštas
KS4/2.2:1356162 | 4 aukštas
KS4/2.1:1356163 | 4 aukštas
KS4/1.2:1356164 | 4 aukštas
KS4/1.1:1356165 | 4 aukštas
KS5/2.2:1356167 | 5 aukštas
KS5/2.1:1356168 | 5 aukštas
KS0/2.1:1369307 | Rūsys
KS5/1.1:1549048 | 5 aukštas
KS5/1.2:1549049 | 5 aukštas
KS5/1.3:1549050 | 5 aukštas
KS0/1.1:1965185 | Rūsys

# IfcDistributionPort (1248)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_1354962
InPort_1354962
2 x OutPort_1354975
2 x InPort_1354968
OutPort_1354982
InPort_1354982
OutPort_1355617
2 x InPort_1355088
2 x OutPort_1355130
2 x OutPort_1355116
InPort_1355107
Port_1355107
InPort_1355116
OutPort_1355117
InPort_1355117
2 x OutPort_1355144
Port_1355124
InPort_1355124
Port_1355138
InPort_1355138
Port_1355218
Port_1355472
Port_1355617
Port_1355798
Port_1355799
Port_1356057
Port_1356058
Port_1356059
Port_1356060
Port_1356111
Port_1356112
Port_1356113
Port_1356114
Port_1356162
Port_1356163
Port_1356164
Port_1356165
Port_1356167
Port_1356168
2 x Port_1356172
Port_1357466
InPort_1357466
2 x OutPort_1357667
InPort_1357472
OutPort_1357716
Port_1357472
2 x InPort_1357492
OutPort_1357506
2 x OutPort_1357518
2 x InPort_1357502
OutPort_1357543
2 x OutPort_1357830
InPort_1357506
2 x OutPort_1357831
2 x InPort_1357514
2 x OutPort_1357526
InPort_1357518
OutPort_1357519
InPort_1357519
2 x OutPort_1357818
InPort_1357520
Port_1357520
2 x InPort_1357537
OutPort_1357650
OutPort_1357729
2 x InPort_1357543
OutPort_1357544
2 x OutPort_1357730
Port_1357544
3 x InPort_1357572
OutPort_1357573
2 x OutPort_1357668
2 x OutPort_1357799
Port_1357573
2 x InPort_1357650
OutPort_1357651
2 x OutPort_1357717
InPort_1357651
InPort_1357667
Port_1357710
InPort_1357710
4 x OutPort_1357735
2 x InPort_1357716
OutPort_1357734
InPort_1357723
Port_1357723
2 x InPort_1357729
OutPort_1357733
InPort_1357733
InPort_1357734
2 x InPort_1357792
OutPort_1357806
OutPort_1357798
2 x InPort_1357798
2 x OutPort_1357819
Port_1357800
InPort_1357800
2 x OutPort_1357820
InPort_1357806
2 x OutPort_1357821
2 x InPort_1357814
InPort_1357818
InPort_1357820
InPort_1357824
Port_1357824
InPort_1357830
Port_1357986
InPort_1357986
2 x OutPort_1358413
InPort_1357992
2 x OutPort_1358450
Port_1357992
InPort_1357994
Port_1357994
Port_1358018
InPort_1358018
2 x InPort_1358235
2 x OutPort_1358451
2 x OutPort_1358414
InPort_1358413
InPort_1358450
InPort_1358465
2 x OutPort_1358470
Port_1358465
Port_1358466
InPort_1358466
2 x OutPort_1358472
InPort_1358467
Port_1358467
Port_1358468
InPort_1358468
2 x InPort_1358469
OutPort_1358506
2 x OutPort_1358473
InPort_1358470
OutPort_1358471
InPort_1358471
2 x OutPort_1358666
InPort_1358472
InPort_1358506
2 x OutPort_1358665
2 x InPort_1358580
InPort_1358684
2 x OutPort_1358689
Port_1358684
Port_1358687
InPort_1358687
InPort_1358689
2 x OutPort_1551626
Port_1358692
InPort_1358692
2 x OutPort_1358926
Port_1358734
InPort_1358734
InPort_1358926
OutPort_1358927
InPort_1358927
2 x OutPort_1551625
Port_1369307
Port_1369311
InPort_1369311
2 x OutPort_1965273
2 x InPort_1369317
2 x OutPort_1384740
2 x OutPort_1384738
Port_1369318
InPort_1369318
2 x OutPort_1384714
2 x InPort_1369320
2 x OutPort_1393636
OutPort_1369333
2 x InPort_1369326
2 x OutPort_2175648
2 x OutPort_1369362
InPort_1369329
2 x OutPort_1369355
Port_1369329
2 x InPort_1369333
OutPort_1369334
OutPort_1369335
InPort_1369334
OutPort_1384713
InPort_1369335
2 x InPort_1369350
2 x InPort_1369353
2 x OutPort_1393637
2 x OutPort_2175649
InPort_1369355
OutPort_1369356
InPort_1369356
2 x OutPort_1393634
2 x InPort_1369357
2 x OutPort_1369361
2 x InPort_1369359
2 x InPort_1377273
2 x OutPort_1965274
2 x OutPort_1393635
InPort_1384713
2 x OutPort_1384739
InPort_1384738
2 x InPort_1393630
InPort_1393634
InPort_1393636
InPort_1459472
2 x OutPort_2175662
Port_1459472
2 x Port_1459560
2 x Port_1459973
Port_1495703
Port_1495979
Port_1508084
Port_1508085
Port_1508144
Port_1508145
Port_1508347
Port_1508348
Port_1508809
Port_1508810
Port_1508943
Port_1508944
Port_1508977
Port_1508978
Port_1509067
Port_1509068
Port_1509104
Port_1509105
Port_1509116
Port_1509117
Port_1509211
Port_1509212
Port_1509227
Port_1509228
Port_1509252
Port_1509253
Port_1509280
Port_1509281
Port_1509591
Port_1509592
Port_1509615
Port_1509616
Port_1509660
Port_1509661
Port_1509721
Port_1509722
Port_1509744
Port_1509745
Port_1509788
Port_1509789
Port_1509875
Port_1509876
Port_1509917
Port_1509918
Port_1509957
Port_1509958
Port_1509977
Port_1509978
Port_1510000
Port_1510001
Port_1510044
Port_1510045
Port_1510074
Port_1510075
Port_1510091
Port_1510092
Port_1510111
Port_1510112
Port_1510269
Port_1510270
Port_1510319
Port_1510320
Port_1510356
Port_1510357
Port_1510373
Port_1510374
Port_1510398
Port_1510399
Port_1510455
Port_1510456
Port_1510496
Port_1510497
Port_1510512
Port_1510513
Port_1510535
Port_1510536
Port_1510550
Port_1510551
Port_1510576
Port_1510577
Port_1510637
Port_1510638
Port_1510654
Port_1510655
Port_1510717
Port_1510718
Port_1510762
Port_1510763
Port_1510819
Port_1510820
Port_1510842
Port_1510843
Port_1510903
Port_1510904
Port_1510922
Port_1510923
Port_1510944
Port_1510945
Port_1511122
Port_1511123
Port_1511145
Port_1511146
Port_1511220
Port_1511221
Port_1511255
Port_1511256
Port_1511275
Port_1511276
Port_1511293
Port_1511294
Port_1511318
Port_1511319
Port_1511367
Port_1511368
Port_1511434
Port_1511435
Port_1511451
Port_1511452
Port_1511504
Port_1511505
Port_1512466
Port_1512947
Port_1513080
Port_1513081
Port_1513188
Port_1513189
Port_1513442
Port_1513443
Port_1515670
Port_1515671
Port_1515844
Port_1515965
Port_1516092
Port_1516428
Port_1516429
Port_1516506
Port_1516592
Port_1516593
Port_1516791
Port_1516792
Port_1516906
Port_1516945
Port_1517013
Port_1517072
Port_1517112
Port_1517138
Port_1517186
Port_1517222
Port_1517833
Port_1517834
Port_1517835
Port_1517836
Port_1518021
Port_1518117
Port_1518222
Port_1518297
Port_1518298
Port_1518400
Port_1518401
Port_1518546
Port_1518633
Port_1518760
Port_1518789
Port_1518858
Port_1518980
Port_1519065
Port_1519136
Port_1519164
Port_1519226
Port_1519266
Port_1519307
Port_1519308
Port_1519332
Port_1519461
Port_1519462
Port_1519463
Port_1519574
Port_1519635
Port_1519677
Port_1519729
Port_1519793
Port_1519870
Port_1519902
Port_1519959
Port_1519967
Port_1519975
Port_1520166
Port_1520167
Port_1520168
Port_1520191
Port_1520192
Port_1520193
Port_1520215
Port_1520216
Port_1520217
Port_1520238
Port_1520239
Port_1520240
Port_1520255
Port_1520256
Port_1520257
Port_1520696
Port_1520697
Port_1520851
Port_1520859
Port_1520871
Port_1520954
Port_1520999
Port_1521000
Port_1521165
Port_1521166
Port_1521330
Port_1521426
Port_1521510
Port_1521560
Port_1521622
Port_1521678
Port_1521715
Port_1521775
Port_1521776
Port_1521867
Port_1521913
Port_1521971
Port_1522048
Port_1522109
Port_1522173
Port_1522261
Port_1522262
Port_1522351
Port_1522352
Port_1522487
Port_1522488
Port_1522679
Port_1522680
Port_1522764
Port_1522796
Port_1522964
Port_1522965
Port_1523189
Port_1523223
Port_1523298
Port_1523299
Port_1523388
Port_1523389
Port_1523485
Port_1523486
Port_1523744
Port_1523754
Port_1523802
Port_1523803
Port_1523984
Port_1524017
Port_1524244
Port_1524245
Port_1524268
Port_1524630
Port_1524776
Port_1524777
Port_1524785
Port_1524786
Port_1525195
Port_1525304
Port_1525370
Port_1525371
Port_1525484
Port_1525503
Port_1525544
Port_1525578
Port_1525634
Port_1525749
Port_1525797
Port_1525798
Port_1525972
Port_1526052
Port_1526091
Port_1526299
Port_1526300
Port_1526328
Port_1526387
Port_1526388
Port_1526518
Port_1526554
Port_1526555
Port_1526672
Port_1526673
Port_1526825
Port_1526833
Port_1526906
Port_1526907
Port_1527078
Port_1527146
Port_1527147
Port_1527268
Port_1527327
Port_1527374
Port_1527375
Port_1527603
Port_1527723
Port_1527755
Port_1527756
Port_1527879
Port_1527880
Port_1528008
Port_1528009
Port_1528119
Port_1528120
Port_1528231
Port_1528320
Port_1528321
Port_1528322
Port_1528336
Port_1528337
Port_1528505
Port_1528506
Port_1528592
Port_1528696
Port_1528697
Port_1528786
Port_1528871
Port_1528939
Port_1529019
Port_1529086
Port_1529145
Port_1529188
Port_1529232
Port_1529284
Port_1529334
Port_1529494
Port_1529513
Port_1529531
Port_1529576
Port_1529626
Port_1529648
Port_1529823
Port_1529824
Port_1529918
Port_1529919
Port_1530041
Port_1530042
Port_1530073
Port_1530132
Port_1530133
Port_1530202
Port_1530281
Port_1530340
Port_1530341
Port_1530440
Port_1530545
Port_1530689
Port_1530690
Port_1530747
Port_1530748
Port_1530786
Port_1530787
Port_1530810
Port_1530881
Port_1530948
Port_1531055
Port_1531104
Port_1531214
Port_1531318
Port_1531391
Port_1531413
Port_1531485
Port_1531544
Port_1531650
Port_1531784
Port_1531947
Port_1532088
Port_1532089
Port_1532165
Port_1532166
Port_1532181
Port_1532182
Port_1532226
Port_1532227
Port_1532247
Port_1532248
Port_1532275
Port_1532276
Port_1532292
Port_1532293
Port_1532319
Port_1532320
Port_1532351
Port_1532352
Port_1532372
Port_1532408
Port_1532409
Port_1549048
Port_1549049
Port_1549050
InPort_1549106
2 x OutPort_1551648
Port_1549106
InPort_1549115
OutPort_1549369
Port_1549115
Port_1549148
InPort_1549148
4 x OutPort_1549374
InPort_1549171
2 x OutPort_1549366
Port_1549171
2 x InPort_1549358
InPort_1549366
OutPort_1549367
Port_1549367
2 x InPort_1549369
OutPort_1549370
OutPort_1549372
InPort_1549370
InPort_1549372
Port_1549373
InPort_1549373
2 x InPort_1551582
OutPort_1551605
InPort_1551605
2 x OutPort_1551649
InPort_1551625
InPort_1551648
Port_1785752
Port_1785753
Port_1792541
Port_1792646
Port_1792767
Port_1792809
Port_1792870
Port_1792953
Port_1793004
Port_1793073
Port_1793158
Port_1793238
Port_1793711
InPort_1793711
2 x OutPort_1793883
InPort_1793798
Port_1793798
Port_1793936
InPort_1793936
2 x OutPort_1793938
Port_1793937
InPort_1793937
Port_1794088
Port_1794806
Port_1795275
Port_1795276
Port_1795311
Port_1795384
Port_1795475
Port_1798332
Port_1798961
Port_1799054
Port_1799098
Port_1799099
Port_1799128
Port_1799129
Port_1799212
Port_1799213
Port_1799249
Port_1799250
Port_1808513
Port_1808514
Port_1808515
Port_1808516
Port_1810985
Port_1810986
Port_1810987
Port_1810988
Port_1810989
Port_1810990
Port_1810991
InPort_1811002
2 x OutPort_1811004
Port_1811002
InPort_1811003
Port_1811003
Port_1811009
Port_1811010
Port_1811011
Port_1811012
Port_1811013
Port_1811014
Port_1811015
Port_1811016
Port_1811017
Port_1811018
Port_1811019
Port_1811020
Port_1811021
Port_1811022
Port_1811023
Port_1811024
Port_1811025
Port_1811026
Port_1811027
Port_1811028
Port_1811029
Port_1811030
Port_1811031
Port_1811032
Port_1811033
Port_1811034
2 x InPort_1811042
2 x OutPort_1811067
2 x OutPort_1811046
InPort_1811043
Port_1811043
InPort_1811048
2 x OutPort_1811052
Port_1811048
Port_1811049
InPort_1811049
InPort_1811055
2 x OutPort_1811057
Port_1811055
InPort_1811056
Port_1811056
Port_1811062
Port_1811063
Port_1811064
Port_1811065
InPort_1811065
Port_1811070
Port_1811071
Port_1811074
Port_1811075
Port_1811237
Port_1811279
Port_1811348
Port_1811390
Port_1811432
Port_1811474
Port_1811534
Port_1811584
Port_1811653
Port_1811775
Port_1812197
Port_1812288
InPort_1812588
2 x OutPort_1812590
Port_1812588
InPort_1812589
Port_1812589
Port_1812653
Port_1812704
Port_1812791
Port_1812842
Port_1812893
Port_1813001
Port_1813070
Port_1813139
Port_1813208
Port_1813277
Port_1813346
Port_1813418
Port_1855747
Port_1855748
Port_1855749
Port_1855750
Port_1855751
Port_1855752
Port_1855753
Port_1855754
Port_1855755
Port_1855756
InPort_1855758
2 x OutPort_1855760
Port_1855758
Port_1855759
InPort_1855759
Port_1855771
Port_1855772
Port_1855778
InPort_1855778
2 x OutPort_1855787
Port_1855779
InPort_1855779
InPort_1855780
OutPort_1855781
Port_1855780
Port_1855781
Port_1855790
Port_1855791
Port_1855792
Port_1855793
Port_1855794
Port_1855795
Port_1855796
Port_1855797
Port_1855798
Port_1855799
Port_1855800
Port_1855801
Port_1855802
Port_1855803
Port_1855804
Port_1855805
Port_1855806
Port_1855807
Port_1855808
Port_1855809
Port_1855810
Port_1855811
Port_1855812
Port_1855813
Port_1855814
Port_1855815
Port_1855816
Port_1855817
Port_1855818
Port_1855819
Port_1855820
Port_1855821
Port_1855822
Port_1855823
Port_1855824
Port_1855825
Port_1855826
Port_1855827
Port_1855828
Port_1855829
Port_1855830
Port_1855831
Port_1855832
Port_1855833
Port_1855834
Port_1855835
Port_1855836
Port_1855837
Port_1855838
Port_1855839
Port_1855840
Port_1855841
Port_1855842
Port_1855843
Port_1855844
Port_1855845
Port_1855846
Port_1855847
Port_1855848
Port_1855849
Port_1855850
Port_1855851
Port_1855859
InPort_1855859
2 x OutPort_1855861
InPort_1855860
Port_1855860
InPort_1855869
OutPort_1855870
Port_1855869
Port_1855870
Port_1855876
Port_1855877
Port_1855878
Port_1855879
Port_1855880
Port_1855881
Port_1855882
Port_1855883
Port_1855884
Port_1855885
Port_1855886
Port_1855887
Port_1855888
Port_1855889
Port_1855890
Port_1855891
Port_1855892
Port_1855893
Port_1855894
Port_1855895
Port_1855896
Port_1855897
Port_1855898
Port_1855899
Port_1858884
Port_1858885
Port_1858886
Port_1858887
Port_1858888
Port_1858889
Port_1858890
Port_1858891
Port_1858892
Port_1858893
Port_1858894
Port_1858895
Port_1858896
Port_1858897
Port_1858898
Port_1858899
Port_1858900
Port_1858901
Port_1858902
Port_1858903
InPort_1858911
2 x OutPort_1858913
Port_1858911
InPort_1858912
Port_1858912
InPort_1858918
OutPort_1858919
Port_1858918
Port_1858919
Port_1858925
Port_1858931
Port_1858932
Port_1858933
Port_1858934
Port_1858939
Port_1858991
Port_1859059
Port_1859147
Port_1859219
Port_1859523
Port_1859531
Port_1859539
Port_1859582
Port_1859643
Port_1859653
Port_1859661
Port_1859958
Port_1860888
Port_1860957
Port_1861102
Port_1861164
Port_1861346
Port_1861522
Port_1861802
Port_1861870
Port_1861995
Port_1862617
Port_1862901
Port_1863020
Port_1863082
Port_1863178
Port_1863480
Port_1863823
Port_1864098
Port_1864202
Port_1864203
Port_1864520
Port_1864712
Port_1864811
Port_1865054
Port_1865195
Port_1865305
Port_1865368
Port_1865396
Port_1866584
Port_1866585
Port_1866922
Port_1867065
Port_1867361
Port_1867781
Port_1867782
Port_1867869
Port_1867870
Port_1868715
Port_1869390
InPort_1869390
2 x OutPort_1869392
Port_1869391
InPort_1869391
Port_1869447
Port_1869448
Port_1869618
Port_1869619
Port_1869664
Port_1869665
Port_1869766
Port_1869767
Port_1869801
2 x Port_1887972
2 x Port_1887973
2 x Port_1887974
2 x Port_1887975
Port_1887976
Port_1887978
Port_1888123
Port_1888125
Port_1888194
Port_1888196
Port_1888275
Port_1888277
Port_1888349
Port_1904692
Port_1904849
Port_1904980
Port_1905057
Port_1905123
Port_1905221
Port_1905315
Port_1905453
Port_1905624
Port_1905668
Port_1905791
Port_1905937
Port_1906059
Port_1906614
Port_1906662
Port_1906792
Port_1906990
Port_1907080
Port_1907203
Port_1907452
Port_1907500
Port_1907533
Port_1907566
Port_1907680
Port_1907724
Port_1907785
Port_1907854
Port_1907915
Port_1907976
Port_1907998
Port_1954800
Port_1959260
Port_1959267
Port_1959274
Port_1959281
Port_1959289
Port_1959296
Port_1959303
Port_1959310
Port_1959317
Port_1959324
Port_1959331
Port_1959338
Port_1959345
Port_1959352
Port_1959359
Port_1959366
Port_1959373
Port_1959380
Port_1959387
Port_1959394
Port_1959401
Port_1959408
Port_1959415
Port_1959422
Port_1959429
Port_1959436
Port_1965156
Port_1965163
Port_1965170
Port_1965185
Port_1965204
Port_1965205
2 x InPort_1965267
2 x OutPort_1965282
InPort_1965273
Port_1965276
InPort_1965276
Port_1973174
Port_1973202
Port_1973322
Port_1973434
Port_1973536
Port_1973638
Port_1973934
Port_1974024
Port_1974250
Port_1974336
Port_1974432
Port_1974550
Port_1974614
Port_1974864
Port_1975000
Port_1975232
Port_1975338
Port_1975582
Port_1975640
Port_1975712
Port_1975842
Port_1975950
Port_1976052
Port_1976124
Port_1976240
Port_1976324
Port_1976858
Port_1977108
Port_1977508
Port_1977556
Port_1977620
Port_1978037
Port_1978230
Port_1978238
Port_1978246
Port_1978254
Port_1978262
Port_1978270
Port_1978278
Port_1978311
Port_1978312
Port_1978313
Port_1978314
Port_1978315
Port_1978316
Port_1978317
Port_1978318
Port_2035242
Port_2035379
Port_2037443
Port_2037473
Port_2039802
Port_2039914
Port_2039975
Port_2040000
Port_2040071
Port_2040142
Port_2040196
Port_2040251
Port_2040303
Port_2040382
Port_2040384
Port_2040425
Port_2040450
Port_2040475
Port_2040536
Port_2040581
Port_2040639
Port_2040666
Port_2040719
2 x InPort_2175637
OutPort_2175660
InPort_2175648
InPort_2175660

# IfcFlowFitting: M_Channel Horizontal Bend:Standard (20)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (M_Channel Horizontal Bend:Standard:...) | In
1354975 | 1 aukštas
1354982 | 1 aukštas
1355130 | 1 aukštas
1355144 | 1 aukštas
1357506 | 2 aukštas
1357526 | 2 aukštas
1357806 | 2 aukštas
1358235 | 3 aukštas
1358469 | 4 aukštas
1358665 | 4 aukštas
1358666 | 4 aukštas
1369353 | Rūsys
1369361 | Rūsys
1369362 | Rūsys
1377273 | Rūsys
1384713 | Rūsys
1384714 | Rūsys
1384740 | Rūsys
1551605 | 5 aukštas
1965282 | Rūsys

# IfcFlowFitting: M_Channel Horizontal Cross:100mm Radius (2)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: 100mm Radius; sets with these values: 2
Name (M_Channel Horizontal Cross:100mm Radius:...) | In
1357735 | 2 aukštas
1549374 | 5 aukštas

# IfcFlowFitting: M_Channel Horizontal Tee:100mm Radius (29)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: 100mm Radius; sets with these values: 2
Name (M_Channel Horizontal Tee:100mm Radius:...) | In
1355116 | 1 aukštas
1357518 | 2 aukštas
1357543 | 2 aukštas
1357572 | 2 aukštas
1357650 | 2 aukštas
1357667 | 2 aukštas
1357716 | 2 aukštas
1357729 | 2 aukštas
1357798 | 2 aukštas
1357818 | 2 aukštas
1357820 | 2 aukštas
1357830 | 2 aukštas
1358413 | 3 aukštas
1358450 | 3 aukštas
1358470 | 4 aukštas
1358472 | 4 aukštas
1358689 | 5 aukštas
1358926 | 5 aukštas
1369333 | Rūsys
1369355 | Rūsys
1384738 | Rūsys
1393634 | Rūsys
1393636 | Rūsys
1549366 | 5 aukštas
1549369 | 5 aukštas
1551625 | 5 aukštas
1551648 | 5 aukštas
1965273 | Rūsys
2175648 | Rūsys

# IfcFlowFitting: M_Conduit Elbow - without Fittings:PP vamzdis (16)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Conduit Fittings
Pset_DistributionFlowElementCommon - Reference: PP vamzdis; sets with these values: 2
Name (M_Conduit Elbow - without Fittings:PP vamzdis:...) | In
1793883 | 5 aukštas
1793938 | 1 aukštas
1811004 | 4 aukštas
1811046 | 4 aukštas
1811052 | 4 aukštas
1811057 | 4 aukštas
1811067 | 4 aukštas
1812590 | 4 aukštas
1855760 | 3 aukštas
1855781 | 3 aukštas
1855787 | 3 aukštas
1855861 | 2 aukštas
1855870 | 2 aukštas
1858913 | 2 aukštas
1858919 | 2 aukštas
1869392 | 1 aukštas

# IfcFlowFitting: M_Ladder Reducer:Standard, M_Ladder Reducer:Standard:2175662
In: 1 aukštas
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2

# IfcFlowFitting: M_Ladder Vertical Inside Bend:Standard, M_Ladder Vertical Inside Bend:Standard:2175660
In: 1 aukštas
Type - Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2

# IfcFlowSegment: Cable Tray with Fittings:Channel Cable Tray (90)
Type - Pset_ProductRequirements - Category: Cable Trays
Pset_DistributionFlowElementCommon - Reference: Channel Cable Tray; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Channel Cable Tray:...) | In | Length (mm)
1354962 | 1 aukštas | 9836.4
1354968 | 1 aukštas | 33740
1355088 | 1 aukštas | 39020.1
1355107 | 1 aukštas | 2859.34
1355117 | 1 aukštas | 15040.7
1355124 | 1 aukštas | 7439.53
1355138 | 1 aukštas | 5062.89
1355617 | 1 aukštas | 9770
1357466 | 2 aukštas | 2640
1357472 | 2 aukštas | 10733.5
1357492 | 2 aukštas | 1825.33
1357502 | 2 aukštas | 12651.3
1357514 | 2 aukštas | 2960
1357519 | 2 aukštas | 22346.6
1357520 | 2 aukštas | 5025.94
1357537 | 2 aukštas | 32756.2
1357544 | 2 aukštas | 5217.68
1357573 | 2 aukštas | 2075.18
1357651 | 2 aukštas | 17334.4
1357668 | 2 aukštas | 3625.58
1357710 | 2 aukštas | 25331.3
1357717 | 2 aukštas | 9790
1357723 | 2 aukštas | 9333.52
1357730 | 2 aukštas | 15318.6
1357733 | 2 aukštas | 9790
1357734 | 2 aukštas | 32756.2
1357792 | 2 aukštas | 8160
1357799 | 2 aukštas | 3577.92
1357800 | 2 aukštas | 21462.5
1357814 | 2 aukštas | 8080
1357819 | 2 aukštas | 19565
1357821 | 2 aukštas | 19645
1357824 | 2 aukštas | 12505.6
1357831 | 2 aukštas | 8388.7
1357986 | 3 aukštas | 6445.43
1357992 | 3 aukštas | 2640
1357994 | 3 aukštas | 41440
1358018 | 3 aukštas | 44593.5
1358414 | 3 aukštas | 44910
1358451 | 3 aukštas | 4263.48
1358465 | 4 aukštas | 5045.43
1358466 | 4 aukštas | 2640
1358467 | 4 aukštas | 41440
1358468 | 4 aukštas | 44593.5
1358471 | 4 aukštas | 6560
1358473 | 4 aukštas | 5960
1358506 | 4 aukštas | 39490
1358580 | 4 aukštas | 1436.52
1358684 | 5 aukštas | 11815.1
1358687 | 5 aukštas | 27619.8
1358692 | 5 aukštas | 5535.48
1358734 | 5 aukštas | 41894.9
1358927 | 5 aukštas | 4702.76
1369311 | Rūsys | 13842.9
1369317 | Rūsys | 3901.39
1369318 | Rūsys | 2860.61
1369320 | Rūsys | 27485
1369326 | Rūsys | 7157.98
1369329 | Rūsys | 17134.6
1369334 | Rūsys | 14019.4
1369335 | Rūsys | 8233.49
1369350 | Rūsys | 1790.52
1369356 | Rūsys | 27485
1369357 | Rūsys | 44413.4
1369359 | Rūsys | 3640.06
1384739 | Rūsys | 22629.5
1393630 | Rūsys | 8233.49
1393635 | Rūsys | 6310.33
1393637 | Rūsys | 6310.33
1549106 | 5 aukštas | 1530
1549115 | 5 aukštas | 4648.52
1549148 | 5 aukštas | 3584.71
1549171 | 5 aukštas | 3584.71
1549358 | 5 aukštas | 1977.82
1549367 | 5 aukštas | 4795.76
1549370 | 5 aukštas | 3224.24
1549372 | 5 aukštas | 5948.7
1549373 | 5 aukštas | 4795.76
1551582 | 5 aukštas | 2210.48
1551626 | 5 aukštas | 38059.9
1551649 | 5 aukštas | 4065.69
1887972 | 2 aukštas | 4600
1887973 | 2 aukštas | 4920
1887974 | 2 aukštas | 4670.21
1887975 | 2 aukštas | 4900
1965267 | Rūsys | 5960
1965274 | Rūsys | 2459.09
1965276 | Rūsys | 2370
2175637 | Rūsys | 318.272
2175649 | Rūsys | 19031.6

# IfcFlowSegment: Cable Tray with Fittings:Ladder Cable Tray (4)
Type - Pset_ProductRequirements - Category: Cable Trays
Pset_DistributionFlowElementCommon - Reference: Ladder Cable Tray; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Ladder Cable Tray:...) | In | Length (mm)
1356172 | 1 aukštas | 22660
1459472 | 1 aukštas | 4540
1459560 | 1 aukštas | 13700
1459973 | 5 aukštas | 4500

# IfcFlowSegment: Conduit without Fittings:PP vamzdis (28)
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: PP vamzdis; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit without Fittings:PP vamzdis:...) | In | Length (mm)
1793711 | 5 aukštas | 1278.25
1793798 | 5 aukštas | 3540.78
1793936 | 1 aukštas | 1278.25
1793937 | 1 aukštas | 3540.78
1811002 | 4 aukštas | 1278.25
1811003 | 4 aukštas | 3540.78
1811042 | 4 aukštas | 6585.72
1811043 | 4 aukštas | 2230.78
1811048 | 4 aukštas | 3230.41
1811049 | 4 aukštas | 2230.78
1811055 | 4 aukštas | 1030.78
1811056 | 4 aukštas | 3540.78
1811065 | 4 aukštas | 450.782
1812588 | 4 aukštas | 1278.25
1812589 | 4 aukštas | 3540.78
1855758 | 3 aukštas | 2970.78
1855759 | 3 aukštas | 3540.78
1855778 | 3 aukštas | 1667.5
1855779 | 3 aukštas | 570.782
1855780 | 3 aukštas | 3100
1855859 | 2 aukštas | 2510.78
1855860 | 2 aukštas | 3540.78
1855869 | 2 aukštas | 540
1858911 | 2 aukštas | 2510.78
1858912 | 2 aukštas | 3540.78
1858918 | 2 aukštas | 540
1869390 | 1 aukštas | 450.782
1869391 | 1 aukštas | 3540.78

# IfcFlowTerminal: Display_DIGIT:Display_DIGIT (30)
In: 2 aukštas
Type - Material: <Unnamed> (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Generic
Type - Pset_ProductRequirements - Category: Electrical Fixtures
Pset_DistributionFlowElementCommon - Reference: Display_DIGIT; sets with these values: 2
Name (Display_DIGIT:Display_DIGIT:...) | Material
1954800
1959260 | <Unnamed>
1959267 | <Unnamed>
1959274 | <Unnamed>
1959281 | <Unnamed>
1959289 | <Unnamed>
1959296 | <Unnamed>
1959303 | <Unnamed>
1959310 | <Unnamed>
1959317 | <Unnamed>
1959324 | <Unnamed>
1959331 | <Unnamed>
1959338 | <Unnamed>
1959345 | <Unnamed>
1959352 | <Unnamed>
1959359 | <Unnamed>
1959366 | <Unnamed>
1959373 | <Unnamed>
1959380 | <Unnamed>
1959387 | <Unnamed>
1959394 | <Unnamed>
1959401 | <Unnamed>
1959408 | <Unnamed>
1959415 | <Unnamed>
1959422 | <Unnamed>
1959429 | <Unnamed>
1959436 | <Unnamed>
1965156 | <Unnamed>
1965163 | <Unnamed>
1965170 | <Unnamed>

# IfcFlowTerminal: ER_Access_point:Access point (60)
Type - Material: White
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: Access point; sets with these values: 2
Name (ER_Access_point:Access point:...) | In
1495703 | Rūsys
1508084 | Rūsys
1508144 | Rūsys
1508347 | Rūsys
1508809 | Rūsys
1508943 | Rūsys
1508977 | Rūsys
1509067 | Rūsys
1509104 | Rūsys
1509116 | 1 aukštas
1509211 | 1 aukštas
1509227 | 1 aukštas
1509252 | 1 aukštas
1509280 | 1 aukštas
1509591 | 1 aukštas
1509615 | 1 aukštas
1509660 | 1 aukštas
1509721 | 1 aukštas
1509744 | 2 aukštas
1509788 | 2 aukštas
1509875 | 2 aukštas
1509917 | 2 aukštas
1509957 | 2 aukštas
1509977 | 2 aukštas
1510000 | 2 aukštas
1510044 | 2 aukštas
1510074 | 2 aukštas
1510091 | 2 aukštas
1510111 | 2 aukštas
1510269 | 2 aukštas
1510319 | 2 aukštas
1510356 | 2 aukštas
1510373 | 2 aukštas
1510398 | 3 aukštas
1510455 | 3 aukštas
1510496 | 3 aukštas
1510512 | 3 aukštas
1510535 | 3 aukštas
1510550 | 3 aukštas
1510576 | 3 aukštas
1510637 | 3 aukštas
1510654 | 3 aukštas
1510717 | 3 aukštas
1510762 | 4 aukštas
1510819 | 4 aukštas
1510842 | 4 aukštas
1510903 | 4 aukštas
1510922 | 4 aukštas
1510944 | 4 aukštas
1511122 | 4 aukštas
1511145 | 4 aukštas
1511220 | 4 aukštas
1511255 | 4 aukštas
1511275 | 4 aukštas
1511293 | 4 aukštas
1511318 | 5 aukštas
1511367 | 5 aukštas
1511434 | 5 aukštas
1511451 | 5 aukštas
1511504 | 5 aukštas

# IfcFlowTerminal: ER_Kabelio_rezervas:Kabelio_rezervas_su_dezute (25)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: Kabelio_rezervas_su_dezute; sets with these values: 2
Name (ER_Kabelio_rezervas:Kabelio_rezervas_su_dezute:...) | In
1798332 | 5 aukštas
1810991 | 5 aukštas
2035242 | Rūsys
2035379 | Rūsys
2037443 | 1 aukštas
2037473 | 1 aukštas
2039802 | 5 aukštas
2039914 | 5 aukštas
2039975 | 5 aukštas
2040000 | 5 aukštas
2040071 | 5 aukštas
2040142 | 5 aukštas
2040196 | 5 aukštas
2040251 | 5 aukštas
2040303 | 5 aukštas
2040382 | 5 aukštas
2040384 | 5 aukštas
2040425 | 5 aukštas
2040450 | 5 aukštas
2040475 | 5 aukštas
2040536 | 5 aukštas
2040581 | 5 aukštas
2040639 | 5 aukštas
2040666 | 5 aukštas
2040719 | 5 aukštas

# IfcFlowTerminal: ER_Potinkiniai lizdai:1xRJ45 (191)
Type - Material: Balta (3)
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 1xRJ45; sets with these values: 2
Name (ER_Potinkiniai lizdai:1xRJ45:...) | In | Material
1512947 | Rūsys
1513081 | Rūsys | Balta
1513189 | 1 aukštas | Balta
1513443 | 1 aukštas | Balta
1515671 | 1 aukštas | Balta
1516428 | 1 aukštas | Balta
1516592 | 1 aukštas | Balta
1516791 | 1 aukštas | Balta
1517222 | 1 aukštas | Balta
1517834 | 1 aukštas | Balta
1517835 | 2 aukštas | Balta
1518222 | 2 aukštas | Balta
1518298 | 2 aukštas | Balta
1518401 | 2 aukštas | Balta
1518546 | 2 aukštas | Balta
1518789 | 2 aukštas | Balta
1518980 | 2 aukštas | Balta
1519164 | 2 aukštas | Balta
1519266 | 2 aukštas | Balta
1519332 | 2 aukštas | Balta
1519463 | 2 aukštas | Balta
1519902 | 2 aukštas | Balta
1520697 | 2 aukštas | Balta
1521000 | 2 aukštas | Balta
1521166 | 2 aukštas | Balta
1521560 | 2 aukštas | Balta
1521715 | 2 aukštas | Balta
1521776 | 2 aukštas | Balta
1521913 | 2 aukštas | Balta
1522048 | 2 aukštas | Balta
1522173 | 2 aukštas | Balta
1522262 | 2 aukštas | Balta
1522352 | 2 aukštas | Balta
1522488 | 2 aukštas | Balta
1522680 | 2 aukštas | Balta
1522796 | 2 aukštas | Balta
1522965 | 2 aukštas | Balta
1523223 | 2 aukštas | Balta
1523299 | 2 aukštas | Balta
1523389 | 2 aukštas | Balta
1523486 | 2 aukštas | Balta
1523803 | 3 aukštas | Balta
1524017 | 2 aukštas | Balta
1524245 | 2 aukštas | Balta
1524268 | 2 aukštas | Balta
1524777 | 3 aukštas | Balta
1524786 | 3 aukštas | Balta
1525195 | 3 aukštas | Balta
1525371 | 3 aukštas | Balta
1525578 | 3 aukštas | Balta
1525634 | 3 aukštas | Balta
1525797 | 3 aukštas | Balta
1526091 | 3 aukštas | Balta
1526328 | 3 aukštas | Balta
1526388 | 3 aukštas | Balta
1526554 | 3 aukštas | Balta
1526672 | 3 aukštas | Balta
1526906 | 3 aukštas | Balta
1527146 | 3 aukštas | Balta
1527374 | 3 aukštas | Balta
1527755 | 3 aukštas | Balta
1527879 | 3 aukštas | Balta
1528008 | 3 aukštas | Balta
1528119 | 3 aukštas | Balta
1528231 | 3 aukštas | Balta
1528320 | 3 aukštas | Balta
1528322 | 3 aukštas | Balta
1528336 | 3 aukštas | Balta
1528506 | 4 aukštas | Balta
1528786 | 4 aukštas | Balta
1529019 | 4 aukštas | Balta
1529188 | 4 aukštas | Balta
1529334 | 4 aukštas | Balta
1529648 | 4 aukštas | Balta
1529824 | 4 aukštas | Balta
1529919 | 4 aukštas | Balta
1530042 | 4 aukštas | Balta
1530073 | 4 aukštas | Balta
1530133 | 4 aukštas | Balta
1530340 | 4 aukštas | Balta
1530689 | 4 aukštas | Balta
1530747 | 4 aukštas | Balta
1530786 | 4 aukštas | Balta
1530810 | 4 aukštas | Balta
1532088 | 5 aukštas | Balta
1532165 | 5 aukštas | Balta
1532181 | 5 aukštas | Balta
1532226 | 5 aukštas | Balta
1532247 | 5 aukštas | Balta
1532275 | 5 aukštas | Balta
1532292 | 5 aukštas | Balta
1532319 | 5 aukštas | Balta
1532351 | 5 aukštas | Balta
1532408 | 5 aukštas | Balta
1795275 | 5 aukštas | Balta
1799212 | 5 aukštas | Balta
1799249 | 5 aukštas | Balta
1810986 | 5 aukštas | Balta
1810989 | 5 aukštas | Balta
1811018 | 4 aukštas | Balta
1811019 | 4 aukštas | Balta
1811032 | 4 aukštas | Balta
1811034 | 4 aukštas | Balta
1855792 | 3 aukštas | Balta
1855797 | 3 aukštas | Balta
1855817 | 3 aukštas | Balta
1855819 | 3 aukštas | Balta
1855831 | 3 aukštas | Balta
1855850 | 2 aukštas | Balta
1864098 | 2 aukštas | Balta
1864203 | 2 aukštas | Balta
1866585 | 2 aukštas | Balta
1867361 | 1 aukštas | Balta
1867782 | 1 aukštas | Balta
1867870 | 1 aukštas | Balta
1869448 | Rūsys | Balta
1869619 | Rūsys | Balta
1869665 | Rūsys | Balta
1869767 | Rūsys | Balta
1887976 | 1 aukštas | Balta
1887978 | 1 aukštas | Balta
1888123 | 2 aukštas | Balta
1888125 | 2 aukštas | Balta
1888194 | 3 aukštas | Balta
1888196 | 3 aukštas | Balta
1888275 | 4 aukštas | Balta
1888277 | 4 aukštas | Balta
1888349 | 5 aukštas | Balta
1904692 | 1 aukštas | Balta
1904849 | 1 aukštas | Balta
1904980 | 2 aukštas | Balta
1905057 | 2 aukštas | Balta
1905123 | 2 aukštas | Balta
1905221 | 2 aukštas | Balta
1905315 | 2 aukštas | Balta
1905453 | 2 aukštas | Balta
1905624 | 2 aukštas | Balta
1905668 | 2 aukštas | Balta
1905791 | 2 aukštas | Balta
1905937 | 2 aukštas | Balta
1906059 | 2 aukštas | Balta
1906614 | 3 aukštas | Balta
1906662 | 3 aukštas | Balta
1906792 | 3 aukštas | Balta
1906990 | 3 aukštas | Balta
1907080 | 3 aukštas | Balta
1907203 | 3 aukštas | Balta
1907452 | 4 aukštas | Balta
1907500 | 4 aukštas | Balta
1907533 | 4 aukštas | Balta
1907566 | 4 aukštas | Balta
1907680 | 4 aukštas | Balta
1907724 | 4 aukštas | Balta
1907785 | 4 aukštas | Balta
1907854 | 4 aukštas | Balta
1907915 | 4 aukštas | Balta
1907976 | 4 aukštas | Balta
1907998 | 5 aukštas | Balta
1965204 | 5 aukštas | Balta
1965205 | 5 aukštas | Balta
1973174 | 2 aukštas | Balta
1973202 | 2 aukštas | Balta
1973322 | 2 aukštas | Balta
1973434 | 2 aukštas | Balta
1973536 | 2 aukštas | Balta
1973638 | 2 aukštas | Balta
1973934 | 2 aukštas | Balta
1974024 | 2 aukštas | Balta
1974250 | 2 aukštas | Balta
1974336 | 2 aukštas | Balta
1974432 | 2 aukštas | Balta
1974550 | 2 aukštas | Balta
1974614 | 2 aukštas | Balta
1974864 | 2 aukštas | Balta
1975000 | 2 aukštas | Balta
1975232 | 2 aukštas | Balta
1975338 | 2 aukštas | Balta
1975582 | 2 aukštas | Balta
1975640 | 2 aukštas | Balta
1975712 | 2 aukštas | Balta
1975842 | 2 aukštas | Balta
1975950 | 2 aukštas | Balta
1976052 | 2 aukštas | Balta
1976124 | 2 aukštas | Balta
1976240 | 2 aukštas | Balta
1976324 | 2 aukštas | Balta
1976858 | 2 aukštas | Balta
1977108 | 2 aukštas | Balta
1977508 | 2 aukštas | Balta
1977556 | 2 aukštas | Balta
1977620 | 2 aukštas | Balta

# IfcFlowTerminal: ER_Potinkiniai lizdai:1xRJ45 (WiFi) (60)
Type - Material: Balta (2)
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 1xRJ45 (WiFi); sets with these values: 2
Name (ER_Potinkiniai lizdai:1xRJ45 (WiFi):...) | In | Material
1495979 | Rūsys
1508085 | Rūsys | Balta
1508145 | Rūsys | Balta
1508348 | Rūsys | Balta
1508810 | Rūsys | Balta
1508944 | Rūsys | Balta
1508978 | Rūsys | Balta
1509068 | Rūsys | Balta
1509105 | Rūsys | Balta
1509117 | 1 aukštas | Balta
1509212 | 1 aukštas | Balta
1509228 | 1 aukštas | Balta
1509253 | 1 aukštas | Balta
1509281 | 1 aukštas | Balta
1509592 | 1 aukštas | Balta
1509616 | 1 aukštas | Balta
1509661 | 1 aukštas | Balta
1509722 | 1 aukštas | Balta
1509745 | 2 aukštas | Balta
1509789 | 2 aukštas | Balta
1509876 | 2 aukštas | Balta
1509918 | 2 aukštas | Balta
1509958 | 2 aukštas | Balta
1509978 | 2 aukštas | Balta
1510001 | 2 aukštas | Balta
1510045 | 2 aukštas | Balta
1510075 | 2 aukštas | Balta
1510092 | 2 aukštas | Balta
1510112 | 2 aukštas | Balta
1510270 | 2 aukštas | Balta
1510320 | 2 aukštas | Balta
1510357 | 2 aukštas | Balta
1510374 | 2 aukštas | Balta
1510399 | 3 aukštas | Balta
1510456 | 3 aukštas | Balta
1510497 | 3 aukštas | Balta
1510513 | 3 aukštas | Balta
1510536 | 3 aukštas | Balta
1510551 | 3 aukštas | Balta
1510577 | 3 aukštas | Balta
1510638 | 3 aukštas | Balta
1510655 | 3 aukštas | Balta
1510718 | 3 aukštas | Balta
1510763 | 4 aukštas | Balta
1510820 | 4 aukštas | Balta
1510843 | 4 aukštas | Balta
1510904 | 4 aukštas | Balta
1510923 | 4 aukštas | Balta
1510945 | 4 aukštas | Balta
1511123 | 4 aukštas | Balta
1511146 | 4 aukštas | Balta
1511221 | 4 aukštas | Balta
1511256 | 4 aukštas | Balta
1511276 | 4 aukštas | Balta
1511294 | 4 aukštas | Balta
1511319 | 5 aukštas | Balta
1511368 | 5 aukštas | Balta
1511435 | 5 aukštas | Balta
1511452 | 5 aukštas | Balta
1511505 | 5 aukštas | Balta

# IfcFlowTerminal: ER_Potinkiniai lizdai:2xRJ45 (428)
Type - Material: Balta (3)
Type - Pset_ProductRequirements - Category: Data Devices
Pset_DistributionFlowElementCommon - Reference: 2xRJ45; sets with these values: 2
Name (ER_Potinkiniai lizdai:2xRJ45:...) | In | Material
1512466 | Rūsys
1513080 | Rūsys | Balta
1513188 | 1 aukštas | Balta
1513442 | 1 aukštas | Balta
1515670 | 1 aukštas | Balta
1515844 | 1 aukštas | Balta
1515965 | 1 aukštas | Balta
1516092 | 1 aukštas | Balta
1516429 | 1 aukštas | Balta
1516506 | 1 aukštas | Balta
1516593 | 1 aukštas | Balta
1516792 | 1 aukštas | Balta
1516906 | 1 aukštas | Balta
1516945 | 1 aukštas | Balta
1517013 | 1 aukštas | Balta
1517072 | 1 aukštas | Balta
1517112 | 1 aukštas | Balta
1517138 | 1 aukštas | Balta
1517186 | 1 aukštas | Balta
1517833 | 1 aukštas | Balta
1517836 | 2 aukštas | Balta
1518021 | 2 aukštas | Balta
1518117 | 2 aukštas | Balta
1518297 | 2 aukštas | Balta
1518400 | 2 aukštas | Balta
1518633 | 2 aukštas | Balta
1518760 | 2 aukštas | Balta
1518858 | 2 aukštas | Balta
1519065 | 2 aukštas | Balta
1519136 | 2 aukštas | Balta
1519226 | 2 aukštas | Balta
1519307 | 2 aukštas | Balta
1519308 | 2 aukštas | Balta
1519461 | 2 aukštas | Balta
1519462 | 2 aukštas | Balta
1519574 | 2 aukštas | Balta
1519635 | 2 aukštas | Balta
1519677 | 2 aukštas | Balta
1519729 | 2 aukštas | Balta
1519793 | 2 aukštas | Balta
1519870 | 2 aukštas | Balta
1519959 | 2 aukštas | Balta
1519967 | 2 aukštas | Balta
1519975 | 2 aukštas | Balta
1520166 | 2 aukštas | Balta
1520167 | 2 aukštas | Balta
1520168 | 2 aukštas | Balta
1520191 | 2 aukštas | Balta
1520192 | 2 aukštas | Balta
1520193 | 2 aukštas | Balta
1520215 | 2 aukštas | Balta
1520216 | 2 aukštas | Balta
1520217 | 2 aukštas | Balta
1520238 | 2 aukštas | Balta
1520239 | 2 aukštas | Balta
1520240 | 2 aukštas | Balta
1520255 | 2 aukštas | Balta
1520256 | 2 aukštas | Balta
1520257 | 2 aukštas | Balta
1520696 | 2 aukštas | Balta
1520851 | 2 aukštas | Balta
1520859 | 2 aukštas | Balta
1520871 | 2 aukštas | Balta
1520954 | 2 aukštas | Balta
1520999 | 2 aukštas | Balta
1521165 | 2 aukštas | Balta
1521330 | 2 aukštas | Balta
1521426 | 2 aukštas | Balta
1521510 | 2 aukštas | Balta
1521622 | 2 aukštas | Balta
1521678 | 2 aukštas | Balta
1521775 | 2 aukštas | Balta
1521867 | 2 aukštas | Balta
1521971 | 2 aukštas | Balta
1522109 | 2 aukštas | Balta
1522261 | 2 aukštas | Balta
1522351 | 2 aukštas | Balta
1522487 | 2 aukštas | Balta
1522679 | 2 aukštas | Balta
1522764 | 2 aukštas | Balta
1522964 | 2 aukštas | Balta
1523189 | 2 aukštas | Balta
1523298 | 2 aukštas | Balta
1523388 | 2 aukštas | Balta
1523485 | 2 aukštas | Balta
1523744 | 3 aukštas | Balta
1523754 | 3 aukštas | Balta
1523802 | 3 aukštas | Balta
1523984 | 2 aukštas | Balta
1524244 | 2 aukštas | Balta
1524630 | 2 aukštas | Balta
1524776 | 3 aukštas | Balta
1524785 | 3 aukštas | Balta
1525304 | 3 aukštas | Balta
1525370 | 3 aukštas | Balta
1525484 | 3 aukštas | Balta
1525503 | 3 aukštas | Balta
1525544 | 3 aukštas | Balta
1525749 | 3 aukštas | Balta
1525798 | 3 aukštas | Balta
1525972 | 3 aukštas | Balta
1526052 | 3 aukštas | Balta
1526299 | 3 aukštas | Balta
1526300 | 3 aukštas | Balta
1526387 | 3 aukštas | Balta
1526518 | 3 aukštas | Balta
1526555 | 3 aukštas | Balta
1526673 | 3 aukštas | Balta
1526825 | 3 aukštas | Balta
1526833 | 3 aukštas | Balta
1526907 | 3 aukštas | Balta
1527078 | 3 aukštas | Balta
1527147 | 3 aukštas | Balta
1527268 | 3 aukštas | Balta
1527327 | 3 aukštas | Balta
1527375 | 3 aukštas | Balta
1527603 | 3 aukštas | Balta
1527723 | 3 aukštas | Balta
1527756 | 3 aukštas | Balta
1527880 | 3 aukštas | Balta
1528009 | 3 aukštas | Balta
1528120 | 3 aukštas | Balta
1528321 | 3 aukštas | Balta
1528337 | 3 aukštas | Balta
1528505 | 4 aukštas | Balta
1528592 | 4 aukštas | Balta
1528696 | 4 aukštas | Balta
1528697 | 4 aukštas | Balta
1528871 | 4 aukštas | Balta
1528939 | 4 aukštas | Balta
1529086 | 4 aukštas | Balta
1529145 | 4 aukštas | Balta
1529232 | 4 aukštas | Balta
1529284 | 4 aukštas | Balta
1529494 | 4 aukštas | Balta
1529513 | 4 aukštas | Balta
1529531 | 4 aukštas | Balta
1529576 | 4 aukštas | Balta
1529626 | 4 aukštas | Balta
1529823 | 4 aukštas | Balta
1529918 | 4 aukštas | Balta
1530041 | 4 aukštas | Balta
1530132 | 4 aukštas | Balta
1530202 | 4 aukštas | Balta
1530281 | 4 aukštas | Balta
1530341 | 4 aukštas | Balta
1530440 | 4 aukštas | Balta
1530545 | 4 aukštas | Balta
1530690 | 4 aukštas | Balta
1530748 | 4 aukštas | Balta
1530787 | 4 aukštas | Balta
1530881 | 5 aukštas | Balta
1530948 | 5 aukštas | Balta
1531055 | 5 aukštas | Balta
1531104 | 5 aukštas | Balta
1531214 | 5 aukštas | Balta
1531318 | 5 aukštas | Balta
1531391 | 5 aukštas | Balta
1531413 | 5 aukštas | Balta
1531485 | 5 aukštas | Balta
1531544 | 5 aukštas | Balta
1531650 | 5 aukštas | Balta
1531784 | 5 aukštas | Balta
1531947 | 5 aukštas | Balta
1532089 | 5 aukštas | Balta
1532166 | 5 aukštas | Balta
1532182 | 5 aukštas | Balta
1532227 | 5 aukštas | Balta
1532248 | 5 aukštas | Balta
1532276 | 5 aukštas | Balta
1532293 | 5 aukštas | Balta
1532320 | 5 aukštas | Balta
1532352 | 5 aukštas | Balta
1532372 | 5 aukštas | Balta
1532409 | 5 aukštas | Balta
1785752 | 5 aukštas | Balta
1785753 | 5 aukštas | Balta
1792541 | 5 aukštas | Balta
1792646 | 5 aukštas | Balta
1792767 | 5 aukštas | Balta
1792809 | 5 aukštas | Balta
1792870 | 5 aukštas | Balta
1792953 | 5 aukštas | Balta
1793004 | 5 aukštas | Balta
1793073 | 5 aukštas | Balta
1793158 | 5 aukštas | Balta
1793238 | 5 aukštas | Balta
1794088 | 5 aukštas | Balta
1794806 | 5 aukštas | Balta
1795276 | 5 aukštas | Balta
1795311 | 5 aukštas | Balta
1795384 | 5 aukštas | Balta
1795475 | 5 aukštas | Balta
1798961 | 5 aukštas | Balta
1799054 | 5 aukštas | Balta
1799098 | 5 aukštas | Balta
1799099 | 5 aukštas | Balta
1799128 | 5 aukštas | Balta
1799129 | 5 aukštas | Balta
1799213 | 5 aukštas | Balta
1799250 | 5 aukštas | Balta
1808513 | 5 aukštas | Balta
1808514 | 5 aukštas | Balta
1808515 | 5 aukštas | Balta
1808516 | 5 aukštas | Balta
1810985 | 5 aukštas | Balta
1810987 | 5 aukštas | Balta
1810988 | 5 aukštas | Balta
1810990 | 5 aukštas | Balta
1811009 | 4 aukštas | Balta
1811010 | 4 aukštas | Balta
1811011 | 4 aukštas | Balta
1811012 | 4 aukštas | Balta
1811013 | 4 aukštas | Balta
1811014 | 4 aukštas | Balta
1811015 | 4 aukštas | Balta
1811016 | 4 aukštas | Balta
1811017 | 4 aukštas | Balta
1811020 | 4 aukštas | Balta
1811021 | 4 aukštas | Balta
1811022 | 4 aukštas | Balta
1811023 | 4 aukštas | Balta
1811024 | 4 aukštas | Balta
1811025 | 4 aukštas | Balta
1811026 | 4 aukštas | Balta
1811027 | 4 aukštas | Balta
1811028 | 4 aukštas | Balta
1811029 | 4 aukštas | Balta
1811030 | 4 aukštas | Balta
1811031 | 4 aukštas | Balta
1811033 | 4 aukštas | Balta
1811062 | 4 aukštas | Balta
1811063 | 4 aukštas | Balta
1811064 | 4 aukštas | Balta
1811070 | 4 aukštas | Balta
1811071 | 4 aukštas | Balta
1811074 | 4 aukštas | Balta
1811075 | 4 aukštas | Balta
1811237 | 4 aukštas | Balta
1811279 | 4 aukštas | Balta
1811348 | 4 aukštas | Balta
1811390 | 4 aukštas | Balta
1811432 | 4 aukštas | Balta
1811474 | 4 aukštas | Balta
1811534 | 4 aukštas | Balta
1811584 | 4 aukštas | Balta
1811653 | 4 aukštas | Balta
1811775 | 4 aukštas | Balta
1812197 | 4 aukštas | Balta
1812288 | 4 aukštas | Balta
1812653 | 4 aukštas | Balta
1812704 | 4 aukštas | Balta
1812791 | 4 aukštas | Balta
1812842 | 4 aukštas | Balta
1812893 | 4 aukštas | Balta
1813001 | 4 aukštas | Balta
1813070 | 4 aukštas | Balta
1813139 | 4 aukštas | Balta
1813208 | 4 aukštas | Balta
1813277 | 4 aukštas | Balta
1813346 | 4 aukštas | Balta
1813418 | 4 aukštas | Balta
1855747 | 3 aukštas | Balta
1855748 | 3 aukštas | Balta
1855749 | 3 aukštas | Balta
1855750 | 3 aukštas | Balta
1855751 | 3 aukštas | Balta
1855752 | 3 aukštas | Balta
1855753 | 3 aukštas | Balta
1855754 | 3 aukštas | Balta
1855755 | 3 aukštas | Balta
1855756 | 3 aukštas | Balta
1855771 | 3 aukštas | Balta
1855772 | 3 aukštas | Balta
1855790 | 3 aukštas | Balta
1855791 | 3 aukštas | Balta
1855793 | 3 aukštas | Balta
1855794 | 3 aukštas | Balta
1855795 | 3 aukštas | Balta
1855796 | 3 aukštas | Balta
1855798 | 3 aukštas | Balta
1855799 | 3 aukštas | Balta
1855800 | 3 aukštas | Balta
1855801 | 3 aukštas | Balta
1855802 | 3 aukštas | Balta
1855803 | 3 aukštas | Balta
1855804 | 3 aukštas | Balta
1855805 | 3 aukštas | Balta
1855806 | 3 aukštas | Balta
1855807 | 3 aukštas | Balta
1855808 | 3 aukštas | Balta
1855809 | 3 aukštas | Balta
1855810 | 3 aukštas | Balta
1855811 | 3 aukštas | Balta
1855812 | 3 aukštas | Balta
1855813 | 3 aukštas | Balta
1855814 | 3 aukštas | Balta
1855815 | 3 aukštas | Balta
1855816 | 3 aukštas | Balta
1855818 | 3 aukštas | Balta
1855820 | 3 aukštas | Balta
1855821 | 3 aukštas | Balta
1855822 | 3 aukštas | Balta
1855823 | 3 aukštas | Balta
1855824 | 3 aukštas | Balta
1855825 | 3 aukštas | Balta
1855826 | 3 aukštas | Balta
1855827 | 3 aukštas | Balta
1855828 | 3 aukštas | Balta
1855829 | 3 aukštas | Balta
1855830 | 3 aukštas | Balta
1855832 | 3 aukštas | Balta
1855833 | 3 aukštas | Balta
1855834 | 3 aukštas | Balta
1855835 | 3 aukštas | Balta
1855836 | 3 aukštas | Balta
1855837 | 3 aukštas | Balta
1855838 | 3 aukštas | Balta
1855839 | 3 aukštas | Balta
1855840 | 3 aukštas | Balta
1855841 | 2 aukštas | Balta
1855842 | 2 aukštas | Balta
1855843 | 2 aukštas | Balta
1855844 | 2 aukštas | Balta
1855845 | 2 aukštas | Balta
1855846 | 2 aukštas | Balta
1855847 | 2 aukštas | Balta
1855848 | 2 aukštas | Balta
1855849 | 2 aukštas | Balta
1855851 | 2 aukštas | Balta
1855876 | 2 aukštas | Balta
1855877 | 2 aukštas | Balta
1855878 | 2 aukštas | Balta
1855879 | 2 aukštas | Balta
1855880 | 2 aukštas | Balta
1855881 | 2 aukštas | Balta
1855882 | 2 aukštas | Balta
1855883 | 2 aukštas | Balta
1855884 | 2 aukštas | Balta
1855885 | 2 aukštas | Balta
1855886 | 2 aukštas | Balta
1855887 | 2 aukštas | Balta
1855888 | 2 aukštas | Balta
1855889 | 2 aukštas | Balta
1855890 | 2 aukštas | Balta
1855891 | 2 aukštas | Balta
1855892 | 2 aukštas | Balta
1855893 | 2 aukštas | Balta
1855894 | 2 aukštas | Balta
1855895 | 2 aukštas | Balta
1855896 | 2 aukštas | Balta
1855897 | 2 aukštas | Balta
1855898 | 2 aukštas | Balta
1855899 | 2 aukštas | Balta
1858884 | 2 aukštas | Balta
1858885 | 2 aukštas | Balta
1858886 | 2 aukštas | Balta
1858887 | 2 aukštas | Balta
1858888 | 2 aukštas | Balta
1858889 | 2 aukštas | Balta
1858890 | 2 aukštas | Balta
1858891 | 2 aukštas | Balta
1858892 | 2 aukštas | Balta
1858893 | 2 aukštas | Balta
1858894 | 2 aukštas | Balta
1858895 | 2 aukštas | Balta
1858896 | 2 aukštas | Balta
1858897 | 2 aukštas | Balta
1858898 | 2 aukštas | Balta
1858899 | 2 aukštas | Balta
1858900 | 2 aukštas | Balta
1858901 | 2 aukštas | Balta
1858902 | 2 aukštas | Balta
1858903 | 2 aukštas | Balta
1858925 | 2 aukštas | Balta
1858931 | 2 aukštas | Balta
1858932 | 2 aukštas | Balta
1858933 | 2 aukštas | Balta
1858934 | 2 aukštas | Balta
1858939 | 2 aukštas | Balta
1858991 | 2 aukštas | Balta
1859059 | 2 aukštas | Balta
1859147 | 2 aukštas | Balta
1859219 | 2 aukštas | Balta
1859523 | 2 aukštas | Balta
1859531 | 2 aukštas | Balta
1859539 | 2 aukštas | Balta
1859582 | 2 aukštas | Balta
1859643 | 2 aukštas | Balta
1859653 | 2 aukštas | Balta
1859661 | 2 aukštas | Balta
1859958 | 2 aukštas | Balta
1860888 | 2 aukštas | Balta
1860957 | 2 aukštas | Balta
1861102 | 2 aukštas | Balta
1861164 | 2 aukštas | Balta
1861346 | 2 aukštas | Balta
1861522 | 2 aukštas | Balta
1861802 | 2 aukštas | Balta
1861870 | 2 aukštas | Balta
1861995 | 2 aukštas | Balta
1862617 | 2 aukštas | Balta
1862901 | 2 aukštas | Balta
1863020 | 2 aukštas | Balta
1863082 | 2 aukštas | Balta
1863178 | 2 aukštas | Balta
1863480 | 2 aukštas | Balta
1863823 | 2 aukštas | Balta
1864202 | 2 aukštas | Balta
1864520 | 2 aukštas | Balta
1864712 | 2 aukštas | Balta
1864811 | 2 aukštas | Balta
1865054 | 2 aukštas | Balta
1865195 | 2 aukštas | Balta
1865305 | 2 aukštas | Balta
1865368 | 2 aukštas | Balta
1865396 | 2 aukštas | Balta
1866584 | 2 aukštas | Balta
1866922 | 1 aukštas | Balta
1867065 | 1 aukštas | Balta
1867781 | 1 aukštas | Balta
1867869 | 1 aukštas | Balta
1868715 | 1 aukštas | Balta
1869447 | Rūsys | Balta
1869618 | Rūsys | Balta
1869664 | Rūsys | Balta
1869766 | Rūsys | Balta
1869801 | Rūsys | Balta
